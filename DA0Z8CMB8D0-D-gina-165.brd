# Allegro board DA0Z8CMB8D0-D-gina-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MDI1-: length 137.8
  TOP w0.102: R29.2 150.36,156.85
  TOP w0.127: 150.36,156.85 150.44,156.94 150.79,156.94 150.83,156.97 U8.8 U8.1 153.08,156.97 153.12,157.01 153.42,157.01 154.14,156.3 154.14,156.02 153.94,155.82 C49.2 153.86,155.34 153.86,154.64 154.06,154.44 154.06,154.05 v1(153.89,153.88) ; v1(217,91.88) 217.1,91.78 217.1,91.58 217.48,91.2 U24.5
  IN3 w0.076: v1(217,91.88) 217.13,92.01 217.13,92.28 216.84,92.57 204.52,92.57 204.01,93.07 202.02,93.07 201.64,93.46 194.09,93.46 193.81,93.18 191.35,93.18 190.78,92.61 186.45,92.61 181.7,97.36 181.7,98.08 182.45,98.83 182.45,99.18 182.2,99.42 181.86,99.42 181.04,98.61 180.45,98.61 180.03,99.02 180.03,99.61 180.79,100.37 180.79,100.71 180.54,100.96 180.19,100.96 179.44,100.21 178.85,100.21 178.43,100.62 178.43,101.21 179.25,102.03 179.25,102.38 179.01,102.62 178.66,102.62 177.87,101.84 177.22,101.84 175.35,103.71 175.35,104.63 175.85,105.14 177.64,105.14 177.89,105.39 177.89,105.74 177.64,105.99 173.83,105.99 173.4,106.42 173.4,107.13 173.83,107.55 176.36,107.55 176.62,107.81 176.62,108.28 176.36,108.53 173.95,108.53 173.53,108.96 173.53,109.67 173.95,110.09 174.96,110.09 175.22,110.35 175.22,110.73 174.96,110.98 174.04,110.98 173.53,111.5 173.53,115.03 173.12,115.43 173.12,116.01 160.96,128.18 160.96,129.05 159.33,130.67 159.33,131.95 157.02,134.26 157.02,137.06 155.29,138.78 155.29,152.34 154.36,153.27 154.36,153.73 154.21,153.88 v1(153.89,153.88)
MDI2+: length 137.5
  TOP w0.127: v1(149.31,167.24) 149.45,167.1 U1.1 U1.8 151.63,167.1 v1(151.77,167.24) ; U24.6 216.98,89.83 v1(216.8,89.65)
  IN3 w0.076: v1(149.31,167.24) 149.48,167.07 150.11,167.07 150.68,166.51 150.68,163.24 150.99,162.92 151.73,162.92 152.14,162.52 152.14,161.94 151.73,161.53 150.87,161.53 150.68,161.34 150.68,155.71 151.01,155.38 151.01,153.88 151.91,152.98 152.57,152.98 153.81,151.75 153.81,138.11 155.41,136.51 155.41,132.48 159.17,128.72 159.17,127.85 170.71,116.3 170.71,106.24 185.84,91.12 193.85,91.12 194.71,91.97 197.31,91.97 199.13,90.15 214.09,90.15 214.39,90.46 216.47,90.46 216.79,90.15 216.79,89.66 v1(216.8,89.65)
  BOTTOM w0.127: C521.2 148.18,166.65 148.29,166.53 148.6,166.53 v1(149.31,167.24) ; R434.2 151.08,164.09 151.72,164.09 151.85,164.21 151.85,164.73 150.78,165.79 150.78,166.66 151.16,167.04 151.57,167.04 v1(151.77,167.24)
MDI2-: length 137.5
  TOP w0.127: v1(149.31,166.6) U1.2 U1.7 v1(151.77,166.6) ; U24.7 216.48,90.09 v1(216.04,89.65)
  IN3 w0.076: v1(149.31,166.6) 149.49,166.78 149.99,166.78 150.39,166.39 150.39,163.12 150.87,162.63 151.61,162.63 151.85,162.39 151.85,162.06 151.61,161.82 150.75,161.82 150.39,161.46 150.39,155.59 150.72,155.26 150.72,153.76 151.79,152.69 152.45,152.69 153.51,151.63 153.51,137.99 155.11,136.39 155.11,132.36 158.87,128.6 158.87,127.73 170.42,116.18 170.42,106.12 185.71,90.83 193.98,90.83 194.83,91.68 197.19,91.68 199.01,89.86 214.21,89.86 214.51,90.17 216.35,90.17 216.49,90.03 216.49,89.9 216.24,89.65 v1(216.04,89.65)
  BOTTOM w0.127: R438.2 151.08,163.29 151.83,163.29 152.28,163.74 152.28,164.91 151.22,165.97 151.22,166.48 151.34,166.6 v1(151.77,166.6) ; v1(149.31,166.6) 149.28,166.6 148.78,166.1 148.32,166.1 148.18,165.96 C522.2
MDI3+: length 137.3
  TOP w0.127: U24.9 215.48,91.78 v1(215.38,91.88) ; U8.5 U8.4 153.49,158.47 153.78,158.76 154.21,158.76 v1(154.26,158.81)
  IN3 w0.076: v1(215.38,91.88) 215.25,91.75 215.25,91.57 215.24,91.57 215.24,91.41 214.95,91.12 201.89,91.12 201.47,91.54 201.47,92.35 201.26,92.57 200.96,92.57 200.75,92.35 200.75,91.17 200.32,90.75 199.73,90.75 199.31,91.17 199.31,92.45 199.19,92.57 194.46,92.57 193.61,91.72 186.1,91.72 174.37,103.44 174.37,104.82 174.26,104.92 172.89,104.92 172.23,105.58 172.23,106.44 172,106.67 171.71,106.67 171.29,107.09 171.29,107.68 171.71,108.1 172.43,108.1 172.67,108.34 172.67,108.69 172.43,108.93 171.71,108.93 171.29,109.35 171.29,109.94 171.71,110.36 172.59,110.36 172.84,110.6 172.84,110.95 172.59,111.2 171.71,111.2 171.29,111.61 171.29,112.2 171.71,112.62 172.41,112.62 172.65,112.86 172.65,113.21 172.41,113.46 171.71,113.46 171.29,113.87 171.29,114.46 171.71,114.88 172,114.88 172.23,115.12 172.23,115.61 160,127.84 160,128.73 158.37,130.37 158.37,131.61 156.13,133.85 156.13,136.64 154.4,138.37 154.4,151.98 152.77,153.62 152.21,153.62 151.6,154.23 151.6,155.3 152.02,155.72 152.99,155.72 153.25,155.98 153.25,156.45 152.99,156.7 151.98,156.7 151.56,157.13 151.56,158.22 151.98,158.65 154.1,158.65 v1(154.26,158.81)
  BOTTOM w0.127: R460.2 150.44,157.74 151.61,157.74 C552.2 152.65,157.92 153.37,157.92 v1(154.26,158.81)
MDI3-: length 137.3
  TOP w0.127: v1(154.26,158.07) 154.26,158.2 154.14,158.33 153.96,158.33 153.6,157.97 U8.3 U8.6 ; v1(214.77,91.88) 214.98,91.67 U24.10
  IN3 w0.076: v1(214.77,91.88) 214.95,91.69 214.95,91.53 214.83,91.41 202.02,91.41 201.76,91.67 201.76,92.48 201.38,92.86 200.84,92.86 200.45,92.48 200.45,91.29 200.2,91.04 199.85,91.04 199.6,91.29 199.6,92.57 199.31,92.86 194.34,92.86 193.49,92.01 186.22,92.01 174.66,103.57 174.66,104.94 174.38,105.22 173.01,105.22 172.53,105.7 172.53,106.56 172.12,106.97 171.83,106.97 171.59,107.21 171.59,107.56 171.83,107.8 172.55,107.8 172.96,108.22 172.96,108.81 172.55,109.23 171.83,109.23 171.59,109.47 171.59,109.82 171.83,110.06 172.71,110.06 173.13,110.48 173.13,111.07 172.71,111.49 171.83,111.49 171.59,111.73 171.59,112.08 171.83,112.33 172.53,112.33 172.94,112.74 172.94,113.33 172.53,113.75 171.83,113.75 171.59,113.99 171.59,114.34 171.83,114.59 172.12,114.59 172.53,115 172.53,115.73 160.3,127.96 160.3,128.85 158.66,130.49 158.66,131.73 156.42,133.97 156.42,136.76 154.69,138.49 154.69,152.1 152.89,153.91 152.33,153.91 151.89,154.35 151.89,155.18 152.14,155.43 153.11,155.43 153.54,155.86 153.54,156.57 153.11,156.99 152.1,156.99 151.85,157.25 151.85,158.1 152.1,158.35 153.76,158.35 153.86,158.25 153.86,157.71 153.95,157.62 154.17,157.62 154.26,157.71 v1(154.26,158.07)
  BOTTOM w0.127: R464.2 150.86,157.36 151.7,157.36 152.1,156.96 C566.2 152.22,157.38 152.33,157.49 153.55,157.49 154.14,158.07 v1(154.26,158.07)
ME_WR#: length 104.3
  TOP w0.14: U32.106 150.64,68.55 150.22,68.97 v1(150,68.97)
  IN2 w0.114: v1(133.1,58.21) 133.44,57.88 133.44,56.12 133.85,55.71 136.97,55.71 137.47,55.2 138.41,55.2 139.4,56.19 139.4,62.47 141.31,64.37 141.31,65.39 143.21,67.29 146.03,67.29 147.43,65.9 148.45,65.9 148.75,66.2 148.75,67.73 v1(150,68.97)
  IN3 w0.089: v1(142.88,100.97) 143.29,100.97 143.94,100.33 144.35,100.33 145.7,98.97 145.7,98.55 146.11,98.14 146.94,98.14 148.86,96.23 148.86,95.43 150.56,93.73 151.81,93.73 153.09,92.44 154.23,92.44 156.52,90.15 156.52,88.48 158.97,86.03 158.97,82.66 159.22,82.42 159.22,79.92 159.56,79.58 159.56,78.27 157.25,75.96 156.65,75.96 155.77,75.08 154,75.08 153.46,75.61 147.28,75.61 146.52,74.85 146.52,74.02 145.34,72.85 145.34,71.33 143.21,69.2 141.56,69.2 139.38,67.01 139.38,63.6 134.95,59.17 134.05,59.17 v1(133.1,58.21)
  BOTTOM w0.14: R658.2 142.88,101.65 v1(142.88,100.97)
MIC2-L: length 11.3
  TOP w0.203: 234.21,36.07 234.18,36.09 U34.17
  TOP w0.381: C510.2 240.09,31.1 v1(237.07,31.1) 235.74,31.1 234.48,32.36 234.48,35.8 234.21,36.07
MIC2-R: length 12.1
  TOP w0.203: 234.91,36.13 234.58,36.46 U34.18
  TOP w0.381: C511.2 241.64,31.35 241.13,31.86 v1(238.59,31.86) 236.05,31.86 235.24,32.67 235.24,35.8 234.91,36.13
MIC2-VREFO: length 13.8
  TOP w0.203: v1(239.56,39.1) 239.18,39.1 238.76,39.52 U34.29
  TOP w0.381: R421.1 v1(241.25,28.58)
  IN1 w0.381: v1(241.25,28.58) 240.88,28.95 240.88,29.96 240.12,30.72 240.12,38.21 239.56,38.77 v1(239.56,39.1)
MIC2_MIC: length 3.7
  TOP w0.381: R420.1 240.37,28.44 C510.1 C511.1 v1(242.63,29.35)
MODPHY_EN: length 3.5
  TOP w0.102: v1(146.47,119.9) 146.11,120.25
  TOP w0.14: TP43.1 145.99,120.38 146.11,120.25
  BOTTOM w0.076: v1(146.47,119.9) 146.18,119.9 145.55,119.27 145.08,119.27 144.96,119.4 144.47,119.4 U45.Y2
MX0: length 106.9
  TOP w0.14: U32.58 151.84,51.05 v1(153.37,49.51) ; RP1.4 64.02,49.39 64.19,49.56 v1(64.47,49.56) 64.52,49.51 64.97,49.51 C476.2
  IN1 w0.114: v1(65.34,46.29) 65.45,46.18 67.43,46.18 68.49,45.11 90.4,45.11 91.23,45.95 101.62,45.95 102.68,44.88 105.43,44.88 106.22,44.1 119.93,44.1 120.75,44.92 123.44,44.92 123.94,45.42 129.82,45.42 131.31,46.91 150.77,46.91 v1(153.37,49.51)
  BOTTOM w0.14: CN15.1 59.65,49.26 60.03,49.64 64.4,49.64 v1(64.47,49.56) 64.89,49.56 65.78,48.68 65.78,46.73 v1(65.34,46.29)
MX1: length 111.1
  TOP w0.14: U32.59 152.24,51.03 153.25,50.02 153.48,50.02 v1(154.01,49.49) ; RP1.3 64.12,48.75 64.63,48.24 C481.2 65.1,47.83 v1(64.65,47.38) 64.65,47 64.12,46.47 v1(64.12,46.29)
  IN1 w0.114: v1(154.01,49.49) 154.01,49.39 151.28,46.65 131.36,46.65 129.91,45.21 124.03,45.21 123.39,44.57 120.7,44.57 120.02,43.88 118.89,43.88 118.14,43.13 114.87,43.13 114.12,43.88 103.38,43.88 101.53,45.73 91.32,45.73 90.49,44.9 68.4,44.9 67.34,45.96 66.58,45.96 66.33,45.7 64.7,45.7 v1(64.12,46.29)
  BOTTOM w0.14: CN15.2 58.28,48.98 58.72,48.54 59.4,48.54 60.25,49.39 61.68,49.39 63.08,47.99 63.08,47.2 63.48,46.8 63.79,46.8 64.12,46.47 v1(64.12,46.29)
MX2: length 121.3
  TOP w0.14: U32.60 152.64,52.92 152.31,53.25 v1(152.02,53.25) ; v1(62.9,46.43) 63.44,46.97 63.84,46.97 64.09,47.23 64.09,47.99 63.97,48.12 RP1.2 ; v1(52.92,47.81) 53.24,47.48 53.55,47.48 53.91,47.13 CP4.4
  IN1 w0.114: v1(52.92,47.81) 53.75,46.97 55.46,46.97 56.35,47.86 57.12,47.86 57.5,48.24 58.59,48.24 v1(58.76,48.07) 58.97,48.07 60.03,49.13 60.84,49.13 61.8,48.17 65.26,48.17 66.17,47.26 67.88,47.26 68.94,46.19 89.8,46.19 90.63,47.02 102.93,47.02 103.99,45.96 107.91,45.96 108.7,45.18 119.48,45.18 120.31,46 122.99,46 123.49,46.5 129.37,46.5 130.86,47.99 147.02,47.99 151.85,52.82 151.85,53.08 v1(152.02,53.25)
  BOTTOM w0.14: CN15.3 57.48,48.64 57.72,48.4 58.43,48.4 v1(58.76,48.07) 58.97,48.28 59.49,48.28 60.34,49.13 61.55,49.13 62.32,48.37 62.32,47.41 62.9,46.82 v1(62.9,46.43)
MX3: length 130.3
  TOP w0.14: U32.61 153.04,52.87 v1(151.98,53.93) ; RP1.1 62.57,47.48 62.19,47.1 61.93,47.1 61.68,46.85 61.68,46.31 62.16,45.83 63.02,45.83 v1(63.5,46.31) ; v1(52.28,47.74) 52.66,47.35 52.79,47.35 53.12,47.02 CP4.2
  IN1 w0.114: v1(52.28,47.74) 52.28,47.99 52.54,48.24 53.17,48.24 54.06,47.35 55.2,47.35 55.36,47.52 55.36,48.27 55.72,48.62 56.64,48.62 v1(56.96,48.31) 58.27,49.62 60.67,49.62 61.89,48.39 65.35,48.39 66.26,47.48 67.97,47.48 69.03,46.41 89.71,46.41 90.54,47.24 103.02,47.24 104.08,46.18 108,46.18 108.79,45.39 119.39,45.39 120.22,46.22 122.9,46.22 123.4,46.72 129.28,46.72 131.61,49.04 147.57,49.04 151.34,52.82 151.34,53.31 151.96,53.93 v1(151.98,53.93)
  BOTTOM w0.14: v1(56.96,48.31) 56.96,48.65 56.68,48.93 CN15.4 ; v1(52.28,47.74) 53.17,46.85 54.31,46.85 54.94,46.22 59.24,46.22 59.7,46.69 61.31,46.69 62.16,45.83 63.02,45.83 v1(63.5,46.31)
MX4: length 111.7
  TOP w0.14: U32.62 153.44,50.56 v1(153.41,50.53) ; RP1.6 59.01,50.02 58.1,49.11 58.1,47.91 v1(58.2,47.81) 58.52,47.48 58.76,47.48 59.19,47.05 CP5.8
  IN1 w0.114: v1(58.2,47.81) 58.55,47.45 60.38,47.45 60.45,47.53 64.99,47.53 65.9,46.61 67.61,46.61 68.67,45.55 90.22,45.55 91.05,46.38 102.66,46.38 103.72,45.32 105.61,45.32 106.4,44.53 119.75,44.53 120.57,45.35 123.26,45.35 123.76,45.86 129.64,45.86 131.13,47.34 150.18,47.34 153.37,50.53 v1(153.41,50.53)
  BOTTOM w0.14: CN15.5 55.88,48.94 56.51,48.31 56.51,48.14 56.78,47.86 57.11,47.86 57.38,48.13 57.41,48.13 57.44,48.16 57.93,48.16 58.2,47.89 v1(58.2,47.81)
MX5: length 115.7
  TOP w0.14: RP1.7 60.74,49.39 60.51,49.62 59.62,49.62 v1(59.39,49.39) 59.21,49.2 59.21,47.79 59.21,47.79 59.21,47.62 59.36,47.48 59.47,47.48 59.59,47.35 59.59,46.17 59.47,46.04 58.68,46.04 58.4,46.31 CP5.6 58.4,47.08 58.1,47.38 57.97,47.38 57.62,47.74 v1(57.59,47.74) ; U32.63 153.84,50.83 v1(154.14,50.53)
  IN1 w0.114: v1(154.14,50.53) 153.56,49.96 153.18,49.96 150.35,47.12 131.22,47.12 129.73,45.64 123.85,45.64 123.35,45.14 120.66,45.14 119.84,44.31 106.31,44.31 105.52,45.1 103.63,45.1 102.57,46.16 91.14,46.16 90.31,45.33 68.58,45.33 67.52,46.4 65.81,46.4 64.9,47.31 60.62,47.31 60.54,47.23 58.1,47.23 v1(57.59,47.74)
  BOTTOM w0.14: CN15.6 55.08,49 55.58,48.5 55.81,48.5 55.82,48.48 55.99,48.48 56.27,48.2 56.27,48.03 56.82,47.48 57.34,47.48 v1(57.59,47.74)
MX6: length 115
  TOP w0.14: RP1.9 60.82,48.12 60.6,47.89 59.66,47.89 v1(59.64,47.87) ; CP5.4 57.59,47.13 57.11,47.61 56.85,47.61 56.5,47.96 56.5,48.43 56.05,48.89 55.72,48.89 v3(55.71,48.88) 55.71,48.14 v1(55.84,48.01) ; U32.64 154.24,51.06 v1(154.77,50.53)
  IN1 w0.114: v1(154.77,50.53) 154.26,51.04 153.32,51.04 149.84,47.55 131.04,47.55 129.55,46.07 123.67,46.07 123.17,45.57 120.48,45.57 119.66,44.75 106.49,44.75 105.7,45.53 103.81,45.53 102.75,46.59 90.88,46.59 90.05,45.76 68.76,45.76 67.7,46.83 65.99,46.83 65.08,47.74 59.76,47.74 v1(59.64,47.87)
  BOTTOM w0.14: v1(59.64,47.87) 58.64,46.87 56.99,46.87 v1(55.84,48.01) 55.69,48.01 55.2,48.5 54.57,48.5 54.28,48.79 CN15.7
MX7: length 113.3
  TOP w0.14: v1(60.52,48.69) 60.52,48.69 60.58,48.75 RP1.8 ; v1(153.42,53.91) 153.6,53.73 U32.65 ; CP5.2 56.21,46.76 v1(56.12,46.85)
  IN1 w0.114: v1(60.52,48.69) 61.25,47.96 65.17,47.96 66.08,47.04 67.79,47.04 68.85,45.98 89.93,45.98 90.76,46.81 102.84,46.81 103.9,45.75 107.82,45.75 108.61,44.96 119.57,44.96 120.39,45.79 123.08,45.79 123.58,46.29 129.46,46.29 130.95,47.77 147.57,47.77 153.42,53.63 v1(153.42,53.91)
  BOTTOM w0.14: v1(60.52,48.69) 60.52,48.69 60.11,48.28 60.11,47.69 59.84,47.42 59.58,47.42 58.63,46.47 56.5,46.47 v1(56.12,46.85) 55.37,47.59 55.37,47.96 55.12,48.22 55.12,48.24 55.12,48.24 54.06,48.24 53.48,48.82 CN15.8
MY0: length 122.2
  TOP w0.14: U32.36 143.04,52.84 142.58,53.3 v1(142.58,53.32) ; CP6.8 37.12,44.64 37.42,44.94 38.19,44.94 v1(38.31,45.07) 40.86,47.62 40.86,48.31 40.59,48.59 40.11,48.59 v1(39.8,48.27)
  IN3 w0.089: v1(142.58,53.32) 142.6,53.3 142.6,52.97 140.55,50.91 137.31,50.91 136.31,49.92 133.94,49.92 132.87,48.85 130.84,48.85 129.88,47.88 123.49,47.88 122.74,47.14 110.75,47.14 109.84,48.05 106.16,48.05 105.11,47 104.14,47 103.41,47.74 96.39,47.74 95.62,46.96 91.66,46.96 89.61,44.91 62.75,44.91 61.12,46.54 58.82,46.54 57.98,45.7 50.57,45.7 48.47,47.8 48.47,48.8 47.57,49.7 41.04,49.7 39.8,48.46 v1(39.8,48.27)
  BOTTOM w0.14: CN15.26 39.08,48.87 39.68,48.27 v1(39.8,48.27)
MY1: length 119.9
  TOP w0.14: CP6.6 38.03,45.42 v1(38.95,46.34) 40.39,47.78 v1(40.39,48.12) ; v1(143.19,53.3) 143.19,53.2 143.44,52.95 U32.37
  IN3 w0.089: v1(143.19,53.3) 143.19,53.27 143.21,53.25 143.19,53.22 143.19,53.04 140.86,50.72 137.39,50.72 136.39,49.73 134.03,49.73 132.96,48.66 130.92,48.66 129.7,47.44 123.31,47.44 122.82,46.95 110.67,46.95 109.76,47.86 106.24,47.86 105.19,46.81 104.06,46.81 103.33,47.55 96.47,47.55 95.7,46.77 91.74,46.77 89.69,44.72 62.67,44.72 61.04,46.35 58.9,46.35 58.06,45.51 50.36,45.51 48.28,47.59 48.28,48.7 47.47,49.51 41.23,49.51 40.39,48.67 v1(40.39,48.12)
  BOTTOM w0.14: CN15.25 39.88,48.96 40.39,48.45 v1(40.39,48.12)
MY2: length 129
  TOP w0.14: v1(143.34,50.28) 143.84,50.78 U32.38 143.84,52.94 143.63,53.15 143.63,53.49 143.19,53.93 v1(143.19,53.96) ; v1(38.9,48.24) 38.13,47.48 36.03,47.48 35.77,47.23 35.77,46.34 35.87,46.24 CP6.4
  IN3 w0.089: v1(38.9,48.24) 39.25,48.24 39.96,47.53 40.39,47.53 40.98,48.12 40.98,48.94 41.36,49.32 47.39,49.32 48.09,48.62 48.09,47.48 50.25,45.32 58.14,45.32 58.98,46.16 60.96,46.16 62.59,44.53 89.77,44.53 91.82,46.58 95.77,46.58 96.55,47.35 103.25,47.35 103.99,46.62 105.27,46.62 106.32,47.67 109.68,47.67 110.6,46.76 122.9,46.76 123.39,47.25 129.78,47.25 131,48.47 133.13,48.47 134.2,49.54 136.47,49.54 137.47,50.53 141.11,50.53 143.62,53.04 143.62,53.53 v1(143.19,53.96)
  BOTTOM w0.14: CN15.24 40.68,48.92 40.98,48.62 40.98,47.99 40.47,47.48 39.96,47.48 39.2,48.24 v1(38.9,48.24)
MY3: length 123.8
  TOP w0.14: CP6.2 37.25,47.02 37.42,46.85 37.42,46.59 v1(37.68,46.34) 38.06,46.34 v1(39.2,47.48) ; U32.39 144.24,52.98 144.08,53.14 v1(144.08,53.32)
  IN3 w0.089: v1(39.2,47.48) 39.46,47.23 40.47,47.23 41.23,47.99 41.23,48.88 41.49,49.13 47.26,49.13 47.84,48.56 47.84,47.42 50.12,45.13 58.22,45.13 59.06,45.97 60.88,45.97 62.52,44.34 89.85,44.34 91.9,46.39 95.85,46.39 96.63,47.16 103.17,47.16 103.91,46.43 105.35,46.43 106.4,47.48 109.6,47.48 110.52,46.57 122.98,46.57 123.47,47.06 129.86,47.06 131.08,48.28 133.21,48.28 134.28,49.35 136.55,49.35 137.55,50.34 141.59,50.34 144.08,52.82 144.08,53.3 144.1,53.32 v1(144.08,53.32)
  BOTTOM w0.14: v1(39.2,47.48) 39.46,47.23 40.6,47.23 41.22,47.85 41.22,48.62 41.48,48.88 CN15.23
MY4: length 125.4
  TOP w0.14: v1(144.08,53.96) 144.51,53.53 144.51,53.13 144.64,53 U32.40 144.64,50.33 v1(144.61,50.3) ; v1(43.11,47.99) 43.52,47.58 43.52,47.23 43.21,46.92 41.66,46.92 41.11,47.48 41.11,48.41 40.69,48.83 38.77,48.83 38.13,48.19 CP1.8
  IN3 w0.089: v1(43.11,47.99) 43.8,47.99 44.75,48.94 47.18,48.94 47.65,48.48 47.65,47.34 50.04,44.94 58.3,44.94 59.14,45.78 60.8,45.78 62.44,44.15 89.92,44.15 91.98,46.2 95.93,46.2 96.71,46.97 103.09,46.97 103.83,46.24 105.43,46.24 106.48,47.29 109.52,47.29 110.44,46.38 123.06,46.38 123.55,46.87 129.94,46.87 131.16,48.09 133.29,48.09 134.36,49.15 136.63,49.15 137.62,50.15 141.67,50.15 144.51,52.98 144.51,53.53 v1(144.08,53.96)
  BOTTOM w0.14: CN15.22 42.28,48.9 42.68,48.5 42.68,48.42 v1(43.11,47.99)
MY5: length 123.3
  TOP w0.14: v1(43.01,47.38) 41.59,47.38 41.36,47.61 41.36,48.62 40.73,49.26 38.57,49.26 38.29,48.98 CP1.6 ; v1(145.88,50.3) 145.04,51.14 U32.41 145.04,53.22 v1(144.94,53.32)
  IN3 w0.089: v1(144.94,53.32) 144.94,53.02 141.88,49.96 137.7,49.96 135.64,47.9 131.24,47.9 130,46.66 123.69,46.66 123.22,46.19 110.36,46.19 109.52,47.02 106.48,47.02 105.5,46.05 103.75,46.05 103.01,46.78 96.79,46.78 96.01,46.01 92.06,46.01 90,43.95 59.34,43.95 58.54,44.75 49.93,44.75 47.46,47.22 47.46,48.33 47.03,48.75 45.17,48.75 43.8,47.38 v1(43.01,47.38)
  BOTTOM w0.14: v1(43.01,47.38) 43.14,47.38 43.65,47.89 43.65,48.37 43.08,48.94 CN15.21
MY6: length 128
  TOP w0.14: v1(42.4,47.86) 42.4,48.6 40.98,50.02 39.64,50.02 38.14,51.52 v1(37.8,51.52) 37.53,51.52 36.79,50.78 36.79,50.02 37.02,49.79 CP1.4 ; v1(144.94,53.96) 145.36,53.54 145.36,52.97 145.44,52.89 U32.42
  IN2 w0.114: v1(93.56,44.96) 93.56,45.09 93.28,45.37 91.26,45.37 90.46,44.57 62.81,44.57 60.17,47.22 57.29,47.22 56.47,48.03 56.47,48.27 56.09,48.66 55.29,48.66 54.51,49.44 43.98,49.44 v1(42.4,47.86)
  IN3 w0.089: v1(144.94,53.96) 145.37,53.53 145.37,52.94 142.2,49.77 137.78,49.77 135.72,47.7 131.32,47.7 130.08,46.47 123.77,46.47 123.3,46 110.28,46 109.44,46.83 106.56,46.83 105.58,45.86 103.67,45.86 102.93,46.59 96.86,46.59 95.85,45.58 94.17,45.58 v1(93.56,44.96)
  BOTTOM w0.14: CN15.20 43.88,48.65 43.98,48.55 43.98,47.56 43.37,46.95 42.78,46.95 42.4,47.33 v1(42.4,47.86)
MY7: length 125.7
  TOP w0.14: U32.43 145.84,52.87 145.8,52.9 v1(145.8,53.32) ; CP1.2 38.39,50.58 39.33,49.64 40.85,49.64 41.79,48.7 v1(41.79,47.86)
  IN2 w0.114: v1(94.19,44.96) 93.55,45.6 91.19,45.6 90.37,44.79 62.9,44.79 60.26,47.43 59.46,47.43 59.22,47.68 59.22,48.42 58.73,48.91 55.82,48.91 55.06,49.67 43.6,49.67 v1(41.79,47.86)
  IN3 w0.089: v1(94.19,44.96) 94.61,44.54 96.81,44.54 98.67,46.4 102.85,46.4 103.59,45.67 105.69,45.67 106.66,46.64 109.37,46.64 110.2,45.81 123.38,45.81 123.85,46.28 130.16,46.28 131.4,47.51 135.8,47.51 137.86,49.58 142.28,49.58 145.8,53.11 v1(145.8,53.32)
  BOTTOM w0.14: CN15.19 44.68,48.97 44.28,48.57 44.28,47.35 43.62,46.69 42.53,46.69 41.79,47.43 v1(41.79,47.86)
MY8: length 115.5
  TOP w0.14: CP2.8 48.65,47.23 47.66,48.22 v1(47,48.22) ; U32.44 146.24,53.52 v1(145.8,53.96)
  IN2 w0.114: v1(47,48.22) 47.53,48.75 52.66,48.75 54.03,47.38 56.2,47.38 57.02,46.57 59.9,46.57 62.55,43.93 91.89,43.93 v1(92.92,44.96)
  IN3 w0.089: v1(145.8,53.96) 146.24,53.53 146.24,53.1 142.53,49.39 137.94,49.39 135.88,47.32 131.48,47.32 130.24,46.08 123.93,46.08 123.44,45.6 109.01,45.6 108.16,46.45 106.74,46.45 105.77,45.48 103.51,45.48 102.77,46.21 98.75,46.21 96.89,44.35 93.53,44.35 v1(92.92,44.96)
  BOTTOM w0.14: CN15.18 45.48,48.82 45.81,48.5 45.81,48.19 46.24,47.76 46.54,47.76 v1(47,48.22)
MY9: length 114.7
  TOP w0.14: v1(46.39,48.22) 46.87,47.74 47.46,47.74 47.86,47.33 CP2.6 ; v1(146.9,53.91) 146.49,53.5 146.49,53.09 146.64,52.94 U32.45
  IN2 w0.114: v1(46.39,48.22) 47.15,48.98 54.34,48.98 55.43,47.89 55.43,47.76 55.59,47.6 56.29,47.6 57.11,46.78 59.99,46.78 62.63,44.14 91.44,44.14 v1(92.26,44.96)
  IN3 w0.089: v1(146.9,53.91) 146.52,53.53 146.52,53.11 142.61,49.2 138.02,49.2 135.96,47.13 131.55,47.13 130.32,45.89 124,45.89 123.52,45.41 108.93,45.41 108.08,46.26 106.82,46.26 105.85,45.28 103.43,45.28 102.7,46.02 98.83,46.02 96.97,44.16 93.06,44.16 v1(92.26,44.96)
  BOTTOM w0.14: CN15.17 46.28,48.33 v1(46.39,48.22)
MY10: length 118.1
  TOP w0.14: v1(146.92,53.27) 147.04,53.16 U32.46 ; v1(45.3,48.22) 45.78,48.22 46.52,47.48 46.69,47.48 47.05,47.13 CP2.4
  IN2 w0.114: v1(45.3,48.22) 46.29,49.21 54.42,49.21 55.2,48.42 56.01,48.42 56.26,48.18 56.26,47.94 57.2,47 60.08,47 62.72,44.36 91.05,44.36 v1(91.65,44.96)
  IN3 w0.089: v1(146.92,53.27) 146.85,53.2 146.85,53.17 142.69,49.01 138.1,49.01 136.04,46.94 131.63,46.94 130.39,45.7 124.08,45.7 123.6,45.22 108.85,45.22 108,46.07 106.9,46.07 105.92,45.09 103.58,45.09 103.38,44.89 102.66,44.89 101.72,45.83 98.92,45.83 97.06,43.97 92.63,43.97 91.65,44.95 v1(91.65,44.96)
  BOTTOM w0.14: CN15.16 47.08,48.87 47.46,48.5 47.46,47.99 46.95,47.48 46.03,47.48 v1(45.3,48.22)
MY11: length 120.5
  TOP w0.14: v1(45.3,46.08) 45.93,46.08 46.26,46.42 CP2.2 46.26,47.15 45.83,47.58 v1(45.31,47.58) ; v1(147.79,53.91) 148.5,53.2 148.79,53.2 149.04,52.94 U32.51
  IN3 w0.089: v1(147.79,53.91) 147.35,53.48 147.35,52.77 147.15,52.56 146.51,52.56 142.77,48.82 138.18,48.82 136.11,46.75 131.71,46.75 130.47,45.51 124.16,45.51 123.68,45.03 108.77,45.03 107.92,45.88 106.98,45.88 106,44.9 103.66,44.9 103.46,44.7 102.58,44.7 101.64,45.64 99.01,45.64 97.13,43.76 53.03,43.76 52.22,44.56 47.46,44.56 45.31,46.71 v1(45.31,47.58)
  BOTTOM w0.14: v1(45.31,47.58) 45.67,47.23 47.2,47.23 47.88,47.91 CN15.15
MY12: length 114.3
  TOP w0.14: v1(148.42,53.93) 149.44,52.91 U32.52 ; v1(51.62,47.81) 51.62,47.51 52.08,47.05 CP3.8 52.08,46.42 52.6,45.89 52.6,44.37 v1(52.16,43.93)
  IN3 w0.089: v1(52.16,43.93) 52.51,43.57 97.27,43.57 99.15,45.45 101.56,45.45 102.5,44.51 103.54,44.51 103.74,44.71 106.08,44.71 107.06,45.69 107.84,45.69 108.69,44.84 123.76,44.84 124.24,45.32 130.55,45.32 131.79,46.56 136.19,46.56 138.26,48.62 142.84,48.62 146.4,52.18 147.79,52.18 148.37,52.76 148.37,53.88 v1(148.42,53.93)
  BOTTOM w0.14: v1(51.62,47.81) 51.17,47.35 49.23,47.35 48.68,47.91 CN15.14
MY13: length 111.3
  TOP w0.14: CP3.6 51.29,47.08 50.63,47.74 50.38,47.74 50,48.12 v1(49.74,48.12) ; v1(149.56,53.4) 149.84,53.12 U32.53
  IN1 w0.114: v1(49.74,48.12) 50.07,48.45 50.07,48.47 50.61,49.01 53.27,49.01 54.96,50.7 61.37,50.7 61.95,50.12 63.79,50.12 63.9,50.23 64.74,50.23 65.07,49.89 66.84,49.89 67.43,49.29 70.12,49.29 71.92,47.49 89.2,47.49 90.03,48.32 106.38,48.32 107.44,47.26 109.72,47.26 110.51,46.47 118.94,46.47 120.5,48.03 129.07,48.03 131.82,50.78 144.56,50.78 145.75,51.97 148.17,51.97 149.18,52.99 149.18,53.02 v1(149.56,53.4)
  BOTTOM w0.14: v1(49.74,48.12) 49.48,48.38 CN15.13
MY14: length 115.3
  TOP w0.14: v1(149.56,54.04) 150.07,53.53 150.07,53.24 150.24,53.07 U32.54 ; CP3.4 50.48,47.13 50,47.61 49.6,47.61 49.03,48.18 v1(49.03,49.22) 49.53,49.22 v1(50.5,48.24)
  IN1 w0.114: v1(50.5,48.24) 51.05,48.79 53.4,48.79 55.09,50.48 61.28,50.48 61.86,49.9 63.99,49.9 64.09,50.01 64.65,50.01 64.98,49.67 65.29,49.67 66.62,48.34 68.32,48.34 69.39,47.27 89.29,47.27 90.12,48.1 106.29,48.1 107.35,47.04 109.63,47.04 110.42,46.26 119.03,46.26 119.86,47.08 122.54,47.08 123.27,47.81 129.15,47.81 131.25,49.9 143.99,49.9 145.84,51.76 148.5,51.76 150,53.25 150,53.6 v1(149.56,54.04)
  BOTTOM w0.14: CN15.12 50.28,48.47 v1(50.5,48.24)
MY15: length 115.4
  TOP w0.14: v1(150.58,53.37) 150.58,52.93 150.64,52.87 U32.55 ; v1(51.12,48.24) 51.12,49.28 v3(50.63,49.77) 48.85,49.77 48.35,49.26 48.35,48.37 49.69,47.02 CP3.2
  IN1 w0.114: v1(150.58,53.37) 148.74,51.54 145.93,51.54 144.08,49.69 131.34,49.69 129.02,47.37 123.13,47.37 122.63,46.87 119.95,46.87 119.12,46.04 110.33,46.04 109.54,46.83 104.35,46.83 103.29,47.89 90.21,47.89 89.38,47.06 69.3,47.06 68.23,48.12 66.53,48.12 65.62,49.04 62.16,49.04 60.93,50.26 55.2,50.26 53.4,48.46 51.33,48.46 v1(51.12,48.24)
  BOTTOM w0.14: v1(51.12,48.24) 51.12,49.22 CN15.11
MY16: length 108.5
  TOP w0.14: v1(54.92,47.81) 54.72,47.61 CP4.6 ; U32.56 151.04,51.32 150.12,50.4 146.77,50.4 v1(146.39,50.78)
  IN1 w0.114: v1(146.39,50.78) 144.86,49.26 131.52,49.26 129.2,46.94 123.31,46.94 122.81,46.43 120.13,46.43 119.3,45.61 108.87,45.61 108.09,46.4 104.17,46.4 103.11,47.46 90.41,47.46 89.58,46.62 69.12,46.62 68.05,47.69 66.35,47.69 65.44,48.61 61.98,48.61 60.76,49.83 56.62,49.83 54.92,48.14 v1(54.92,47.81)
  BOTTOM w0.14: CN15.10 51.88,48.65 52.28,48.24 53.17,48.24 54.06,47.35 54.47,47.35 v1(54.92,47.81)
MY17: length 113.4
  TOP w0.14: v1(150.58,54.09) 151.44,53.23 U32.57 ; v1(54.31,47.81) 54.19,47.94 v3(54.19,48.88) 54.7,48.88 55.37,48.2 55.37,46.89 CP4.8
  IN1 w0.114: v1(150.58,54.09) 151.01,53.65 151.01,53.12 149.21,51.32 146.02,51.32 144.17,49.47 131.43,49.47 129.11,47.15 123.22,47.15 122.72,46.65 120.04,46.65 119.21,45.82 110.24,45.82 109.45,46.61 104.26,46.61 103.2,47.67 90.3,47.67 89.47,46.84 69.21,46.84 68.14,47.91 66.44,47.91 65.53,48.82 62.07,48.82 60.84,50.05 56.45,50.05 54.31,47.91 v1(54.31,47.81)
  BOTTOM w0.14: v1(54.31,47.81) 53.98,47.81 53.3,48.5 52.79,48.5 52.68,48.61 CN15.9
N12E_SCL: length 18.2
  BOTTOM w0.102: U43.C9 52.41,126.64 52.91,126.14 53.04,126.14 53.66,125.53 53.9,125.53 54.7,124.74 54.7,123.74 55.46,122.98
  BOTTOM w0.14: v1(54.44,111.26) 54.44,112.39 R632.1 55.51,113.45 55.51,115.53 56.21,116.23 56.21,122.23 55.46,122.98
N12E_SDA: length 13.3
  BOTTOM w0.102: 55.46,122.59 54.45,123.6 54.45,124.7 53.84,125.3 52.6,125.3 U43.C8
  BOTTOM w0.14: 55.46,122.59 55.97,122.09 55.97,116.7 v1(55.46,116.19) 55.08,115.81 R612.1
NBSWON#: length 281.2
  TOP w0.14: R310.1 143.04,70.63 U32.125 143.04,67.03 143.31,66.76 143.65,66.76 144.13,66.28 144.13,64.39 145.29,63.24 145.92,63.24 146.48,62.67 v1(146.59,62.67) ; v1(72.58,104.89) 75.9,104.89 76.84,103.95 80.65,103.95 v1(83.27,101.33) ; v1(164.55,44.31) 164.75,44.51 SW1.2
  IN1 w0.114: v1(146.59,62.67) 149.61,62.67 152.87,59.42 152.87,58.78 153.36,58.29 156.53,58.29 158.91,55.92 158.91,51.78 160.23,50.45 160.23,49.61 164.04,45.8 164.04,44.81 v1(164.55,44.31)
  IN3 w0.089: v1(29.14,118.58) 29.45,118.58 30.57,117.46 31.84,117.46 33.05,116.24 33.05,114.82 38.1,109.78 43.71,109.78 44.28,110.35 51.65,110.35 52.09,109.9 58.95,109.9 60.41,108.44 64.57,108.44 66.13,106.88 70,106.88 71.99,104.89 v1(72.58,104.89) ; v1(146.59,62.67) 146.32,62.94 145.44,62.94 144.74,62.25 144.74,60.44 143.42,59.12 141.99,59.12 141.82,59.29 141.82,59.8 140.32,61.3 137.35,61.3 134.96,58.91 134.07,58.91 133.56,58.4 133.56,57.91 131.57,55.91 129.88,55.91 127.98,54.02 125.68,54.02 125.22,53.56 124.89,53.56 124.02,54.42 117.64,54.42 117.08,53.86 116.67,53.86 116.42,54.11 116.42,54.77 115.45,55.74 105.88,55.74 104.56,54.42 103.51,54.42 101.94,55.99 90.51,55.99 89.75,55.23 88.35,55.23 87.32,54.19 86.43,54.19 86.15,54.47 85.22,54.47 85.22,54.47 73.62,54.47 73.43,54.66 71.52,54.66 71.43,54.57 66.98,54.57 66.35,55.2 66.35,56.02 65.11,57.26 65.11,62.72 66.02,63.63 66.02,64.29 65.13,65.17 65.13,72.02 65.59,72.48 69.53,72.48 78.32,81.26 80.86,81.26 83.91,84.31 83.91,96.38 84.03,96.5 84.03,100.57 v1(83.27,101.33)
  BOTTOM w0.14: v1(29.14,118.58) 27.54,118.58 27.09,119.03 TP130.1 23.33,119.24 22.31,119.24 20.33,117.26 20.33,116.87 17.88,114.42 15.69,114.42 12.68,117.43 CN6.10 ; v1(146.59,62.67) 146.26,63 146.26,63.74 146.59,64.06 R729.2
NOA_STBN_0: length 5.4
  BOTTOM w0.076: U45.AA62 106.79,118.34 106.79,118.34 106.39,117.94 106.07,117.94 105.96,117.82 104.83,117.82 104.58,118.08 102.28,118.08 TP132.1
NOA_STBN_1: length 16.2
  TOP w0.14: v1(93.63,115.58) 94.29,115.58 TP69.1
  IN2 w0.114: v1(104.76,121.4) 104.66,121.5 102.83,121.5 102.18,120.85 99.23,120.85 93.96,115.58 v1(93.63,115.58)
  BOTTOM w0.076: v1(104.76,121.4) 105.32,120.84 106.01,120.84 U45.U63
NOA_STBP_0: length 6.8
  TOP w0.14: v1(102.52,118.91) TP52.1
  BOTTOM w0.076: v1(102.52,118.91) 102.52,118.62 102.73,118.42 102.9,118.25 104.65,118.25 104.9,117.99 105.89,117.99 106.01,118.11 106.32,118.11 106.55,118.34 106.55,118.52 106.72,118.69 106.97,118.69 107.22,118.44 U45.AA61
NOA_STBP_1: length 16.9
  IN2 w0.114: v1(94.9,114.08) 96.15,115.33 96.15,115.88 100.04,119.78 104.97,119.78 v1(105.62,120.43)
  BOTTOM w0.076: v1(105.62,120.43) 105.7,120.35 106.32,120.35 106.61,120.65 U45.U62
  BOTTOM w0.14: TP141.1 94.91,114.08 v1(94.9,114.08)
NV_PLLVDD: length 0.6
  BOTTOM w0.381: U43.L6 v1(45.06,123.68)
  vias: v1(45.68,119.49)
ODD_PRSNT#: length 12.8
  TOP w0.14: v1(146.9,110.78) 147.29,110.78 149.63,113.12 151.88,113.12 152.1,112.89 152.26,112.89 152.59,112.56 v1(153.25,112.56)
  BOTTOM w0.076: v1(146.9,110.78) 146.64,111.03 145.96,111.03 145.3,111.69 145.17,111.69 144.95,111.91 144.7,111.91 144.48,111.68 144.48,111.5 144.3,111.32 143.78,111.32 U45.AN3
  BOTTOM w0.14: R635.1 153.68,112.12 v1(153.25,112.56)
OPI_COMP1: length 4.1
  BOTTOM w0.241: 136.74,106.41 136.74,106.66 136.2,107.2 U45.AY15
  BOTTOM w0.381: 136.74,106.41 136.74,104.78 137.37,104.15 R654.2
OPI_COMP2: length 8
  BOTTOM w0.241: U45.AW15 136.58,107.72 136.58,107.29 137.25,106.62 137.25,106.56
  BOTTOM w0.381: 137.25,106.56 137.27,106.54 137.27,105.1 137.93,104.44 137.93,102.77 137.89,102.73 R664.2 137.89,101.54 v3(137.4,101.05)
PCBEEP: length 4
  TOP w0.14: U34.12 231.18,37.92 230.84,37.58 230.84,36.53 C508.1 229.8,36.56 v1(229.32,36.56)
PCBEEP_EC: length 97.7
  TOP w0.14: U32.34 142.24,52.9 142.1,53.04 142.1,53.73 142.83,54.47 144.72,54.47 145.86,55.61 145.86,57.13 146.55,57.82 148.35,57.82 148.98,57.2 150.01,57.2 151.16,58.35 153.91,58.35 v1(154.31,58.76) ; v1(170.89,42.9) 171.79,43.8 174.08,43.8 175.22,44.94 183.85,44.94 190.97,37.83 219.03,37.83 219.92,38.72 D20.2
  IN1 w0.114: v1(170.89,42.9) 167.39,42.9 160.45,49.84 160.45,50.54 159.12,51.87 159.12,56 156.37,58.76 v1(154.31,58.76)
PCH_ACPRESENT: length 21.3
  TOP w0.089: v1(139.93,113.81) 140.14,113.81 140.9,113.04 140.9,110.19 140.55,109.84 140.55,109.71
  TOP w0.14: R239.2 143.46,98.04 v1(143.47,98.03) 143.98,98.03 144.36,98.41 144.36,98.97 144.15,99.17 144.15,99.81 144.67,100.32 R234.1 144.74,100.82 144.61,100.95 144.61,101.2 144.23,101.58 144.23,102.1 R219.1 144.74,103 144.5,103.23 144.5,104.77 142.75,106.53 142.75,106.8 141.62,107.93 140.93,107.93 140.55,108.31 140.55,109.71
  BOTTOM w0.102: v1(139.93,113.81) 140.24,114.11 U45.AJ8
PCH_AZ_CODEC_BITCLK: length 134.9
  TOP w0.127: U34.6 230.71,40.32 230.53,40.5 229.96,40.5 229.33,41.13 C498.2 229.53,41.34 v1(229.53,41.94) ; v1(163.64,89.63) 164.09,90.09 164.09,90.18 164.44,90.52 166.93,90.52 167.61,89.84 188.04,89.84 191.85,86.03 196.9,86.03 198.81,84.11 198.81,82.81 205.39,76.23 v1(205.39,75.68)
  IN3 w0.127: v1(205.39,75.68) 206.59,74.48 206.59,73.72 208.19,72.12 213.95,72.12 218.07,68.01 218.07,62.98 218.75,62.29 220.76,62.29 226.07,56.98 226.07,44.13 227.8,42.4 229.07,42.4 v1(229.53,41.94)
  BOTTOM w0.127: R652.1 142.71,103.61 143.32,103.01 143.32,100.35 C679.2 143.86,99.66 143.47,99.27 143.47,98.21 146.94,94.74 149.14,94.74 150.03,95.63 154.4,95.63 154.73,95.3 156.43,95.3 159.91,91.82 159.91,89.53 160.62,88.82 162.82,88.82 v1(163.64,89.63)
PCH_AZ_CODEC_RST#: length 136
  TOP w0.127: U34.11 230.84,38.32 230.61,38.08 230.09,38.08 C503.1 229.57,38.85 v1(230.03,39.3) ; D17.1 v1(224.49,48.62) ; v1(163.66,90.28) 164.22,90.84 167.06,90.84 167.74,90.15 188.17,90.15 191.98,86.34 197.03,86.34 199.13,84.24 199.13,82.94 205.83,76.25 205.83,74.71 v1(205.39,74.28)
  IN3 w0.127: v1(230.03,39.3) 229.5,39.3 225.13,43.67 225.13,47.99 v1(224.49,48.62) 223.91,49.21 223.91,58.24 220.5,61.66 218.49,61.66 217.43,62.71 217.43,67.5 214.33,70.6 208.31,70.6 205.39,73.52 v1(205.39,74.28)
  BOTTOM w0.127: v1(163.66,90.28) 163.46,90.48 162.85,90.48 161.57,89.21 160.71,89.21 160.23,89.69 160.23,91.96 156.57,95.62 154.86,95.62 154.53,95.95 149.9,95.95 149.01,95.06 147.07,95.06 144.76,97.36 v1(144.76,98.15) 144.71,98.21 144.71,99.1 144.48,99.33 144.48,100.08 144.24,100.32 143.83,100.32 143.65,100.5 143.65,101.75 R659.1
PCH_AZ_CODEC_SDIN0: length 138
  TOP w0.127: v1(204.05,75.93) 203.79,75.93 198.15,81.57 198.15,83.75 196.51,85.39 191.59,85.39 187.78,89.2 164.72,89.2 v1(164.55,89.37) ; R405.2 v1(226.65,39.73)
  IN3 w0.127: v1(226.65,39.73) 226.25,40.14 226.25,40.9 224.62,42.53 224.62,47.35 223.48,48.5 223.48,58.23 220.37,61.34 218.36,61.34 217.12,62.58 217.12,67.05 213.93,70.24 208.09,70.24 204.68,73.64 204.68,75.29 v1(204.05,75.93)
  BOTTOM w0.076: U45.AY10 139.2,107.17 139.39,106.98 139.39,105.08 139.63,104.83
  BOTTOM w0.127: 139.63,104.83 140.29,104.17 140.29,103.29 141.16,102.42 141.16,100.92 142.17,99.91 142.17,98.5 142.96,97.71 143.07,97.71 146.67,94.11 149.4,94.11 150.3,95 154.14,95 154.47,94.67 156.15,94.67 159.27,91.54 159.27,87.89 159.61,87.55 162.73,87.55 v1(164.55,89.37)
PCH_AZ_CODEC_SDOUT: length 132.7
  TOP w0.127: v1(164.55,90.03) 166.97,90.03 167.48,89.52 187.91,89.52 191.72,85.71 196.77,85.71 198.48,83.99 198.48,81.69 203.78,76.39 204.35,76.39 204.81,75.93 204.81,75.6 v1(205.39,75.02) ; U34.5 231.19,40.72 231.12,40.65 230.72,40.65 230.62,40.75 230.46,40.75 v1(230.08,41.13)
  IN3 w0.127: v1(230.08,41.13) 228.43,41.13 225.66,43.9 225.66,56.94 220.63,61.97 218.62,61.97 217.75,62.84 217.75,67.81 213.89,71.68 207.97,71.68 206.08,73.57 206.08,74.33 v1(205.39,75.02)
  BOTTOM w0.127: R657.1 141.69,100.85 142.48,100.05 142.48,98.63 143.09,98.03 143.2,98.03 146.8,94.42 149.27,94.42 150.17,95.32 154.27,95.32 154.6,94.99 156.29,94.99 159.59,91.68 159.59,89.4 160.49,88.5 163.15,88.5 164.14,89.49 164.14,89.62 v1(164.55,90.03)
PCH_AZ_CODEC_SYNC: length 134.5
  TOP w0.127: v1(230.25,38.69) 230.69,38.69 230.72,38.72 U34.10 ; v1(164.52,88.71) 164.7,88.88 187.65,88.88 191.46,85.07 196.38,85.07 197.82,83.63 197.82,81.39 203.89,75.32 v1(204.05,75.32)
  IN3 w0.127: v1(204.05,75.32) 204.05,73.64 207.83,69.86 213.67,69.86 216.8,66.74 216.8,62.45 218.23,61.02 220.23,61.02 223.05,58.21 223.05,47.38 223.48,46.95 223.48,42.78 223.99,42.27 223.99,39.99 225.29,38.69 v1(230.25,38.69)
  BOTTOM w0.127: R684.1 141.33,97.24 143.05,97.24 146.51,93.78 149.54,93.78 150.43,94.68 154.01,94.68 154.34,94.35 156.02,94.35 158.95,91.42 158.95,87.76 159.48,87.23 163.05,87.23 v1(164.52,88.71)
PCH_BATLOW#: length 16.1
  TOP w0.14: v1(143.17,111.99) 142.96,111.78 142.96,110.22 143.72,109.46 143.72,108.26 145.16,106.83 145.16,106.54 147.56,104.14 147.56,103.65 147.79,103.41 147.79,103.1 148.42,102.47 148.42,101.96 R226.1 147.91,101.2 148.17,100.95 v1(148.17,100.06) 148.92,100.06 R237.1
  BOTTOM w0.102: U45.AN4 142.87,111.69 v1(143.17,111.99)
PCH_BLON: length 103.9
  TOP w0.14: v1(68.79,106.03) 69.17,106.41 v1(69.17,107.3) 69.17,107.93 68.79,108.31 65.62,108.31 65.1,107.8 R191.1 R193.2 66.26,105.12 66.26,104.39 66.13,104.25 Q18.5
  IN2 w0.114: v1(68.79,106.03) 69.33,106.56 71.69,106.56 72.73,105.52 76.67,105.52 78.19,104 80.73,104 81.37,103.36 83.19,103.36 85.96,106.13 85.96,111.13 88.48,113.65 93.24,113.65 93.68,113.2 95.53,113.2 100.42,118.09 105.88,118.09 106.89,119.11 109.3,119.11 109.69,119.49 111.72,119.49 111.86,119.64 129.24,119.64 130.42,120.83 130.42,123.14 131.83,124.54 134.04,124.54 134.55,125.06 134.55,128.23 135.06,128.73 136.07,128.73 138.74,131.4 v1(140.07,131.4)
  BOTTOM w0.076: v1(140.07,131.4) 140.07,130.97 139.37,130.27 U45.A9
PCH_BLON_EC: length 216.1
  TOP w0.14: v1(66.51,106.03) 66.25,106.28 R193.1 ; v1(146.49,65.44) 146.49,66.56 146.26,66.79 145.65,66.79 145.44,67 U32.119
  IN3 w0.089: v1(146.49,65.44) 146.49,64.53 148,63.02 148,60.65 147.1,59.75 147.1,58.33 145.14,56.37 142.71,56.37 142.2,56.88 140.08,56.88 139.32,57.64 136.9,57.64 135.33,56.07 135.33,55.87 134.83,55.38 134.08,55.38 131.6,52.89 129.91,52.89 128.28,51.26 119.4,51.26 119.03,50.9 115.66,50.9 114.62,51.95 112.54,51.95 111.68,52.8 106.2,52.8 104.78,51.38 104.24,51.38 104.01,51.15 91.11,51.15 89.23,49.26 81.81,49.26 80.84,48.29 70.93,48.29 69.72,49.49 65.49,49.49 65.16,49.16 64.31,49.16 63.68,49.79 62.07,49.79 60.54,51.32 51.35,51.32 48.66,54 36.19,54 35.59,54.6 35.59,73.74 37.11,75.26 37.11,95.09 36.03,96.16 36.03,99.48 36.53,99.98 36.53,103.36 40.22,107.04 41.36,107.04 41.93,107.62 47.39,107.62 47.84,108.06 59.78,108.06 60.54,107.3 65.24,107.3 v1(66.51,106.03)
PCH_BRIGHT: length 148.9
  TOP w0.14: v1(60.12,109.69) 60.12,109.17 59.29,108.34 58.51,108.34 58,107.83 58,106.54 57.62,106.16 57.62,105.52 57.31,105.22 54.9,105.22 53.53,103.84 53.53,99.68 53.65,99.55 v1(53.65,99.58)
  IN1 w0.114: v1(91.55,138.92) 91.55,144.03 96.44,148.92 103.96,148.92 108.54,144.33 v1(117.81,144.33) 118.77,144.33 120.37,142.73 126.25,142.73 128.36,140.62 136.2,140.62 140.44,136.38 141.82,136.38 v1(142.45,135.75)
  IN3 w0.089: v1(91.55,138.92) 88.48,135.85 84.06,135.85 80.62,132.41 80.62,121.74 68.08,109.2 60.61,109.2 v1(60.12,109.69)
  BOTTOM w0.076: U45.B8 139.99,129.49 139.99,130.2 140.83,131.03 140.83,131.84 141.95,132.96 142.08,132.96 142.66,133.54 142.66,133.84
  BOTTOM w0.14: v1(53.65,99.58) 53.63,99.55 53.6,99.55 54.36,100.31 R671.2 ; R502.1 117.05,136.36 118.07,137.37 118.07,138.67 115.78,140.95 115.78,142.3 v1(117.81,144.33) ; v1(142.45,135.75) 142.66,135.54 142.66,133.84
PCH_INTVRMEN: length 12
  BOTTOM w0.076: 143.85,104.76 142.11,104.76 140.41,106.46 140.41,108.49 U45.AV7
  BOTTOM w0.14: R676.2 145.02,100.32 145.63,100.93 145.63,101.2 145.31,101.52 145.31,102.03 R660.1 144.61,102.74 v1(144.61,103.62) 144.61,104 143.85,104.76
PCH_JTAG_TDO: length 20
  TOP w0.14: R162.2 90.59,116.75 90.64,116.7 R164.2 91.14,116.07 v1(91.4,115.81) 91.92,115.29 91.93,115.29 92.63,114.59 104.91,114.59 106.85,116.52 v1(107.2,116.52)
  BOTTOM w0.102: v1(107.2,116.52) 107.5,116.23 U45.AE61
PCH_JTAGX: length 8.8
  BOTTOM w0.076: U45.AE63 106.16,116.19 104.15,116.19 104.15,116.19 104.03,116.19 103.68,116.54 102.35,116.54 101.51,117.38 101.13,117.38 100.92,117.59 v3(100.21,117.59)
  BOTTOM w0.089: v3(100.21,117.59) 100.03,117.59 99.65,117.97 99.53,117.97
  BOTTOM w0.14: R597.2 R594.1 99.53,117.97
PCH_PWRBTN#: length 17.5
  TOP w0.089: 142.2,108.71 141.94,108.96 141.94,112.56 v1(141.51,112.99)
  TOP w0.14: 142.2,108.71 144.1,106.8 v1(144.1,106.54) 144.1,106.25 145.27,105.09 145.27,103.77 146.21,102.83 146.21,102.14 146.52,101.83 R221.1 146.57,101.5 146.57,100.65 R236.2 146.56,100.2 146.31,100.44 145.87,100.44 R235.1
  BOTTOM w0.102: U45.AL7 141.2,113.3 v1(141.51,112.99)
PCH_PWROK: length 199.8
  TOP w0.14: v1(151.27,57.79) 151.27,57.81 151.32,57.86 153.77,57.86 154.21,58.3 154.52,58.3 155.14,58.93 U32.78 157.92,58.93 R356.2 R352.2
  IN1 w0.114: v1(82.76,103.87) 82.38,103.87 78.44,99.93 78.44,96.81 74.56,92.92 73.92,92.92 71.87,90.87 71.87,88.4 67.38,83.91 67.38,80.46 66.44,79.52 66.44,78.14 66.03,77.73 66.03,77.37 65.6,76.94 65.6,76.29 64.9,75.59 64.9,75.01 63.97,74.08 63.97,69.2 63.71,68.94 63.71,66.44 65.02,65.13 65.02,64.51 64.84,64.34 64.84,55.67 64.82,55.65 64.82,55.26 65.41,54.67 66.56,54.67 66.9,54.33 70.58,54.33 71.81,53.1 76.18,53.1 v1(76.44,52.84)
  IN2 w0.114: v1(76.44,52.84) 76.67,53.07 80.72,53.07 82.09,51.7 97.65,51.7 98.01,52.06 113.44,52.06 113.72,51.77 114.28,51.77 115.05,51.01 123.5,51.01 126.32,53.83 128.4,53.83 129.04,54.47 131.91,54.47 132.72,55.27 136.79,55.27 137.32,54.74 137.32,54.37 137.85,53.83 139.91,53.83 141.31,55.24 148.69,55.24 149.22,54.71 150.44,54.71 151.09,55.36 151.09,57.6 v1(151.27,57.79) ; v1(82.76,103.87) 83.32,103.87 85.73,106.28 85.73,113.06 88.25,115.59 90.09,115.59 91.91,117.41 91.91,122.46 91.65,122.72 91.65,124.95 94.95,128.25 94.95,130.24 96.83,132.11 v1(97.44,132.11)
  BOTTOM w0.14: v1(96.91,133.46) 97.05,133.33 R518.2 97.75,132.42 v1(97.44,132.11)
PCH_RSMRST#: length 13.7
  BOTTOM w0.076: 141.31,106.31 141.16,106.47 141.16,107.8 U45.AW6
  BOTTOM w0.089: 141.31,106.31 141.57,106.05 143.47,106.05
  BOTTOM w0.14: 143.47,106.05 143.7,105.83 144.18,105.83 145.68,104.33 147.41,104.33 147.79,103.95 v1(147.79,103.69) 148.08,103.4 148.08,102.82 R663.1 148.75,102.15 148.75,101.58 148.55,101.38 R678.2
PCH_SLP_A#: length 64.1
  IN2 w0.114: v1(149.89,64.98) 150.12,65.21 150.12,66.38 152.49,68.74 152.49,71.33 152.87,71.72 152.87,72.88 152.64,73.1 152.64,74.93 151,76.58 151,78.13 151.41,78.53 151.41,83.11 152.61,84.31 152.61,85.58 148.68,89.52 148.68,93.98 147.93,94.73 147.93,96.4 147.36,96.97 143.94,96.97 142.06,98.85 142.06,102.34 142.83,103.11 142.83,103.87 142.33,104.38 142.33,105.22 144.24,107.13 144.24,113.66 143.81,114.09 142.18,114.09 v1(141.89,113.8)
  BOTTOM w0.102: v1(141.89,113.8) 141.92,113.77 U45.AL5
  BOTTOM w0.14: v1(149.89,64.98) 149.63,64.98 149.39,64.74 149.39,64.28 R733.2
PCH_SLP_LAN#: length 3.2
  TOP w0.14: TP67.1 139.91,115.68 140.42,115.17 140.42,114.61 v1(141.21,113.83)
  BOTTOM w0.102: U45.AJ7 140.89,114.15 v1(141.21,113.83)
PCH_SLP_S0#: length 74.1
  TOP w0.14: v1(147.66,114.18) 148.04,114.56 148.04,115.28 v1(149.68,116.93)
  IN2 w0.114: v1(147.66,114.18) 147.13,113.65 145.98,113.65 144.67,112.33 144.67,106.21 143.09,104.63 143.09,102.85 142.33,102.09 142.33,98.89 143.17,98.05 145.53,98.05 146.06,97.52 147.66,97.52 149.38,95.8 149.38,89.43 153.04,85.76 153.04,80.12 151.84,78.92 151.84,78.35 151.43,77.95 151.43,76.76 153.08,75.11 153.08,73.04 153.42,72.7 153.42,71.73 152.7,71.02 152.7,68.65 150.58,66.53 150.58,65.26 150.33,65.01 150.33,64.07 149.74,63.48 146.26,63.48 145.52,64.22 v1(145.52,64.88)
  BOTTOM w0.14: R727.2 144.83,64.06 145.52,64.75 v1(145.52,64.88) ; R598.1 149.66,116.95 v1(149.68,116.93)
PCH_SLP_S0#_R: length 5.6
  BOTTOM w0.076: U45.AF3 143.78,115.82 144.3,115.82 144.53,116.05 144.53,116.23 144.7,116.4 146.44,116.4 146.62,116.22 147.19,116.22 147.4,116.43 147.52,116.43 148.04,116.95 R598.2
PCH_SLP_S5#: length 60.2
  IN2 w0.114: v1(142.43,111.81) 143.21,111.03 143.21,106.41 142.07,105.27 142.07,103.74 141.85,103.52 141.85,98.76 143.85,96.75 147.25,96.75 147.71,96.3 147.71,94.64 148.46,93.89 148.46,89.43 152.27,85.62 152.27,84.57 151.19,83.49 151.19,80.54 150.5,79.85 150.5,77.76 150.07,77.33 150.07,76.81 151.79,75.09 151.79,73.29 152.49,72.59 152.49,71.64 152.18,71.33 152.18,68.77 149.79,66.38 149.79,65.77 149.39,65.36 149.39,64.88 v1(149.89,64.37)
  BOTTOM w0.102: v1(142.43,111.81) 142.42,111.81 141.95,111.35 U45.AP5
  BOTTOM w0.14: R735.2 150.59,63.68 v1(149.89,64.37)
PCH_SLP_SUS#: length 90.7
  TOP w0.14: v1(147.93,56.91) 148.36,56.47 150.95,56.47 151.96,55.46 154.41,55.46 155.07,56.13 U32.71 ; v1(159.72,88.5) 158.2,86.98 Q24.2
  IN3 w0.089: v1(147.93,56.91) 148.94,57.92 148.94,63.46 148.39,64.01 148.39,65.74 148.69,66.04 148.69,67.82 149.44,68.56 149.44,69.2 150.6,70.36 152.67,70.36 152.93,70.11 154.42,70.11 155.41,71.1 155.41,71.43 156.14,72.16 157.83,72.16 161.77,76.1 161.77,76.44 163.79,78.46 163.79,80.12 161.69,82.22 161.69,86.53 159.97,88.25 159.97,88.25 159.72,88.49 v1(159.72,88.5) 159.72,89.01 159.59,89.14 159.59,90.98 154.41,96.16 153.34,96.16 151.19,98.31 151.19,99.69 150.36,100.52 150.36,100.79 145.92,105.23 145.92,105.94 145.58,106.28 145.58,109.17 146.01,109.59 v1(146.01,110.45)
  BOTTOM w0.076: v1(146.01,110.45) 145.9,110.45 145.03,111.32 144.63,111.32 144.46,111.16 143.71,111.16 143.63,111.23 143.2,111.23 U45.AP4
PCH_SLP_WLAN#: length 2.3
  TOP w0.14: TP79.1 142.48,113.47 v1(142.48,113.57)
  BOTTOM w0.102: U45.AM5 141.92,112.79 142.48,113.34 v1(142.48,113.57)
PCH_SPI_CLK: length 26.9
  TOP w0.14: R112.2 152.49,124.55 153.22,123.81 153.22,123.45 153.63,123.05 C193.1 153.6,122.78 v1(153.6,122.26)
  IN1 w0.102: 146.54,116.65 146.55,116.63 146.9,116.63
  IN1 w0.114: 146.9,116.63 148.79,116.63 149.18,117.03 149.18,117.33 149.31,117.46 149.84,117.46 149.97,117.33 149.97,117.22 150.09,117.1 150.47,117.1 150.59,117.22 150.59,118.4 150.47,118.53 149.95,118.53 149.82,118.65 149.82,118.91 149.95,119.04 150.45,119.04 150.58,119.17 150.58,119.49 150.76,119.67 150.76,120.25 150.88,120.38 152.61,120.38 152.74,120.25 152.74,119.65 153.25,119.13 153.25,118.13 153.38,118 154.05,118 154.17,118.13 154.17,119.83 154.01,120 153.51,120 153.26,120.25 153.26,121.01 153.6,121.36 v1(153.6,122.26) ; v1(143.82,117.98) 143.96,117.98 144.99,116.95 146.24,116.95 146.54,116.65
  BOTTOM w0.102: v1(143.82,117.98) 143.52,118.28 U45.AA3
PCH_SPI_CLK_EC: length 98.1
  TOP w0.14: v1(160.59,118.7) 160.59,119.64 158.4,121.83 156.5,121.83 156.12,122.21 154.39,122.21 153.97,121.79 153.32,121.79 153.17,121.94 153.17,122.72 152.82,123.07 152.82,123.66 152,124.47 152,126.17 152.49,126.65 R102.1 ; U32.105 151.04,68.59 151.42,68.97 v1(151.72,68.97) ; v1(162.9,85.45) 162.39,85.45 161.2,86.65 161.2,93.15 v1(166.45,98.41)
  IN1 w0.114: v1(160.59,118.7) 160.59,117.79 161.46,116.92 163.69,116.92 164.54,116.07 164.54,113.13 164.3,112.89 163.22,112.89 163.01,112.68 163.01,112.33 163.22,112.12 164.09,112.12 164.3,111.92 164.3,111.57 164.09,111.36 163.22,111.36 163.01,111.16 163.01,110.8 163.22,110.6 164.47,110.6 164.68,110.4 164.68,110.04 164.47,109.84 163.22,109.84 163.01,109.64 163.01,109.28 163.22,109.08 165.62,109.08 165.82,108.87 165.82,108.52 165.62,108.31 163.22,108.31 163.01,108.11 163.01,107.76 163.22,107.55 165.49,107.55 165.69,107.35 165.69,106.99 165.49,106.79 163.22,106.79 163.01,106.59 163.01,101.85 v1(166.45,98.41) ; v1(151.72,68.97) 151.91,68.79 156.07,68.79 156.52,69.23 156.52,69.74 156.92,70.15 156.92,71.41 158.74,73.23 158.74,75.96 160.23,77.45 160.23,80.12 162.9,82.79 v1(162.9,85.45)
PCH_SPI_CS0#: length 34.1
  TOP w0.14: v1(143.16,131.58) 143.65,131.58 v1(144.51,132.44) 144.95,132.88 146.02,132.88 146.57,133.44 146.57,135.3 R85.2 148.29,136.87 148.65,136.51 150.07,136.51 150.2,136.38 154.64,136.38 154.9,136.64 U14.1 154.9,138.54 155.41,139.05 R76.2
  IN3 w0.076: 142.91,120.31 142.61,120.01 141.83,120.01 141.27,119.45 v1(141.24,119.45)
  IN3 w0.089: v1(143.16,131.58) 143.16,130.84 144.25,129.76 144.25,120.75 143.92,120.43 143.03,120.43 142.91,120.31
  BOTTOM w0.102: v1(141.24,119.45) 140.89,119.1 U45.Y7
PCH_SPI_CS1#: length 4.2
  TOP w0.14: TP48.1 145.98,118.88 v1(146.08,118.78)
  BOTTOM w0.076: v1(146.08,118.78) 145.95,118.65 143.68,118.65 143.6,118.73 143.21,118.73 U45.Y4
PCH_SPI_IO2: length 30.6
  TOP w0.14: v1(142.5,131.58) 142.6,131.68 142.6,132.72 144.41,134.53 145.2,134.53 145.83,135.16 145.83,135.75 147.79,137.7 147.79,138.16 v1(148.42,138.79) 150.2,140.57 R74.1
  IN3 w0.076: 143.21,120.08 142.98,119.85 142.29,119.85 v1(141.89,119.45)
  IN3 w0.089: 143.21,120.08 143.34,120.21 144.01,120.21 144.47,120.67 144.47,123.72 144.73,123.98 144.73,129.68 144.01,130.4 144.01,131.52 143.44,132.09 143.01,132.09 v1(142.5,131.58)
  BOTTOM w0.102: U45.Y6 141.54,119.1 v1(141.89,119.45)
PCH_SPI_IO3: length 29.1
  TOP w0.14: R105.1 153.92,126.34 154.49,125.76 156.37,125.76 156.93,125.21 v1(156.93,124.88)
  BOTTOM w0.076: 152.1,116.32 151.95,116.47 147.94,116.47 147.66,116.19 147.41,116.19 147.2,115.99 146.62,115.99 146.37,116.24 144.95,116.24 U45.AF1
  BOTTOM w0.14: v1(156.93,124.88) 156.93,124.44 158.1,123.27 158.11,123.27 158.5,122.88 158.5,122.88 159.09,122.28 159.34,122.28 159.72,121.9 159.72,120.51 158.94,119.73 158.94,116.8 158.61,116.47 156.83,116.47 156,115.64 152.78,115.64 152.1,116.32
PCH_SPI_SI: length 28.8
  TOP w0.14: R111.2 151.34,124.22 152.15,123.4 152.15,122.72 v1(152.59,122.28)
  IN1 w0.114: v1(146.01,118.17) 147.98,118.17 148.11,118.04 148.11,117.46 148.23,117.33 148.45,117.33 148.57,117.46 148.57,118.04 148.7,118.17 149.07,118.17 149.2,118.3 149.2,118.98 149.07,119.11 148.02,119.11 147.89,119.24 147.89,119.49 148.02,119.62 148.29,119.62 148.41,119.74 148.41,120.64 148.13,120.92 148.13,121.94 148.26,122.07 148.55,122.07 148.68,121.94 148.68,121.27 148.8,121.14 149.36,121.14 149.49,121.01 149.49,120.76 149.36,120.63 149.06,120.63 148.93,120.51 148.93,120 149.06,119.87 150,119.87 150.13,120 150.13,121.56 150.25,121.68 150.5,121.68 150.63,121.56 150.63,121.13 150.76,121 152.52,121 152.65,121.13 152.65,121.4 152.52,121.52 151.27,121.52 151.14,121.65 151.14,121.88 151.27,122.01 152.31,122.01 v1(152.59,122.28)
  BOTTOM w0.076: U45.AA2 144.55,117.98 144.87,117.98 145.13,117.72 145.56,117.72 v1(146.01,118.17)
PCH_SPI_SI_EC: length 98.3
  TOP w0.14: v1(166.96,97.79) 161.89,92.71 161.89,87.1 v1(162.9,86.09) ; U32.102 152.24,68.57 152.29,68.63 152.29,69.26 151.93,69.63 v1(151.72,69.63) 151.72,69.83 R314.1 ; v1(159.39,118.86) 159.22,118.86 158.91,119.16 158.91,119.67 157.44,121.14 152.84,121.14 151.22,122.77 151.22,123.55 150.88,123.89 150.88,124.44 150.76,124.57 150.76,127.69 R100.1
  IN1 w0.114: v1(151.72,69.63) 154.85,69.63 156.04,70.82 156.04,71.51 156.2,71.67 156.3,71.67 157.98,73.35 157.98,76.28 159.6,77.9 159.6,80.37 162.01,82.79 162.01,85.71 162.39,86.09 v1(162.9,86.09) ; v1(166.96,97.79) 166.2,97.79 162.39,101.59 162.39,111.16 162.19,111.36 160.69,111.36 160.49,111.57 160.49,111.92 160.69,112.12 162.19,112.12 162.39,112.33 162.39,112.68 162.19,112.89 160.56,112.89 160.36,113.09 160.36,113.45 160.56,113.65 163.71,113.65 163.92,113.85 163.92,114.21 163.71,114.41 160.56,114.41 160.36,114.61 160.36,114.97 160.56,115.17 163.44,115.17 163.64,115.38 163.64,116.09 163.44,116.3 160.51,116.3 159.83,116.98 159.83,118.42 v1(159.39,118.86)
PCH_SPI_SO: length 40.7
  TOP w0.14: v1(144.59,135.59) 144.59,135.59 147.02,138.03 147.02,138.67 v1(149.06,140.7) 149.64,141.28 150.64,141.28 151.59,142.23 153.64,142.23 154.64,141.22 154.64,139.93 R78.1
  IN3 w0.089: v1(144.59,135.59) 144.15,135.16 144.15,134.91 142.1,132.86 142.1,130.25 143.61,128.74 143.61,123.58 142.77,122.74 142.77,121.21 142.45,120.89 140.29,120.89 140.01,120.61 140.01,119.39 140.42,118.98 142.58,118.98 143.17,118.39 v1(143.17,117.98)
  BOTTOM w0.102: v1(143.17,117.98) 142.87,118.28 U45.AA4
PCH_SPI_SO_EC: length 108.6
  TOP w0.14: v1(144.59,134.96) 145.09,134.96 145.47,135.34 145.47,135.98 147.37,137.87 147.37,138.35 149.95,140.93 150.81,140.93 151.77,141.89 153.5,141.89 154.14,141.24 R75.1 ; v1(152.61,66) 151.84,66.77 U32.103
  IN1 w0.114: v1(167.55,86.09) 167.04,85.58 166.58,85.58 164.68,83.68 164.68,79.57 161.22,76.11 161.22,74.38 158.1,71.26 158.1,68.98 156.93,67.8 156.93,66.09 156.25,65.41 153.48,65.41 152.89,66 v1(152.61,66)
  IN3 w0.089: v1(167.55,86.09) 167.42,86.22 167.42,90.21 162.65,94.98 162.65,95.27 162.08,95.83 162.08,96.45 158.56,99.97 158.56,101.81 160.03,103.29 160.03,104.05 160.49,104.5 160.49,105.57 158.78,107.27 158.78,109.41 157.95,110.25 157.95,112 156.07,113.88 156.07,114.72 154.64,116.14 154.64,116.7 154.26,117.08 153.12,117.08 152.87,117.33 152.87,118.6 151.98,119.49 150.81,119.49 150.45,119.85 150.45,121.81 149.94,122.32 149.36,122.32 149.14,122.54 149.14,125.6 148.24,126.5 148.24,127.16 147.66,127.74 147.66,127.87 147.66,128.78 146.72,129.72 146.72,131.61 144.98,133.35 144.6,133.35 144.05,133.89 144.05,134.2 144.59,134.73 v1(144.59,134.96)
  BOTTOM w0.14: v1(152.61,66) 152.65,66.03 R720.1
