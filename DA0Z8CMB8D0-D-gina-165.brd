# Allegro board DA0Z8CMB8D0-D-gina-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ULT_RVSD_61: length 1.3
  TOP w0.14: v1(108.5,124.02) 108.5,124.57 TP24.1
  BOTTOM w0.102: v1(108.5,124.02) 108.8,123.72 U45.L59
ULT_RVSD_62: length 2.2
  TOP w0.14: v1(109.99,125.25) 109.89,125.35 109.89,126.78 TP15.1
  BOTTOM w0.254: U45.J58 v1(109.99,125.25)
ULT_RVSD_63: length 1.4
  TOP w0.14: v1(110.07,122.65) 110.01,122.59 TP31.1
  BOTTOM w0.102: 109.69,122.65 U45.N58
  BOTTOM w0.14: v1(110.07,122.65) 109.69,122.65
ULT_RVSD_64: length 1.4
  TOP w0.14: v1(110.04,117.44) 109.39,117.44 TP56.1
  BOTTOM w0.14: U45.AC58 v1(110.04,117.44)
ULT_RVSD_65: length 6.7
  TOP w0.14: TP58.1 127.59,116.36 127.8,116.36 v1(128.23,115.93)
  BOTTOM w0.14: v1(128.23,115.93) 128.23,116.5 129.08,117.36 130.21,117.36 130.82,117.97 131.51,117.97 U45.AB23
ULT_RVSD_66: length 4.9
  TOP w0.14: TP59.1 128.02,116.77 v1(128.86,115.93)
  BOTTOM w0.14: U45.AD23 129.27,116.96 128.86,116.55 v1(128.86,115.93)
ULT_RVSD_67: length 6.9
  TOP w0.14: v1(127.59,115.93) TP66.1
  BOTTOM w0.14: v1(127.59,115.93) 127.59,116.21 129.07,117.68 130.13,117.68 130.67,118.22 131.35,118.22 U45.AA23
ULT_RVSD_68: length 2.4
  TOP w0.14: v1(109.19,116.63) 109.19,116.33 108.29,115.43 TP73.1
  BOTTOM w0.102: U45.AE59 109,116.32 109,116.44 v1(109.19,116.63)
ULT_RVSD_69: length 1.4
  TOP w0.14: v1(107.86,122.51) 107.86,123 TP29.1
  BOTTOM w0.102: U45.P60 108.15,122.22 v1(107.86,122.51)
ULT_RVSD_70: length 1.7
  TOP w0.14: v1(107.2,122.51) 107.2,122.82 TP27.1
  BOTTOM w0.102: v1(107.2,122.51) 107.5,122.21 U45.P61
ULT_RVSD_71: length 1.4
  TOP w0.14: TP25.1 109.41,123.52 v1(109.23,123.34)
  BOTTOM w0.102: U45.N59 108.82,122.93 v1(109.23,123.34)
ULT_RVSD_72: length 7.3
  BOTTOM w0.076: U45.N61 107.24,123.19 105.09,123.19 104.67,122.77 104.12,122.77 103.86,122.5 103.83,122.5 103.72,122.39 103.72,122.08
  BOTTOM w0.14: TP125.1 101.84,121.68 103.31,121.68 103.72,122.08
ULT_RVSD_73: length 1.4
  TOP w0.14: v1(109.24,121.85) 109.31,121.78 TP37.1
  BOTTOM w0.102: v1(109.24,121.85) 109.21,121.85 U45.T59
ULT_RVSD_74: length 2.3
  TOP w0.14: TP72.1 106.64,115.32 v1(107.85,116.52)
  BOTTOM w0.102: U45.AD60 108.15,116.82 v1(107.85,116.52)
ULT_RVSD_75: length 3.2
  TOP w0.14: TP75.1 107.43,115.45 v1(108.5,116.52)
  BOTTOM w0.102: U45.AD59 108.8,116.82 v1(108.5,116.52)
ULT_RVSD_76: length 1.3
  TOP w0.14: v1(109.22,118.12) 109.31,118.21 TP49.1
  BOTTOM w0.102: v1(109.22,118.12) 108.91,118.44 U45.AA59
ULT_RVSD_77: length 10.6
  TOP w0.14: TP54.1 99.66,116.72 v1(100.88,116.72)
  BOTTOM w0.076: v1(100.88,116.72) 101.54,116.06 103.53,116.06 103.77,115.82 105.8,115.82 105.93,115.69 106.3,115.69 106.35,115.71 106.46,115.76 107.8,115.76 U45.AE60
ULT_RVSD_78: length 1.4
  TOP w0.14: v1(108.5,118.02) 108.5,117.77 TP57.1
  BOTTOM w0.102: U45.AC59 108.8,117.72 v1(108.5,118.02)
ULT_RVSD_79: length 1.4
  TOP w0.14: TP71.1 109.68,115.61 v1(109.18,115.61)
  BOTTOM w0.102: v1(109.18,115.61) 109.13,115.56 U45.AG58
ULT_RVSD_80: length 1.4
  TOP w0.14: v1(108.5,121.02) 108.5,121.44 TP34.1
  BOTTOM w0.102: U45.U59 108.8,120.72 v1(108.5,121.02)
ULT_RVSD_81: length 2
  TOP w0.14: v1(109.15,119.58) 108.34,118.77 TP50.1
  BOTTOM w0.102: U45.V59 108.82,119.93 109.15,119.6 v1(109.15,119.58)
URDBG: length 1.9
  BOTTOM w0.14: U40.28 104.97,147.95 105.37,147.56 TP105.1
USB3_RXN0: length 142.3
  TOP w0.14: v1(230.31,81.14) 230.08,80.91 230.08,80.37 231.11,79.35 231.11,78.71 v1(231.61,78.22) 231.11,77.72 231.11,75.41 231.25,75.27 231.83,75.27 231.98,75.41 R296.2
  IN1 w0.102: v1(133.25,126.51) 133.48,126.28 133.63,126.28 133.83,126.48 134.25,126.48 134.48,126.7 134.48,128.19 134.87,128.58 135.51,128.58 136.96,130.03 140.7,130.03 141.84,131.17 143.22,131.17 144.75,129.65 145.88,129.65 146.14,129.4 156.02,129.4 170.77,114.65 170.77,106.72 181.7,95.8 181.7,94.47 185.53,90.64 193.48,90.64 194.32,91.47 197.85,91.47 198.53,92.16 205.68,92.16 206.23,91.6 207.95,91.6 208.92,92.57 219.16,92.57 220.05,93.46 223,93.46 224.02,92.44 226.22,92.44 228.56,90.1 228.56,82.06 228.77,81.85 229.79,81.85 230.01,81.63 230.01,81.44 v1(230.31,81.14)
  BOTTOM w0.102: U45.G20 133.3,126.51 v1(133.25,126.51)
USB3_RXN0_R: length 7.5
  TOP w0.14: R296.1 233.13,75.3 233.4,75.3 D10.1 234.39,75.29 235.04,75.29 v1(235.54,75.8) 236.05,75.29 236.78,75.29 237.53,76.04 238.07,76.04 238.23,76.21 CN13.5
USB3_RXN1: length 131.4
  TOP w0.14: v1(228.99,94.09) 228.99,93.91 229.14,93.77 230.53,93.77 231.28,93.02 231.96,93.02 232.11,93.18 232.11,93.45 R249.2
  IN1 w0.102: v1(134.07,127.81) 133.97,127.81 133.87,127.91 133.87,128 134.45,128.58 134.45,128.89 136.56,131 137.17,131 137.5,130.67 140.34,130.67 140.95,131.28 140.95,131.63 141.31,131.99 143.36,131.99 144.3,131.05 145.12,131.05 145.81,130.35 146.11,130.35 146.58,129.88 156.24,129.88 171.46,114.66 171.46,106.77 182.28,95.95 182.28,94.69 185.85,91.12 193.23,91.12 194.17,92.06 197.11,92.06 197.72,92.67 202.85,92.67 203.23,93.05 203.79,93.05 204.12,92.72 208.27,92.72 208.6,93.05 218.79,93.05 219.7,93.96 220.96,93.96 223,96 223.49,96 223.79,96.3 228.51,96.3 229.52,95.28 229.52,93.84 229.42,93.74 229.09,93.74 228.99,93.84 v1(228.99,94.09)
  BOTTOM w0.102: v1(134.07,127.81) 134.07,128.05 134.2,128.18 134.4,128.18 134.6,127.98 U45.E18
USB3_RXN1_R: length 7.6
  TOP w0.14: R249.1 233.13,93.21 233.4,93.21 D6.1 234.39,93.2 235.04,93.2 v1(235.54,93.71) 236.05,93.2 236.69,93.2 237.54,94.05 238.1,94.05 238.23,94.19 CN8.5
USB3_RXP0: length 142.2
  TOP w0.14: v1(229.55,81.14) 229.82,80.87 229.82,80.26 230.84,79.24 230.84,78.72 v1(230.34,78.22) 230.84,77.71 230.84,75.3 231.14,75 231.64,75 R302.2
  IN1 w0.102: v1(133.23,125.88) 133.42,126.07 133.72,126.07 133.92,126.27 134.33,126.27 134.68,126.62 134.68,128.1 134.96,128.38 135.59,128.38 137.04,129.83 140.78,129.83 141.93,130.97 143.14,130.97 144.66,129.45 145.8,129.45 146.05,129.19 155.94,129.19 170.57,114.56 170.57,106.64 181.49,95.72 181.49,94.39 185.45,90.43 193.57,90.43 194.4,91.27 197.93,91.27 198.62,91.95 205.59,91.95 206.15,91.4 208.03,91.4 209,92.36 219.24,92.36 220.13,93.25 222.92,93.25 223.94,92.24 226.14,92.24 228.35,90.02 228.35,81.98 228.69,81.64 229.7,81.64 229.8,81.54 229.8,81.39 v1(229.55,81.14)
  BOTTOM w0.102: v1(133.23,125.88) 133.6,125.5 U45.H20
USB3_RXP0_R: length 7.5
  TOP w0.14: CN13.6 238.23,75.64 238.09,75.78 237.64,75.78 236.89,75.03 236.04,75.03 v1(235.54,74.53) 235.05,75.03 234.38,75.03 D11.1 233.4,75.03 233.13,75.03 R302.1
USB3_RXP1: length 131.4
  TOP w0.14: v1(228.99,93.33) 229.16,93.5 230.42,93.5 231.17,92.76 231.79,92.76 R256.2
  IN1 w0.102: v1(228.99,93.33) 229.19,93.53 229.51,93.53 229.73,93.75 229.73,95.37 228.59,96.5 223.71,96.5 223.4,96.2 222.91,96.2 220.88,94.17 219.62,94.17 218.7,93.25 208.52,93.25 208.19,92.92 204.21,92.92 203.88,93.25 203.15,93.25 202.77,92.87 197.64,92.87 197.03,92.26 194.08,92.26 193.14,91.32 185.94,91.32 182.48,94.78 182.48,96.03 171.66,106.85 171.66,114.75 156.33,130.08 146.67,130.08 146.19,130.56 145.9,130.56 145.2,131.25 144.38,131.25 143.44,132.19 141.22,132.19 140.75,131.72 140.75,131.36 140.26,130.87 137.58,130.87 137.25,131.2 136.47,131.2 134.25,128.97 134.25,128.67 133.66,128.08 133.66,127.53 v1(134.07,127.12)
  BOTTOM w0.102: v1(134.07,127.12) 134.39,126.81 U45.F18
USB3_RXP1_R: length 7.6
  TOP w0.14: R256.1 233.13,92.94 233.4,92.94 D7.1 234.38,92.94 235.05,92.94 v1(235.54,92.44) 236.04,92.94 236.8,92.94 237.65,93.79 238.08,93.79 238.23,93.64 CN8.6
USB3_TXN0: length 158.8
  TOP w0.14: C370.1 229.73,70.89 229.48,70.89 229.33,71.04 229.33,73.39 229.64,73.69 229.64,76.22 v1(229.85,76.44)
  IN3 w0.089: v1(229.85,76.44) 229.55,76.74 229.55,76.97 229.24,77.28 227.97,77.28 226.82,76.13 223.27,76.13 222.33,75.19 209.62,75.19 205.76,79.05 202.99,79.05 201.08,80.96 199.46,80.96 195.37,85.05 192.46,85.05 192.27,84.86 183.66,84.86 179.82,88.71 178.7,88.71 163.09,104.31 163.09,108.25 162.52,108.82 162.52,111.36 158.91,114.97 158.91,116.02 158.28,116.65 157.24,116.65 154.97,118.91 154.97,119.45 154.3,120.13 153.76,120.13 153.2,120.68 153.2,122.67 152.13,123.73 152.13,125.69 149.28,128.53 149.28,129.5 148.34,130.44 148.34,133.57 146.41,135.5 146.41,136.11 145,137.52 141.4,137.52 140.64,136.76 140.01,136.76 138.77,135.53 138.77,133.97 137.25,132.44 133.73,132.44 130.89,129.6 127.42,129.6 126.61,130.41 124.93,130.41 124.39,130.95 124.39,131.44 124.12,131.71 123.95,131.71 v1(123.77,131.89)
  BOTTOM w0.076: v1(123.77,131.89) 123.99,131.67 124.17,131.67 124.42,131.43 124.42,131.05 124.8,130.67 124.8,129.24 125.1,128.95 U45.C33
USB3_TXN0_C: length 1.6
  TOP w0.14: C370.2 231.1,70.73 231.61,70.73 231.98,71.1 R311.2
USB3_TXN0_R: length 7.5
  TOP w0.14: CN13.8 238.23,70.18 238.09,70.04 237.71,70.04 237.03,70.73 236.04,70.73 v1(235.54,71.23) 235.04,70.73 234.38,70.73 D12.1 233.4,70.73 233.13,70.73 R311.1
USB3_TXN1: length 162
  TOP w0.14: v1(228.3,80.12) 228.42,80.24 228.42,87.86 229.38,88.82 229.76,88.82 C305.1
  IN3 w0.089: v1(124.88,131.91) 125.12,131.67 125.39,131.67 125.98,132.27 132.41,132.27 133.6,133.46 135.94,133.46 136.84,134.36 136.84,135.45 137.47,136.08 138.05,136.08 138.72,136.75 138.72,138.32 139.4,139 139.95,139 141.22,140.27 145,140.27 146.55,138.71 146.55,137.42 149.16,134.82 149.16,130.77 150.83,129.09 150.83,128.29 151.6,127.52 152.01,127.52 152.94,126.59 152.94,124.06 154.21,122.79 154.21,121.35 155.34,120.23 156.74,120.23 157.31,119.65 157.31,118.31 157.78,117.84 158.33,117.84 159.8,116.37 159.8,115.35 163.36,111.79 163.36,109.13 164.11,108.38 164.11,104.57 179.23,89.44 180.06,89.44 183.97,85.53 191.8,85.53 192.13,85.86 195.7,85.86 199.79,81.77 201.38,81.77 203.21,79.94 206.64,79.94 207.22,79.36 207.22,78.76 209.67,76.31 216.54,76.31 217.04,76.81 220.39,76.81 221.74,78.17 227.08,78.17 228.48,79.57 228.48,79.94 v1(228.3,80.12)
  BOTTOM w0.076: U45.B33 125.1,129.46 125.64,130 125.64,130.36 125.53,130.47 125.53,131.49 125.32,131.7 125.09,131.7 v1(124.88,131.91)
USB3_TXN1_C: length 1.6
  TOP w0.14: R276.2 231.6,88.64 231.1,88.64 C305.2
USB3_TXN1_R: length 7.5
  TOP w0.14: R276.1 233.13,88.64 233.4,88.64 D8.1 234.38,88.64 235.17,88.64 v1(235.67,89.14) 236.17,88.64 237.16,88.64 237.78,88.02 238.03,88.02 238.23,88.22 CN8.8
USB3_TXP0: length 158.8
  TOP w0.14: v1(229.09,76.44) 229.37,76.16 229.37,73.81 229.07,73.5 229.07,70.93 229.37,70.62 229.77,70.62 229.95,70.45 C377.1
  IN3 w0.089: v1(123.77,131.26) 123.77,131.41 123.86,131.51 124.04,131.51 124.19,131.35 124.19,130.86 124.84,130.21 126.53,130.21 127.34,129.4 130.97,129.4 133.82,132.24 137.33,132.24 138.97,133.88 138.97,135.44 140.09,136.56 140.72,136.56 141.49,137.32 144.92,137.32 146.21,136.03 146.21,135.42 148.14,133.49 148.14,130.35 149.08,129.41 149.08,128.45 151.93,125.6 151.93,123.65 152.99,122.58 152.99,120.6 153.67,119.92 154.21,119.92 154.77,119.36 154.77,118.83 157.16,116.44 158.2,116.44 158.71,115.93 158.71,114.89 162.31,111.28 162.31,108.74 162.89,108.17 162.89,104.23 178.61,88.5 179.73,88.5 183.58,84.65 192.36,84.65 192.55,84.85 195.28,84.85 199.37,80.76 201,80.76 202.9,78.85 205.67,78.85 209.53,74.99 222.41,74.99 223.35,75.93 226.91,75.93 228.05,77.07 229.16,77.07 229.35,76.89 229.35,76.69 v1(229.09,76.44)
  BOTTOM w0.076: U45.B34 124.64,129.21 124.64,130.6 124.25,130.98 124.25,131.36 124.1,131.51 123.86,131.51 123.77,131.42 v1(123.77,131.26)
USB3_TXP0_C: length 1.6
  TOP w0.14: R321.2 231.98,70.1 231.61,70.46 231.1,70.46 C377.2
USB3_TXP0_R: length 7.5
  TOP w0.14: CN13.9 238.23,69.64 238.09,69.78 237.6,69.78 236.92,70.46 236.04,70.46 v1(235.54,69.96) 235.04,70.46 234.38,70.46 D13.1 233.4,70.46 233.13,70.46 R321.1
USB3_TXP1: length 162
  TOP w0.14: C308.1 229.95,88.45 229.84,88.55 229.49,88.55 228.69,87.74 228.69,80.37 v1(228.94,80.12)
  IN3 w0.089: v1(124.88,131.28) 125.07,131.47 125.47,131.47 126.07,132.06 132.5,132.06 133.69,133.26 136.03,133.26 137.04,134.27 137.04,135.37 137.55,135.87 138.13,135.87 138.92,136.66 138.92,138.24 139.48,138.79 140.04,138.79 141.31,140.06 144.92,140.06 146.35,138.63 146.35,137.33 148.95,134.73 148.95,130.68 150.63,129.01 150.63,128.2 151.52,127.31 151.93,127.31 152.74,126.5 152.74,123.98 154.01,122.71 154.01,121.27 155.25,120.02 156.65,120.02 157.11,119.57 157.11,118.22 157.7,117.63 158.25,117.63 159.6,116.28 159.6,115.27 163.15,111.71 163.15,109.04 163.9,108.29 163.9,104.48 179.15,89.24 179.97,89.24 183.88,85.33 191.88,85.33 192.21,85.66 195.61,85.66 199.7,81.57 201.3,81.57 203.12,79.74 206.55,79.74 207.02,79.27 207.02,78.67 209.58,76.11 216.63,76.11 217.13,76.61 220.47,76.61 221.83,77.96 227.16,77.96 228.69,79.49 228.69,79.99 228.81,80.12 v1(228.94,80.12)
  BOTTOM w0.076: v1(124.88,131.28) 124.88,131.43 124.98,131.53 125.25,131.53 125.36,131.42 125.36,130.41 125.47,130.29 125.47,130.07 125.31,129.9 125.18,129.9 125.1,129.99 U45.A33
USB3_TXP1_C: length 1.6
  TOP w0.14: R281.2 231.6,88.37 231.1,88.37 C308.2
USB3_TXP1_R: length 7.5
  TOP w0.14: CN8.9 238.23,87.59 238.06,87.75 237.67,87.75 237.05,88.37 236.17,88.37 v1(235.67,87.87) 235.17,88.37 234.38,88.37 D9.1 233.4,88.37 233.13,88.37 R281.1
USB_BC_EN: length 7.8
  TOP w0.14: R329.2 227.42,66.16 v1(227.54,66.28) ; U26.4 228.16,65.66 v1(227.54,66.28) ; v1(227.54,66.28) 227.67,66.4 v1(227.67,67.17)
  BOTTOM w0.14: R792.1 225.33,64.31 U49.4 227.23,64.31 227.54,64.63 v1(227.54,66.28)
USB_BC_ON: length 108.1
  TOP w0.14: U32.97 154.24,68.54 154.77,69.07 155.74,69.07 v1(155.86,69.2) ; U26.1 229.97,64.36 229.45,64.88 227.95,64.88 227.45,65.38 R329.1 226.91,65.39 226.27,66.02 v1(226.27,67.55)
  IN2 w0.114: v1(226.27,67.55) 226.15,67.42 222.34,67.42 218.6,71.15 215.3,71.15 212.15,74.31 212.15,76.97 211.98,77.14 211.98,80.98 210.84,82.12 210.18,82.12 205.57,86.72 203.29,86.72 199.11,90.9 194.63,90.9 193.8,90.07 167.51,90.07 163.53,86.09 163.53,85.15 163.1,84.72 163.1,82.2 163.53,81.77 163.53,78.52 157.18,72.17 157.18,70.46 156.42,69.69 156.42,69.45 156.16,69.2 v1(155.86,69.2)
USB_CHARGE_ON: length 111.3
  TOP w0.14: U32.96 156.65,66.13 v1(157.95,67.42) 157.43,67.42 157.18,67.66 v1(157.18,67.67) ; v1(196.36,46.16) 196.36,43.48 199.48,40.37 206.33,40.37 207.25,41.28 217.11,41.28 219.53,43.7 219.53,47.35 223.22,51.05 223.22,61.45 221.07,63.61 221.07,67.05 R326.2
  IN1 w0.114: v1(157.95,67.42) 159,66.36 159,63.78 163.15,59.63 163.15,53.78 166.25,50.68 170.14,50.68 171.54,49.29 187.26,49.29 189.82,46.73 195.8,46.73 v1(196.36,46.16)
USB_OC0#: length 160.8
  IN2 w0.114: v1(169.88,86.98) 170.06,87.16 181.77,87.16 182.68,86.25 185.28,86.25 187.13,88.1 197.39,88.1 202.75,82.74 205.54,82.74 209.2,79.08 209.2,74 212.61,70.6 218.4,70.6 222.28,66.71 227.75,66.71 v1(228.22,66.24) ; v1(147.07,112.79) 148.57,114.28 151.62,114.28 152,113.9 153.63,113.9 154.01,114.28 155.03,114.28 157.06,116.32 158.15,116.32 158.68,116.85 158.68,117.92 158.99,118.22 v1(159.39,118.22) 159.44,118.17 159.44,116.82 159.11,116.49 159.11,114.18 159.44,113.85 159.44,112.12 158.4,111.08 v1(158.4,110.75)
  IN3 w0.089: v1(228.22,66.24) 229.96,67.97 229.96,72.75 231.33,74.13 231.33,77.3 231.99,77.96 231.99,79.6 v1(233.57,81.19)
  BOTTOM w0.076: 146.87,112.79 146.34,113.32 145.03,113.32 144.95,113.4 144.7,113.4 144.51,113.21 144.51,113.04 144.3,112.82 143.78,112.82 U45.AL3
  BOTTOM w0.14: v1(159.39,118.22) 161.04,116.57 164.68,116.57 167.6,113.65 167.6,96.63 169.5,94.73 169.5,87.36 v1(169.88,86.98) ; U49.3 228.54,64.31 228.22,64.64 v1(228.22,66.24) ; v1(147.07,112.79) 146.87,112.79 ; v1(158.4,110.75) 158.07,110.42 158.07,109.7 158.44,109.33 159.13,109.33 ; U48.3 v1(233.57,81.19)
USB_OC1#: length 412
  TOP w0.14: v1(161.3,110.78) 161.3,107.32 161.98,106.64 161.98,105.42 v1(160.49,103.92) ; v1(18.35,114) 18.17,113.83 15.4,113.83 12.91,116.32 v1(12.28,116.32) 12.21,116.38 U18.3 ; v1(238.21,110.47) 238.91,110.47 239.29,110.85 U19.3
  IN1 w0.114: v1(18.35,114) 18.96,113.39 22.18,113.39 26.05,109.53 26.05,100.28 29.9,96.43 29.9,94.98 30.7,94.19 30.7,91.18 29.02,89.5 29.02,49.62 31.59,47.04 40.03,47.04 41.11,48.12 41.11,48.37 41.49,48.75 50.05,48.75 50.52,49.22 53.11,49.22 54.8,50.91 61.46,50.91 62.04,50.33 63.7,50.33 63.81,50.44 64.83,50.44 65.16,50.1 66.93,50.1 67.52,49.51 70.21,49.51 72.01,47.7 89.11,47.7 90.59,49.18 96.17,49.18 96.82,48.54 106.47,48.54 107.53,47.48 109.81,47.48 110.6,46.69 118.85,46.69 120.41,48.24 128.98,48.24 131.73,51 144.47,51 145.66,52.19 148.08,52.19 148.93,53.04 148.93,54.78 148.52,55.18 146.55,55.18 143.59,58.15 142.89,58.15 141.87,59.17 141.87,59.86 140.93,60.8 140.93,65.95 143.98,69 143.98,69.68 145.04,70.75 146.67,70.75 147.25,71.33 147.95,71.33 148.96,72.34 149.8,72.34 150.44,72.98 152.3,72.98 152.94,73.63 152.94,83.25 154.69,84.99 155.96,84.99 v1(157.06,86.09)
  IN2 w0.114: v1(238.21,110.47) 237.19,109.46 237.19,108.21 225.87,96.88 223.1,96.88 220.81,94.6 216.24,94.6 215.91,94.93 212.12,94.93 211.79,94.6 204.39,94.6 203.25,93.46 194.65,93.46 192.44,91.25 183.14,91.25 180.8,93.58 179.66,93.58 162.47,110.78 v1(161.3,110.78)
  BOTTOM w0.089: U45.AT1 144.94,110.08 145.61,109.41 146.31,109.41 146.49,109.23 146.49,108.57 147.53,107.53
  BOTTOM w0.14: 147.53,107.53 147.63,107.43 147.96,107.43 148.74,106.65 149.45,106.65 150.21,105.89 152.22,105.89 152.74,106.41 153.76,106.41 154.52,105.65 157.46,105.65 158.35,106.54 158.35,108.46 158.58,108.7 RP2.8 159.8,108.7 159.96,108.85 159.96,110.1 160.21,110.35 160.87,110.35 v1(161.3,110.78) ; v1(160.49,103.92) 160.49,103.49 160.16,103.16 160.16,97.85 159.09,96.78 159.09,95.74 163.41,91.42 164.17,91.42 164.98,90.61 164.98,88.55 163.28,86.85 157.82,86.85 v1(157.06,86.09)
USB_OC2#: length 30.5
  BOTTOM w0.076: 147.38,114.79 146.59,114.79 146.15,115.23 145.71,115.23 145.55,115.07 144.63,115.07 144.18,114.61 U45.AH2
  BOTTOM w0.14: RP2.7 159.67,108.06 159.88,107.86 159.88,107.04 160.03,106.89 162.21,106.89 162.54,107.22 162.54,107.91 161.91,108.54 161.91,110.84 161.46,111.29 161.04,111.29 160.87,111.11 v1(160.74,111.11) 160.36,111.11 160.18,111.29 157.27,111.29 157.13,111.43 155.84,111.43 155.43,111.83 155.43,113.56 155.09,113.9 153.45,113.9 153.25,114.11 153.25,114.87 152.9,115.21 151.82,115.21 151.61,115.43 151.29,115.43 151.09,115.63 150.3,115.63 149.86,115.19 147.93,115.19 147.79,115.05 147.63,115.05 147.38,114.79
USB_OC3#: length 18.7
  BOTTOM w0.076: 145.24,107.82 145.24,108.2 145.01,108.43 144.31,108.43 144.3,108.44 144,108.44 143.67,108.77 U45.AV3
  BOTTOM w0.14: 145.24,107.82 146.14,106.92 147.79,106.92 148.55,106.16 149.18,106.16 149.95,105.39 158.07,105.39 v1(158.96,106.28) 159.13,106.45 RP2.6
USBCOMP: length 12.4
  TOP w0.254: v1(138.05,113.46) 138.05,113.43 138.74,112.73 138.74,107.58 v1(139.15,107.17) 139.28,107.04 139.28,106.04 139.96,105.35 139.96,104.32 R207.1
  BOTTOM w0.254: v1(138.05,113.46) 138.05,113.64 U45.AJ11 138.44,114.03 139.09,114.03 U45.AJ10
USBON#: length 400.1
  TOP w0.14: v1(153.45,58.78) 153.86,59.19 154.89,59.19 155.03,59.33 U32.79 ; U19.4 v1(237.7,109.27) ; U18.4 12.21,119.3 11.77,118.86 8.34,118.86 v1(7.2,117.71) 6.94,117.46 6.94,114.41 8.21,113.14 12.4,113.14 12.81,113.55 19.03,113.55 20.79,115.3 21.93,115.3 22.82,116.19 22.82,117.2 23.28,117.66 26.81,117.66 27.14,117.33 27.14,116.82 v1(27.9,116.06)
  IN2 w0.114: v1(237.7,109.27) 237.7,108.39 228.56,99.25 228.56,91.04 228.3,90.79 228.3,81.64 229.57,80.37 v1(229.57,79.08) 229.57,78.32 228.43,77.17 228.43,68.06 227.42,67.04 222.34,67.04 218.53,70.85 215.22,70.85 211.67,74.41 211.67,75.29 210.52,76.44 210.52,79.79 208.3,82.01 208.2,82.01 205.65,84.57 201.91,84.57 197.6,88.88 167.85,88.88 164.64,85.67 164.64,76.45 163.83,75.64 161.97,75.64 158.12,71.79 158.12,69.25 157.75,68.88 157.12,68.88 156,67.76 156,67.27 155.57,66.85 155.57,63.52 153.96,61.91 153.96,60.64 153.45,60.13 v1(153.45,58.78) 152.88,58.21 151.1,58.21 150.86,57.97 150.86,55.43 150.35,54.93 149.31,54.93 148.78,55.45 140.9,55.45 139.51,54.06 138.21,54.06 v1(137.75,54.52)
  IN3 w0.089: v1(27.9,116.06) 29.91,114.05 31.26,114.05 31.79,113.52 34.2,111.11 34.2,107.6 34.73,107.07 34.73,103.34 33.61,102.21 33.61,100.14 34.75,98.99 34.75,95.63 35.83,94.55 35.83,80.41 33.42,78.01 33.42,66.8 33.58,66.64 33.58,57.04 34.31,56.31 34.31,54.03 35.75,52.58 40.91,52.58 41.55,51.93 48.87,51.93 50.81,49.99 60.05,49.99 61.53,48.51 63.15,48.51 63.78,47.88 65.86,47.88 66.16,47.58 68.06,47.58 68.63,47 88.79,47 91.56,49.78 104.46,49.78 104.78,50.1 105.43,50.1 106.12,50.79 111.87,50.79 113.23,49.43 119.46,49.43 120.01,49.98 128.83,49.98 130.44,51.59 132.16,51.59 133.87,53.3 136.38,53.3 137.6,54.52 v1(137.75,54.52)
  BOTTOM w0.14: v1(229.57,79.08) 229.57,80.22 230.03,80.68 233.43,80.68 233.57,80.54 U48.4
USBP0+: length 112.2
  TOP w0.14: v1(223.73,69.45) 223.86,69.32 U25.6
  IN1 w0.102: v1(223.73,69.45) 223.45,69.17 223.35,69.17 223.25,69.28 223.25,70.97 223.68,71.4 223.68,72.55 219.29,76.95 215.38,76.95 212.46,79.87 210.27,79.87 208.44,81.7 208.44,86.9 206.64,88.71 204.21,88.71 203.65,89.26 200.24,89.26 198.48,87.51 184.34,87.51 182,89.85 177.73,89.85 172.08,95.5 163.37,95.5 160.97,97.9 155.79,97.9 154.49,99.2 154.49,100.19 151.72,102.96 151.72,103.62 150.34,105 149.23,105 147.69,106.54 146.01,106.54 143.77,108.77 142.25,108.77 141.94,109.08 141.94,109.46 141.47,109.93 141.25,109.93 140.93,110.25 140.93,111.54 140.65,111.82 140.29,111.82 v1(140.04,112.07)
  BOTTOM w0.089: U45.AM8 140.52,112.06 140.48,112.02 140.09,112.02 v1(140.04,112.07)
USBP0+_C: length 8.8
  TOP w0.14: U25.3 227.28,69.32 v1(227.42,69.45)
  BOTTOM w0.14: v1(227.42,69.45) 227.66,69.21 228.82,69.21 229.43,69.82 229.43,72.23 230.23,73.02 231.61,73.02 R711.2
USBP0+_R: length 4.9
  BOTTOM w0.14: CN13.3 235.84,73.02 234.38,73.02 D31.1 233.4,73.02 233.13,73.02 R711.1
USBP0-: length 111.9
  TOP w0.14: v1(223.73,68.69) 223.86,68.82 U25.7
  IN1 w0.102: v1(140.04,111.46) 140.19,111.62 140.56,111.62 140.72,111.46 140.72,110.16 141.16,109.72 141.39,109.72 141.74,109.37 141.74,108.99 142.16,108.57 143.69,108.57 145.92,106.33 147.61,106.33 149.14,104.8 150.25,104.8 151.52,103.53 151.52,102.87 154.29,100.1 154.29,99.11 155.7,97.7 160.88,97.7 163.28,95.3 172,95.3 177.65,89.65 181.92,89.65 184.25,87.31 198.57,87.31 200.32,89.06 203.56,89.06 204.12,88.5 206.55,88.5 208.24,86.82 208.24,81.61 210.19,79.66 212.38,79.66 215.3,76.74 219.2,76.74 223.48,72.47 223.48,71.48 223.05,71.05 223.05,69.19 223.27,68.97 223.45,68.97 v1(223.73,68.69)
  BOTTOM w0.089: U45.AN8 140.35,111.67 140.14,111.46 v1(140.04,111.46)
USBP0-_C: length 8.9
  TOP w0.14: v1(227.39,68.69) 227.16,68.92 226.88,68.92 226.78,68.82 U25.2
  BOTTOM w0.14: R712.2 231.6,72.75 230.34,72.75 229.7,72.12 229.7,69.71 228.93,68.94 227.64,68.94 v1(227.39,68.69)
USBP0-_R: length 4.9
  BOTTOM w0.14: R712.1 233.13,72.75 233.4,72.75 D32.1 234.38,72.75 235.89,72.75 CN13.2
USBP1+: length 128.9
  IN1 w0.076: v1(141.48,110.37) 141.72,110.61 141.89,110.61 142.03,110.76 142.03,112.09 142.15,112.2 142.67,112.2 142.98,112.51 143.06,112.51 143.08,112.49 143.09,112.49
  IN1 w0.102: v1(231.02,91.83) 231.3,91.55 231.77,91.55 232.32,91 232.32,88.71 231.1,87.49 231.1,80.37 230.23,79.51 218.53,79.51 217.84,78.83 214.69,78.83 213.09,80.43 210.73,80.43 209.05,82.1 209.05,87.51 207.3,89.26 204.5,89.26 203.87,89.9 199.89,89.9 197.98,87.99 184.56,87.99 181.38,91.17 177.22,91.17 172.4,95.98 163.78,95.98 161.3,98.46 156.21,98.46 155.46,99.21 155.46,100.64 155.13,100.97 154.41,100.97 152.83,102.55 152.83,104 151.03,105.8 149.13,105.8 147.89,107.04 146.36,107.04 144.36,109.04 144.36,112.25 144.12,112.49 143.09,112.49
  BOTTOM w0.089: U45.AT7 141.15,110.05 v1(141.48,110.37)
  BOTTOM w0.14: R690.2 231.98,91.68 231.84,91.54 231.32,91.54 v1(231.02,91.83)
USBP1+_R: length 5.5
  BOTTOM w0.14: R690.1 233.13,91.56 233.4,91.56 D29.1 234.43,91.51 235.96,91.51 236.43,91.04 236.59,91.04 236.73,91.18 CN8.3
USBP1-: length 128.9
  IN1 w0.076: 143.09,112.69 143.08,112.69 143.06,112.67 142.91,112.67 142.6,112.37 142.08,112.37 141.87,112.16 141.87,110.83 141.82,110.78 141.72,110.78 v1(141.48,111.02)
  IN1 w0.102: 143.09,112.69 144.21,112.69 144.56,112.34 144.56,109.13 146.44,107.25 147.97,107.25 149.22,106 151.11,106 153.03,104.09 153.03,102.64 154.49,101.18 155.21,101.18 155.66,100.73 155.66,99.3 156.3,98.66 161.38,98.66 163.86,96.19 172.49,96.19 177.3,91.37 181.47,91.37 184.64,88.2 197.9,88.2 199.81,90.1 203.95,90.1 204.59,89.47 207.38,89.47 209.25,87.6 209.25,82.19 210.81,80.63 213.17,80.63 214.77,79.03 217.75,79.03 218.44,79.71 230.15,79.71 230.89,80.46 230.89,87.57 232.11,88.79 232.11,90.92 231.68,91.35 231.3,91.35 v1(231.02,91.07)
  BOTTOM w0.089: v1(141.48,111.02) 141.47,111.03 140.98,111.03 140.78,110.83 140.78,110.64 140.87,110.55 140.99,110.55 141.09,110.64 U45.AR7
  BOTTOM w0.14: R692.2 231.62,91.27 231.22,91.27 v1(231.02,91.07)
USBP1-_R: length 5.5
  BOTTOM w0.14: R692.1 233.13,91.29 233.4,91.29 D30.1 234.34,91.25 235.85,91.25 236.32,90.78 236.59,90.78 236.73,90.64 CN8.2
USBP2+: length 148.5
  TOP w0.14: v1(87.11,107.3) 86.93,107.12 86.62,107.12 84.41,109.33 71.43,109.33 v1(71.26,109.51)
  IN1 w0.102: v1(31.99,115.6) 31.78,115.4 31.78,115.16 35.63,111.31 43.73,111.31 45.08,109.97 51.05,109.97 53.13,107.88 60.99,107.88 62.41,109.31 71.05,109.31 v1(71.26,109.51) ; v1(139.56,111.02) 139.34,110.8 139.19,110.8 138.9,111.1 138.9,112.51 139.38,112.99 139.38,113.75 138.24,114.89 135.25,114.89 134.86,114.5 134.54,114.5 133.85,115.2 132.16,115.2 131.06,114.11 126.53,114.11 125.76,114.88 125.76,115.28 125.14,115.91 112.06,115.91 111.04,116.93 109.87,116.93 109.52,117.28 106.89,117.28 105.88,116.27 100.08,116.27 96.17,112.36 96.17,110.02 93.24,107.1 87.31,107.1 v1(87.11,107.3)
  BOTTOM w0.076: U45.AP8 140.33,110.83 139.75,110.83 v1(139.56,111.02)
  BOTTOM w0.14: v1(31.99,115.6) 31.85,115.47 31.85,115.13 31.45,114.74 30.33,114.74 28,117.07 21.92,117.07 20.28,115.43 20.28,114.75 19.8,114.26 v1(19.8,113.52) 19.06,113.52 18.68,113.14 15.71,113.14 15.33,113.52 14.44,113.52 R621.1
USBP2+_R: length 13
  BOTTOM w0.14: CN6.8 7.96,116.43 7.84,116.31 7.08,116.31 6.55,115.78 6.55,112.9 7.59,111.86 11.63,111.86 11.79,112.03 12.64,112.88 12.91,113.14 R621.2
USBP2-: length 148.5
  TOP w0.14: v1(71.26,108.9) 71.42,109.06 84.3,109.06 86.51,106.85 86.94,106.85 v1(87.11,106.69)
  IN1 w0.102: v1(139.56,110.37) 139.33,110.6 139.1,110.6 138.69,111.01 138.69,112.59 139.18,113.07 139.18,113.67 138.15,114.69 135.34,114.69 134.95,114.3 134.63,114.3 134.63,114.3 134.46,114.3 133.76,115 132.24,115 131.15,113.9 126.45,113.9 125.56,114.79 125.56,115.2 125.05,115.71 111.97,115.71 110.96,116.72 109.79,116.72 109.43,117.08 106.98,117.08 105.96,116.06 100.16,116.06 96.37,112.27 96.37,109.94 93.33,106.89 87.31,106.89 v1(87.11,106.69) ; v1(31.38,115.58) 31.58,115.38 31.58,115.07 35.54,111.11 43.65,111.11 44.99,109.76 50.96,109.76 53.04,107.68 61.07,107.68 62.49,109.1 71.05,109.1 v1(71.26,108.9)
  BOTTOM w0.076: U45.AR8 140.52,110.5 140.36,110.66 139.85,110.66 v1(139.56,110.37)
  BOTTOM w0.14: v1(31.38,115.58) 31.58,115.38 31.58,115.25 31.34,115.01 30.44,115.01 28.11,117.33 21.81,117.33 20.01,115.54 20.01,114.86 19.57,114.41 v1(18.87,114.41) 18.87,113.71 18.57,113.41 15.82,113.41 15.44,113.79 14.43,113.79 R617.1
USBP2-_R: length 13
  BOTTOM w0.14: R617.2 13.16,114.28 12.86,114.28 12.73,114.16 12.73,113.34 11.52,112.12 7.71,112.12 6.82,113.01 6.82,115.67 7.19,116.04 7.86,116.04 7.97,115.93 CN6.7
USBP3+: length 201.7
  TOP w0.14: R72.2 234.65,142.47 234.92,142.47 235.1,142.29 235.1,141.22 235.97,140.34 235.97,140.12 v1(235.77,139.91)
  IN1 w0.102: v1(235.77,139.91) 235.54,139.91 235.44,139.81 235.44,139.56 235.57,139.43 236.18,139.43 238.59,137.02 238.59,134.27 240.19,132.67 240.19,125.99 243.67,122.51 243.67,111.79 243.04,111.16 239.45,111.16 238.72,110.43 238.72,109 233.26,103.54 233.26,88.54 231.91,87.19 231.91,78.81 230.64,77.54 230.64,74.24 224.46,68.06 222.97,68.06 222.21,68.82 222.21,70.82 217.79,75.24 214.59,75.24 212,77.83 209.51,77.83 209.08,78.27 209.08,79.03 207.76,80.35 207.76,82.16 207.3,82.62 207.3,86.94 206.47,87.77 200.99,87.77 198.94,85.72 192.34,85.72 191.77,85.15 184.29,85.15 181.24,88.2 177.3,88.2 171.66,93.84 156.47,93.84 152.08,98.23 151.55,98.23 151.34,98.44 151.34,99.55 150.33,100.57 150.33,101.11 149.51,101.92 149.51,102.27 147.2,104.58 145.68,104.58 142.99,107.27 141.11,107.27 140.24,108.15 140.24,109.05 v1(139.58,109.71)
  BOTTOM w0.076: U45.AT10 139.09,110.05 139.01,109.97 139.01,109.79 139.09,109.71 v1(139.58,109.71)
USBP3+_R: length 7.4
  TOP w0.14: R72.1 234.7,143.29 234.7,145.57 235.2,146.07 235.72,146.07 D3.1 236.94,145.77 236.94,145.46 237.12,145.27 237.26,145.27 CN5.3
USBP3-: length 201.7
  TOP w0.14: v1(236.51,139.91) 236.24,140.18 236.24,140.45 235.37,141.33 235.37,142.16 R73.2
  IN1 w0.102: v1(139.61,109.08) 139.93,109.08 140.04,108.97 140.04,108.06 141.03,107.07 142.9,107.07 145.59,104.38 147.12,104.38 149.31,102.19 149.31,101.84 150.12,101.03 150.12,100.48 151.14,99.47 151.14,98.36 151.47,98.03 151.99,98.03 156.39,93.63 171.58,93.63 177.22,87.99 181.16,87.99 184.2,84.95 191.86,84.95 192.42,85.52 199.03,85.52 201.08,87.56 206.38,87.56 207.1,86.85 207.1,82.53 207.55,82.08 207.55,80.27 208.87,78.94 208.87,78.18 209.42,77.63 211.91,77.63 214.5,75.04 217.7,75.04 222,70.74 222,68.73 222.89,67.85 224.54,67.85 230.84,74.15 230.84,77.45 232.11,78.72 232.11,87.11 233.46,88.45 233.46,103.46 238.92,108.92 238.92,110.35 239.53,110.96 243.12,110.96 243.87,111.71 243.87,122.6 240.39,126.08 240.39,132.75 238.79,134.35 238.79,137.1 236.51,139.39 v1(236.51,139.91)
  BOTTOM w0.076: U45.AR10 139.17,110.47 138.85,110.14 138.85,109.31 139.07,109.08 v1(139.61,109.08)
USBP3-_R: length 7.4
  TOP w0.14: CN5.2 237.26,145.01 237.01,145.01 236.67,145.35 236.67,145.54 236.56,145.65 236.31,145.65 236.18,145.53 D4.1 235.65,145.81 235.31,145.81 234.97,145.46 234.97,143.24 235.08,143.12 R73.1
USBP4+: length 121.4
  IN1 w0.102: v1(221.29,69.94) 221.01,70.21 221.01,70.9 217.76,74.15 214.46,74.15 212.3,76.31 209.51,76.31 207.93,77.89 207.93,78.68 206.54,80.08 206.54,86.3 205.76,87.08 201.58,87.08 199.53,85.03 192.83,85.03 192.19,84.39 183.78,84.39 180.65,87.51 176.48,87.51 171.22,92.77 156.55,92.77 151.98,97.34 151.05,97.34 149.89,98.49 149.89,99.35 148.65,100.59 148.65,101.26 146.68,103.23 145.63,103.23 142.71,106.15 141.1,106.15 138.41,108.83 138.41,109.71 136.94,111.19 136.94,111.96 136.62,112.28 136.3,112.28 v1(136.09,112.5)
  BOTTOM w0.102: v1(136.09,112.5) 136.56,112.97 U45.AL15
  BOTTOM w0.14: CN12.3 226.82,73.21 226.68,73.35 225.09,73.35 224.24,72.5 224.24,71.48 223.36,70.61 221.26,70.61 221.05,70.41 221.05,70.18 v1(221.29,69.94)
USBP4-: length 121.4
  IN1 w0.102: v1(136.09,111.85) 136.31,112.07 136.53,112.07 136.74,111.87 136.74,111.1 138.21,109.63 138.21,108.75 141.01,105.94 142.63,105.94 145.54,103.03 146.59,103.03 148.45,101.18 148.45,100.51 149.69,99.26 149.69,98.41 150.96,97.14 151.89,97.14 156.46,92.57 171.14,92.57 176.39,87.31 180.57,87.31 183.69,84.18 192.27,84.18 192.91,84.83 199.61,84.83 201.66,86.88 205.67,86.88 206.33,86.22 206.33,79.99 207.73,78.6 207.73,77.8 209.42,76.11 212.22,76.11 214.38,73.95 217.68,73.95 220.81,70.82 220.81,70.09 v1(220.66,69.94)
  BOTTOM w0.102: U45.AM15 136.68,112.28 136.25,111.85 v1(136.09,111.85)
  BOTTOM w0.14: CN12.5 226.78,73.71 226.69,73.62 224.98,73.62 223.97,72.61 223.97,71.6 223.25,70.88 221.15,70.88 220.79,70.52 220.79,70.06 v1(220.66,69.94)
USBP5+: length 95.3
  IN3 w0.089: v1(74.66,95.87) 74.96,95.56 74.96,94.95 75.34,94.57 76.55,94.57 78.06,96.09 78.06,99.21 81.75,102.9 81.75,109.71 88.99,116.95 88.99,118.86 89.75,119.62 105.33,119.62 106.22,118.73 109.27,118.73 109.98,118.02 111.16,118.02 112.81,116.37 125.64,116.37 126.83,115.17 126.83,114.89 127.14,114.59 130.85,114.59 132.33,116.06 132.92,116.06 133.58,115.4 135.49,115.4 136.56,114.33 136.56,113.97 137.17,113.36 137.17,112.86 137.64,112.39 v1(137.64,112.32)
  BOTTOM w0.102: v1(137.64,112.32) 137.32,112 U45.AN13
  BOTTOM w0.14: v1(74.66,95.87) 74.94,96.15 74.94,96.96 75.38,97.4 75.38,99.06 73.89,100.55 71.4,100.55 R675.1
USBP5+_R: length 5.4
  BOTTOM w0.14: CN7.5 70.05,103.72 70.15,103.62 70.15,102.43 69.29,101.57 69.29,100.84 69.78,100.35 70.07,100.35 R675.2
USBP5-: length 95.3
  IN3 w0.089: v1(137.64,112.97) 137.54,112.87 137.44,112.87 137.37,112.95 137.37,113.45 136.76,114.06 136.76,114.42 135.58,115.6 133.66,115.6 133,116.27 132.24,116.27 130.77,114.79 127.22,114.79 127.03,114.98 127.03,115.26 125.72,116.57 112.89,116.57 111.24,118.22 110.07,118.22 109.36,118.93 106.31,118.93 105.42,119.82 89.66,119.82 88.78,118.94 88.78,117.04 81.54,109.8 81.54,102.98 77.86,99.3 77.86,96.17 76.46,94.78 75.42,94.78 75.17,95.03 75.17,95.56 v1(75.5,95.89)
  BOTTOM w0.102: U45.AM13 137.32,112.65 v1(137.64,112.97)
  BOTTOM w0.14: v1(75.5,95.89) 75.21,96.19 75.21,96.85 75.65,97.29 75.65,99.17 74,100.82 71.4,100.82 R667.1
USBP5-_R: length 5.4
  BOTTOM w0.14: CN7.4 70.55,103.77 70.42,103.63 70.42,102.32 69.56,101.46 69.56,100.95 69.89,100.61 70.11,100.61 70.24,100.75 R667.2
USBP6+: length 99.7
  IN3 w0.089: v1(138.21,112) 138.21,111.85 138.31,111.74 138.64,111.74 139.1,112.2 139.1,113.95 137.88,115.17 136.86,115.17 135.95,116.09 133.92,116.09 133.56,116.44 133.56,118.19 132.72,119.03 130.3,119.03 128.53,120.8 128.53,121.69 125.35,124.88 118.87,124.88 118.25,125.5 118.25,126.14 117.53,126.86 109.23,126.86 108.52,126.15 104.39,126.15 103.38,127.16 98.09,127.16 95.93,125 94.66,125 91.94,122.28 88.48,122.28 81.06,114.87 81.06,103.18 76.29,98.41 74.81,98.41 74.68,98.28 v1(74.68,97.98)
  BOTTOM w0.102: v1(138.21,112) 138.48,112 138.6,111.87 U45.AN11
  BOTTOM w0.14: v1(74.68,97.98) 74.68,98.23 74.6,98.32 73.88,98.32 73.24,98.97 72.07,98.97 71.64,98.54 71.41,98.54 R685.1
USBP6+_R: length 7.6
  BOTTOM w0.14: R685.2 70.07,98.31 69.65,98.31 68.35,99.62 68.35,103.29 68.67,103.6 68.67,103.88 68.55,104 CN7.8
USBP6-: length 99.7
  IN3 w0.089: v1(138.21,111.35) 138.4,111.54 138.73,111.54 139.3,112.12 139.3,114.04 137.96,115.38 136.95,115.38 136.03,116.29 134,116.29 133.77,116.53 133.77,118.27 132.8,119.24 130.39,119.24 128.74,120.89 128.74,121.78 125.43,125.08 118.96,125.08 118.45,125.59 118.45,126.22 117.61,127.06 109.14,127.06 108.43,126.35 104.48,126.35 103.46,127.36 98,127.36 95.84,125.21 94.57,125.21 91.86,122.49 88.39,122.49 80.86,114.95 80.86,103.27 76.2,98.61 74.91,98.61 v1(74.66,98.87)
  BOTTOM w0.102: U45.AP11 138.53,111.02 v1(138.21,111.35)
  BOTTOM w0.14: R682.1 71.38,98.8 71.53,98.8 71.96,99.23 73.35,99.23 74,98.59 74.38,98.59 v1(74.66,98.87)
USBP6-_R: length 7.6
  BOTTOM w0.14: R682.2 70.24,98.69 70.13,98.58 69.76,98.58 68.61,99.73 68.61,103.18 68.94,103.51 68.94,103.87 69.05,103.98 CN7.7
USBP7+: length 155.3
  IN3 w0.089: v1(77.96,52.43) 77.73,52.21 77.73,51.98 77.35,51.6 73.6,51.6 73.34,51.86 71.83,51.86 70.79,52.89 65.48,52.89 65.02,53.35 64.72,53.35 63.31,54.76 63.31,55.27 62.75,55.83 62.75,63.63 63.76,64.64 63.76,68.9 64.32,69.46 64.32,72.38 65.43,73.49 69.4,73.49 78.01,82.1 80.17,82.1 82.89,84.82 82.89,96.34 82.38,96.85 82.38,101.62 83.83,103.07 83.83,111.07 89.62,116.86 89.62,118.35 89.95,118.68 99.23,118.68 100.32,117.59 109.18,117.59 109.81,116.95 111.08,116.95 112.18,115.86 125.26,115.86 125.82,115.3 125.82,114.92 126.63,114.11 131.06,114.11 132,115.05 133.23,115.05 133.36,114.92 134.12,114.92 134.71,114.33 134.71,114.11 135.47,113.35 135.47,109.97 135.87,109.56 136.23,109.56 136.74,110.07 136.74,111.22 137,111.49 137.44,111.49 v1(137.65,111.7)
  BOTTOM w0.089: v1(137.65,111.7) 137.3,111.35 U45.AP13
  BOTTOM w0.14: v1(77.96,52.43) 77.7,52.17 77.7,51.92 76.83,51.05 76.83,50.77 76.95,50.65 CN17.4
USBP7-: length 155.3
  IN3 w0.089: v1(137.65,111.05) 137.41,111.29 137.09,111.29 136.94,111.14 136.94,109.98 136.31,109.36 135.79,109.36 135.26,109.88 135.26,113.27 134.5,114.03 134.5,114.25 134.04,114.72 133.27,114.72 133.15,114.84 132.09,114.84 131.15,113.9 126.54,113.9 125.61,114.83 125.61,115.22 125.17,115.66 112.09,115.66 111,116.75 109.73,116.75 109.09,117.38 100.24,117.38 99.15,118.47 90.03,118.47 89.82,118.26 89.82,116.77 84.03,110.98 84.03,102.98 82.58,101.53 82.58,96.94 83.09,96.43 83.09,84.74 80.26,81.9 78.1,81.9 69.49,73.29 65.52,73.29 64.52,72.3 64.52,69.38 63.97,68.82 63.97,64.56 62.95,63.54 62.95,55.91 63.51,55.36 63.51,54.85 64.8,53.55 65.11,53.55 65.56,53.1 70.87,53.1 71.91,52.06 73.43,52.06 73.69,51.8 77.27,51.8 77.53,52.06 77.53,52.23 v1(77.33,52.43)
  BOTTOM w0.089: U45.AR13 137.11,110.7 137.04,110.63 137.04,110.45 137.14,110.35 137.43,110.35 137.65,110.58 v1(137.65,111.05)
  BOTTOM w0.14: CN17.5 76.45,50.66 76.56,50.77 76.56,51.16 77.43,52.03 77.43,52.28 77.43,52.28 77.43,52.33 v1(77.33,52.43)
USBPWR1:
  vias: v1(233.26,65.26) v2(233.51,67.42) v2(233.51,66.53) v2(235.57,69.17) v2(235.57,68.41)
USBPWR2: length 24.4
  TOP w0.508: C163.1 v1(242.68,125.71)
  TOP w0.762: v2(239.91,134.9) v1(237.58,137.23) 237.58,141.08 CN5.1
  IN2 w0.762: v2(239.91,134.9) v1(237.58,137.23) 237.58,141.08 CN5.1
  BOTTOM w0.762: v2(239.91,134.9) v1(237.58,137.23) 237.58,141.08 CN5.1
  vias: v2(240.61,135.28) v2(240.61,134.49) v2(242.02,113.01) v2(242.02,112.25) v2(242.66,126.48) v2(242.78,113.39) v2(242.78,112.63) v2(242.78,111.87)
USBPWR3:
  vias: v1(234.53,85.33) v2(233.38,85.45) v2(233.38,84.69) v2(235.52,87.03) v2(235.57,86.22)
USBPWR4:
  vias: v1(9.91,113.62) v1(10.52,113.62) v1(11.21,114.41) v1(11.13,113.62) v1(12.02,113.78)
VA1: length 26.1
  TOP w0.254: PQ11.1 29.17,87.03 29.17,89.65 30.79,91.27 PC31.1
  TOP w0.305: v2(43.37,92.64) 43.37,92.52 42.48,91.63 PD1.2
  IN2 w0.254: v2(43.37,92.64) 42.2,93.81 38.57,93.81 37.04,95.34 37.04,98.33 PJ1.1
  vias: v1(30.84,96.38) v1(30.84,95.54) v1(31.33,95.92) v1(31.38,95.06) v1(32.98,98.15)
VA2:
  vias: v3(40.78,88.15)
VDD33/18: length 29.3
  TOP w0.254: C333.2 208.86,79.11 209.63,79.11 v1(209.64,79.1) 209.64,79.11 C334.2 210.27,79.49 v1(210.91,80.12) 211.98,81.2 U24.33 ; C325.2 224.77,83.17 v1(224.49,83.17) R285.2
  BOTTOM w0.254: v1(209.64,79.1) 209.15,78.62 209.15,76.44 210.68,74.91 214.21,74.91 217.51,78.22 218.65,78.22 219.31,78.88 221.98,78.88 223.61,80.5 223.61,81.92 224.49,82.81 v1(224.49,83.17)
VGA_COMP: length 2.5
  BOTTOM w0.127: v1(103.59,156.85) 103.77,156.67 U40.6 ; C562.1 103.71,157.71
  BOTTOM w0.14: v1(103.59,156.85) 103.71,156.97 103.71,157.71
VGA_OVT#: length 28.1
  TOP w0.14: R185.1 39.1,109.48 39.84,110.22 Q15.1 41.28,111.03 45.98,111.03 47.33,112.38 51.29,112.38 v1(52.82,113.9)
  BOTTOM w0.102: U43.A6 53.7,123.23 55.2,121.73 55.2,119.74
  BOTTOM w0.14: 55.2,119.74 55.2,118.69 53.42,116.9 53.42,116.22 53.24,116.04 53.24,114.33 v1(52.82,113.9)
VGA_RST: length 4.8
  BOTTOM w0.127: U40.5 103.37,156.41 102.57,157.21 R459.2 102.07,158.34 102.07,159.22 v1(101.79,159.5)
VGA_RST#: length 9.3
  TOP w0.14: v1(29.96,122.87) 29.6,122.87 29.19,123.28 C190.1 R124.2
  IN3 w0.089: v1(29.96,122.87) 30.41,122.41 32.34,122.41 34.49,124.56 v1(35.09,124.56)
  BOTTOM w0.102: v1(35.09,124.56) 35.49,124.96 U43.AC7
VGPU_EN: length 142.7
  IN1 w0.114: v1(145.35,119.87) 145.98,120.51 147.28,120.51 147.6,120.83 147.6,122.3 147.9,122.6 148.99,122.6 149.43,122.16 149.99,122.16 150.37,122.55 151.63,122.55 152.45,123.37 153.53,123.37 155.09,121.81 v1(155.09,121.78) ; v1(49,75.68) 49,74.96 50.3,73.67 51.14,73.67 52.32,72.49 57.61,72.49 59.39,74.28 59.39,75.93 59.85,76.39 60.59,76.39 61.38,77.17 62.65,77.17 63.08,76.74 64.79,76.74 65.6,77.55 65.6,77.94 66,78.34 66,79.69 66.94,80.63 66.94,84.09 71.43,88.58 71.43,91.07 v1(74.15,93.79)
  IN2 w0.076: v1(145.35,119.87) 144.53,119.05 140.35,119.05 140.17,119.24 139.53,119.24
  IN2 w0.114: 139.53,119.24 138.44,119.24 137.87,118.67 137.4,118.67 136.95,119.13 135.12,119.13 134.63,119.62 133.61,119.62 132.14,118.15 132.14,117.66 131.51,117.04 126.41,117.04 125.69,116.32 113.67,116.32 112.24,114.88 109.77,114.88 109.56,114.66 108.34,114.66 104.48,110.8 99.22,110.8 98.51,110.09 98.51,108.19 94.19,103.87 92.08,103.87 88.68,100.47 84.82,100.47 82.73,98.37 80.31,98.37 75.73,93.79 v1(74.15,93.79)
  BOTTOM w0.14: PR170.2 48.9,75.57 v1(49,75.68) ; R557.1 R560.2 155.09,122.47 v1(155.09,121.78) ; v1(145.35,119.87) 144.84,119.87 U45.V1
VGPU_PSI: length 74.7
  IN3 w0.089: v1(38.82,99.86) 38.82,99.83 38.54,99.55 38.54,98.51 38.64,98.41 38.64,95.16 37.51,94.02 37.51,76.23 41.51,72.23 48.35,72.23 v1(49.28,73.16)
  BOTTOM w0.14: v1(49.28,73.16) 49.03,73.16 48.9,73.29 PR174.2 ; v1(38.82,99.86) 39.28,100.31 39.28,101.41 39.84,101.96 39.84,108.82 42,110.98 45.78,110.98 46.69,110.06 48.82,110.06 50,111.24 50,112.63 50.39,113.02 R629.1
  BOTTOM w0.152: U43.B4 53.18,122.46 53.55,122.09 53.79,122.09 54.35,121.53 54.35,119.18 52.08,116.9 52.08,113.95 51.77,113.65 51.13,113.65 R629.1
VGPU_PWMVID: length 71.1
  TOP w0.14: PR74.2 48.9,72 v1(48.98,71.92)
  IN3 w0.089: v1(48.98,71.92) 41.55,71.92 37.3,76.17 37.3,95.16 36.22,96.24 36.22,99.4 36.72,99.9 36.72,102.91 v1(37.56,103.75)
  BOTTOM w0.102: U43.E7 50.5,124.82 50,124.32 50,123.05 49.84,122.89 49.46,122.89 49.23,122.67 49.23,122.28 48.98,122.03 47.84,122.03 47.58,121.78 47.58,121.52 47.33,121.27 47,121.27 46.74,121.01 46.74,119.8 46.06,119.11
  BOTTOM w0.14: 46.06,119.11 45.81,118.86 45.42,118.86 42.68,116.11 42.68,113.22 42.88,113.01 42.88,112 42.38,111.49 41.74,111.49 39.46,109.2 39.46,105.65 v1(38.31,104.5) v1(37.56,103.75)
VGPU_PWRGD: length 64.1
  TOP w0.14: U21.1 42.14,104.62 43.14,103.62 44.16,103.62 R218.2 45.31,103.12 v1(45.5,103.31) ; PR57.2 59.65,77.5 59.86,77.71 60.79,77.71 61.17,78.09 63.16,78.09 63.74,78.67 66.83,78.67 67.01,78.85 67.01,81.24 67.67,81.9 68.28,81.9 69.1,82.72 69.1,91.35 69.81,92.06 69.81,100.82 68.54,102.09 68.54,102.85 v1(67.9,103.49)
  IN3 w0.089: v1(45.5,103.31) 45.5,103.79 45.96,104.25 53.82,104.25 55.16,102.92 64.79,102.92 65.36,103.49 v1(67.9,103.49)
VL: length 287.5
  TOP w0.208: PU5.13 197.42,62.34 197.67,62.09 PC65.2 197.19,60.97 195.69,60.97 191.86,57.13 191.86,52.94 193.38,51.42 v1(193.38,51.04)
  IN2 w0.203: v1(66.94,48.9) 65.69,50.15 64.47,50.15 63.13,51.5 62.21,51.5 61.6,52.1 61.6,52.49 60.59,53.5 60.59,54.33 58.54,56.37 58.54,59.71 59.58,60.75 59.58,62.14 58.94,62.78 58.94,64.56 59.65,65.26 59.65,70.24 61.43,72.02 61.43,73.18 63.71,75.47 63.71,77.05 v1(64.3,77.63)
  BOTTOM w0.203: v1(193.38,51.04) 193.89,50.53 193.89,46.47 192.24,44.81 177.5,44.81 174.49,41.8 174.49,38.99 173.37,37.87 155.11,37.87 153.63,39.35 153.63,46.73 153.49,46.87 149.95,46.87 147.86,48.95 139.42,48.95 136.54,51.83 134.46,51.83 131.82,54.47 130.59,54.47 130.29,54.16 130.29,51.33 128.2,49.25 95.92,49.25 94.75,48.07 89.64,48.07 88.94,47.37 85.03,47.37 83.74,48.66 82.25,48.66 81.8,48.2 81.8,45.75 81.54,45.49 68.55,45.49 66.94,47.11 v1(66.94,48.9) ; PR158.1 PR159.1 97.62,107.81 v3(99.4,106.03) 100.19,105.24 100.19,104.83 101.02,104 101.51,104 102.14,104.63 103.34,104.63 103.71,104.26 103.71,102.61 104.23,102.09 104.23,99.42 103.57,98.77 92.83,98.77 90.94,100.66 86.1,100.66 85.18,99.73 81.77,99.73 77.26,95.21 77.26,94.25 74.27,91.27 72.72,91.27 72.16,90.71 72.16,85.65 71.41,84.9 68.23,84.9 67.52,84.18 67.52,82.15 68.46,81.21 68.46,78.79 67.76,78.09 64.63,78.09 64.3,77.76 v1(64.3,77.63)
VMA_CLK0: length 79.6
  TOP w0.102: v1(64.28,135.61) 64.4,135.61 64.6,135.41 64.6,135.25 64.44,135.09 63.21,135.09 62.69,135.61 57.55,135.61 57.51,135.65 57.49,135.65 ; U16.J7 65.14,131.28 65.47,130.96 65.47,130.86 65.31,130.7 64.3,130.7 63.92,130.32 63.92,129.95 v1(63.71,129.75) ; U13.J7 65.34,143.15 65.44,143.05 65.44,142.82 65.38,142.76 64.58,142.76 64.4,142.59 64.4,142.23 64.68,141.95 64.68,141.65 v1(64.52,141.49)
  TOP w0.152: R87.1 55.58,135.8 55.73,135.65 57.49,135.65
  IN1 w0.127: v1(63.71,129.75) 63.97,130 63.97,130.32 64.46,130.81 64.46,131.37 64.77,131.68 64.77,132.72 65.1,133.05 65.1,133.65 64.48,134.28 64.48,135.42 v1(64.28,135.61) 64.49,135.82 64.49,136.1 64.78,136.39 65.09,136.39 65.26,136.57 65.26,136.77 64.87,137.16 64.87,140.82 64.75,140.93 64.75,141.26 v1(64.52,141.49)
  IN3 w0.089: v1(64.28,135.61) 64.39,135.61 64.59,135.81 64.59,136.73 64.26,137.06 63.84,137.06 63.64,136.86 63.64,134.18 63.4,133.94 62.8,133.94 62.56,134.18 62.56,136.87 62.43,137 61.99,137 61.86,136.87 61.86,134.16 61.59,133.89 61.04,133.89 60.78,134.16 60.78,135.86 60.65,135.98 60.27,135.98 60.14,135.86 60.14,134.85 59.91,134.61 59.29,134.61 59.13,134.78 59.13,135.9 59.06,135.98 58.56,135.98 58.43,135.85 58.43,134.81 58.23,134.61 57.25,134.61 56.97,134.89 56.97,135.22 56.84,135.35 56.42,135.35 56.27,135.2 56.27,134.88 56,134.61 55.34,134.61 55.06,134.89 55.06,135.67 54.86,135.87 54.57,135.87 54.37,135.67 54.37,133.01 54.01,132.65 53.48,132.65 52.87,133.25 51.48,133.25 51.31,133.43 51.31,134.35 51.55,134.59 52.1,134.59 52.44,134.24 52.86,134.24 53.03,134.41 53.03,134.61 52.31,135.33 52.31,135.72 52.83,136.24 52.83,136.45 51.82,137.46 51.82,137.98 52.18,138.34 52.18,138.79 51.98,139 51.82,139 51.7,138.87 v1(51.7,138.63)
  BOTTOM w0.102: v1(64.52,141.49) 64.62,141.49 64.74,141.37 64.74,141.14 64.45,140.85 64.45,140.52 64.68,140.29 65.04,140.29 65.19,140.44 65.33,140.44 65.43,140.34 65.43,140.1 65.28,139.95 U41.J7 ; U44.J7 65.35,128.08 65.43,128.16 65.43,128.48 65.1,128.81 64.34,128.81 63.94,129.21 63.94,129.53 v1(63.71,129.75) ; U43.D24 51.3,139.03 v1(51.7,138.63)
VMA_CLK0#: length 79.5
  TOP w0.102: U16.K7 65.67,131.02 65.67,130.78 65.39,130.5 64.39,130.5 64.12,130.23 64.12,130.04 v1(64.4,129.75) ; U13.K7 65.73,143.15 65.64,143.07 65.64,142.74 65.47,142.56 64.66,142.56 64.6,142.5 64.6,142.31 64.88,142.04 64.88,141.78 v1(65.13,141.52) ; v1(64.95,135.63) 64.8,135.49 64.8,135.16 64.52,134.88 63.13,134.88 62.6,135.41 57.54,135.41 57.5,135.37 57.49,135.37
  TOP w0.152: 57.49,135.37 55.72,135.37 R87.2
  IN1 w0.127: v1(65.13,141.52) 65,141.39 65,141.02 65.11,140.92 65.11,137.26 65.5,136.87 65.5,136.47 65.19,136.15 64.88,136.15 64.73,136 64.73,135.82 64.92,135.63 v1(64.95,135.63) 64.73,135.41 64.73,134.38 65.34,133.77 65.34,132.95 65.01,132.62 65.01,131.58 64.7,131.27 64.7,130.71 64.21,130.22 64.21,129.95 v1(64.4,129.75)
  IN3 w0.089: v1(64.95,135.63) 64.77,135.8 64.77,136.81 64.33,137.24 63.77,137.24 63.46,136.93 63.46,134.25 63.32,134.12 62.87,134.12 62.74,134.25 62.74,136.94 62.5,137.18 61.91,137.18 61.68,136.94 61.68,134.23 61.52,134.07 61.12,134.07 60.96,134.23 60.96,135.93 60.73,136.16 60.2,136.16 59.97,135.93 59.97,134.92 59.83,134.79 59.37,134.79 59.31,134.85 59.31,135.98 59.13,136.15 58.48,136.15 58.25,135.92 58.25,134.89 58.15,134.79 57.32,134.79 57.15,134.96 57.15,135.29 56.92,135.53 56.35,135.53 56.09,135.27 56.09,134.96 55.92,134.79 55.41,134.79 55.24,134.96 55.24,135.74 54.93,136.05 54.5,136.05 54.19,135.74 54.19,133.08 53.93,132.83 53.55,132.83 52.95,133.43 51.56,133.43 51.49,133.5 51.49,134.27 51.62,134.41 52.02,134.41 52.36,134.06 52.94,134.06 53.21,134.34 53.21,134.68 52.49,135.4 52.49,135.65 53.01,136.17 53.01,136.52 52,137.53 52,137.91 52.36,138.26 52.36,138.87 52.03,139.2 51.97,139.2 v1(51.7,139.47)
  BOTTOM w0.102: v1(65.13,141.52) 64.94,141.33 64.94,141.06 64.65,140.77 64.65,140.61 64.76,140.5 64.96,140.5 65.11,140.65 65.42,140.65 65.63,140.43 65.63,140.05 65.74,139.95 U41.K7 ; U43.D25 51.3,139.78 51.61,139.47 v1(51.7,139.47) ; U44.K7 65.74,128.08 65.63,128.18 65.63,128.57 65.19,129.02 64.42,129.02 64.14,129.3 64.14,129.49 v1(64.4,129.75)
VMA_CLK1: length 82.6
  TOP w0.102: 45,146.03 45,146.06 44.96,146.1 44.96,148.22 43.72,149.46 43.72,152.46 43.82,152.55 v1(44.01,152.55) ; v1(49.75,151.98) 48.96,152.77 48.96,153.48 48.8,153.64 48.57,153.64 48.47,153.53 U12.J7 ; U11.J7 36.6,153.6 36.69,153.69 36.83,153.69 37,153.52 37,153.12 37.19,152.92 37.97,152.92 v1(38.26,152.64)
  TOP w0.152: R68.1 45.51,144.08 45.51,144.32 45.39,144.45 44.92,144.45 44.81,144.56 44.81,144.8 45,144.99 45,146.03
  IN1 w0.127: v1(38.26,152.64) 38.27,152.64 38.57,152.94 41.36,152.94 41.63,152.66 41.63,152.45 41.94,152.14 42.6,152.14 43.23,152.76 43.8,152.76 v1(44.01,152.55) 44.02,152.55 44.17,152.7 45.04,152.7 45.78,153.43 46.66,153.43 47.35,152.75 48.98,152.75 v1(49.75,151.98)
  IN3 w0.089: v1(44.01,152.55) 44.32,152.87 44.82,152.87 45.12,152.56 45.12,151.44 45.65,150.91 45.65,150.75 45.34,150.45 45.2,150.45 43.98,151.66 43.56,151.66 43.26,151.36 43.26,150.94 44.88,149.32 44.88,149.07 44.7,148.89 44.45,148.89 42.96,150.38 42.66,150.38 42.25,149.97 42.25,149.64 43.47,148.42 43.47,148.28 43.17,147.97 43.02,147.97 42.15,148.85 41.85,148.85 41.43,148.43 41.43,148.16 42.27,147.31 42.27,147.15 42.16,147.03 41.75,147.03 41.53,146.82 41.53,146.26 41.75,146.04 42.28,146.04 42.4,145.92 42.4,145.56 42.28,145.43 41.75,145.43 41.53,145.22 41.53,144.82 42.02,144.33 42.02,144.15 41.77,143.9 41.59,143.9 41.1,144.39 40.8,144.39 40.4,143.99 40.4,143.69 40.78,143.31 40.78,143.17 40.49,142.88 40.35,142.88 39.97,143.26 39.67,143.26 39.13,142.71 39.13,142.08 39.54,141.66 41.85,141.66 41.95,141.56 41.95,141.09 41.85,140.98 38.16,140.98 37.69,140.52 37.69,140.06 38.26,139.49 38.73,139.49 39.23,139.99 40.09,139.99 40.38,139.7 40.38,139.09 40.6,138.88 41.16,138.88 41.37,139.09 41.37,139.4 41.48,139.5 41.63,139.5 43.82,137.3 43.82,137.17 43.68,137.02 v1(43.42,137.02)
  BOTTOM w0.102: v1(43.42,137.02) 43.44,137.02 U43.N22 ; U38.J7 39.8,153.6 39.7,153.7 39.13,153.7 39.05,153.62 39.05,153.21 38.75,152.92 38.39,152.92 38.26,152.79 v1(38.26,152.64) ; v1(49.75,151.98) 49.75,151.99 51.21,153.45 51.62,153.45 U39.J7
VMA_CLK1#: length 82.6
  TOP w0.102: 44.72,146.03 44.72,146.06 44.76,146.1 44.76,148.14 43.52,149.37 43.52,152.74 v1(44.02,153.24) ; v1(38.23,153.4) 37.95,153.13 37.27,153.13 37.2,153.2 37.2,153.6 36.91,153.89 36.69,153.89 36.6,153.98 U11.K7 ; U12.K7 48.47,153.97 48.6,153.84 48.89,153.84 49.16,153.57 49.16,152.86 49.45,152.57 49.64,152.57 v1(49.75,152.67)
  TOP w0.152: 44.72,146.03 44.72,145.11 44.53,144.92 R68.2
  IN1 w0.127: v1(38.23,153.4) 38.46,153.18 41.46,153.18 41.87,152.76 41.87,152.55 42.04,152.38 42.5,152.38 43.14,153.02 43.8,153.02 v1(44.02,153.24) 44.33,152.94 44.94,152.94 45.68,153.67 46.76,153.67 47.45,152.99 49.08,152.99 49.53,152.54 49.62,152.54 v1(49.75,152.67)
  IN3 w0.089: v1(44.02,153.24) 44.22,153.04 44.89,153.04 45.3,152.64 45.3,151.52 45.83,150.99 45.83,150.68 45.42,150.27 45.13,150.27 43.91,151.48 43.63,151.48 43.44,151.29 43.44,151.01 45.06,149.39 45.06,149 44.77,148.71 44.37,148.71 42.89,150.2 42.73,150.2 42.43,149.89 42.43,149.71 43.65,148.49 43.65,148.2 43.24,147.8 42.95,147.8 42.07,148.67 41.92,148.67 41.61,148.36 41.61,148.23 42.45,147.39 42.45,147.08 42.23,146.86 41.82,146.86 41.71,146.75 41.71,146.33 41.82,146.22 42.35,146.22 42.58,145.99 42.58,145.49 42.35,145.26 41.82,145.26 41.71,145.15 41.71,144.89 42.2,144.41 42.2,144.08 41.84,143.72 41.52,143.72 41.03,144.21 40.87,144.21 40.58,143.92 40.58,143.76 40.95,143.39 40.95,143.1 40.56,142.7 40.27,142.7 39.9,143.08 39.74,143.08 39.3,142.64 39.3,142.15 39.61,141.84 41.92,141.84 42.13,141.64 42.13,141.01 41.92,140.81 38.23,140.81 37.87,140.44 37.87,140.13 38.34,139.67 38.65,139.67 39.16,140.17 40.17,140.17 40.56,139.78 40.56,139.16 40.67,139.06 41.09,139.06 41.2,139.16 41.2,139.47 41.4,139.68 41.7,139.68 44,137.37 44,137.25 v1(44.22,137.02)
  BOTTOM w0.102: v1(49.75,152.67) 50.14,152.67 U39.K7 ; v1(38.23,153.4) 38.23,153.31 38.41,153.12 38.67,153.12 38.85,153.3 38.85,153.7 39.04,153.9 39.7,153.9 39.8,154.01 U38.K7 ; v1(44.22,137.02) 44.62,137.42 U43.M22
