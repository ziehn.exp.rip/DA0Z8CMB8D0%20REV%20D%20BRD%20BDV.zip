# Allegro board DA0Z8CMB8D0-D-gina-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
APS1: length 8.1
  BOTTOM w0.14: CN14.1 152.28,59.96 152.51,59.72 152.96,59.72 153.96,60.72 153.96,62.04 154.26,62.34 155.03,62.34 v1(155.41,61.96) 155.89,62.44 R737.1 155.89,63.48 155.66,63.71 R723.1
APS3: length 13.5
  BOTTOM w0.14: R737.2 154.42,63.59 154.26,63.74 154.26,64.37 154.77,64.88 154.77,65.13 154.5,65.41 153.99,65.41 153.68,65.72 153.68,66.48 v1(153.12,67.04) R716.1 151.81,67.03 R718.1 151.81,64.5 151.71,64.39 151.71,62.7 151.55,62.54 151.55,61.89 151.28,61.63 CN14.3
APS7: length 9.1
  BOTTOM w0.14: CN14.7 149.28,61.08 148.93,61.43 148.93,61.96 148.32,62.57 148.32,64.27 148.42,64.37 148.42,65.01 147.79,65.64 v1(147.79,66.05) 148.17,66.05 148.42,65.8 R717.1 148.84,65.83 R718.2
APWORK: length 204.9
  TOP w0.14: U32.30 139.44,54.53 138.52,53.6 ; 138.52,53.6 138.52,52.69 139.15,52.05 v1(140.04,52.05) ; 138.52,53.6 138.29,53.83 R377.1
  IN3 w0.089: v1(59.9,53.96) 58.67,55.18 58.67,60.05 59.66,61.04 59.66,62.27 59.23,62.7 59.23,64.42 59.64,64.83 59.64,72.25 63.17,75.78 63.7,75.78 64.21,76.29 68.06,76.29 76.06,84.28 76.06,91.06 75.4,91.72 74.95,91.72 74.71,91.49 73.91,91.49 73.49,91.91 73.49,92.34 74.56,93.41 74.56,94.1 73.85,94.81 73.85,99.38 74.39,99.92 76.4,99.92 80.07,103.59 80.07,115.74 89.69,125.36 91.29,125.36 94.37,128.45 95.53,128.45 96.22,129.14 96.22,130.29 96.5,130.57 v1(97.44,130.57) ; v1(140.04,52.05) 140.04,51.8 139.34,51.1 137.23,51.1 136.87,50.74 134.47,50.74 132.77,49.04 130.76,49.04 129.8,48.07 120.73,48.07 120.23,47.57 110.59,47.57 109.92,48.24 105.55,48.24 105.23,47.93 96.31,47.93 95.54,47.15 91.58,47.15 89.58,45.15 67.57,45.15 v1(67.27,45.45)
  BOTTOM w0.14: v1(67.27,45.45) 66.02,46.7 66.02,48.78 64.81,49.99 61.33,49.99 59.52,51.8 59.52,53.58 v1(59.9,53.96) ; R519.2 99.02,132.95 99.78,132.19 99.78,130.92 99.42,130.57 v1(97.44,130.57)
APWROK_R: length 140.7
  TOP w0.14: v1(136.89,54.57) 136.6,54.28 R377.2 R379.2
  IN1 w0.114: v1(155.84,119.36) 155.84,116.94 155.55,116.65 155.55,116.23 156.17,115.6 156.17,114.29 159.49,110.97 159.49,109.82 159.71,109.6 159.71,106.02 159.39,105.7 v1(159.39,105.09)
  IN2 w0.114: v1(142.34,118.5) 142.6,118.5 142.71,118.6 145.3,118.6 146.06,119.36 147.1,119.36 147.38,119.64 149.18,119.64 149.39,119.85 150.1,119.85 150.71,119.24 151.27,119.24 151.5,119.47 152.99,119.47 153.48,118.98 155.28,118.98 155.66,119.36 v1(155.84,119.36)
  IN3 w0.089: v1(136.89,54.57) 136.97,54.57 137.63,55.23 138.29,55.23 138.79,55.73 140.03,55.73 140.35,55.4 146.18,55.4 147.45,56.67 147.45,57.38 148.09,58.02 148.09,59.85 148.47,60.23 148.47,63.26 147.02,64.71 147.02,65.64 146.77,65.9 146.14,65.9 145.8,65.57 144.03,65.57 143,64.54 141.88,64.54 141.52,64.89 141.52,65.7 142.99,67.17 146.08,67.17 147.02,68.11 147.02,70.12 148.67,71.77 153.17,71.77 154.02,72.63 154.54,72.63 156.95,75.04 157.56,75.04 160.41,77.89 160.41,79.93 160.07,80.28 160.07,82.79 159.88,82.98 159.88,86.33 157.39,88.82 157.39,90.58 153.37,94.59 150.9,94.59 149.78,95.71 149.78,98.87 148.18,100.47 148.18,100.91 146.45,102.64 146.03,102.64 144.83,103.83 144.83,105.33 144.64,105.52 144.64,109.56 145.07,109.98 145.07,110.84 145.47,111.24 145.47,111.89 145.82,112.24 145.82,114.42 145.63,114.61 145.63,115.05 145.88,115.3 145.88,115.66 144.08,117.46 143.03,117.46 142.45,118.04 142.45,118.39 v1(142.34,118.5)
  BOTTOM w0.102: U45.AB5 142.19,118.35 v1(142.34,118.5)
  BOTTOM w0.14: v1(159.39,105.09) 159.37,105.09 159.34,105.06 159.34,105.01 158.84,104.51 R653.2
BAT-V: length 3.9
  BOTTOM w0.14: PR209.2 54.86,57.6 54.44,58.02 54.19,58.02 53.68,58.53 52.28,58.53 52.03,58.28 PR207.2
  vias: v2(32.09,57.26) v2(32.09,56.5) v2(32.09,55.74) v2(32.09,54.97) v2(32.09,54.21) v2(32.09,53.45) v2(33.11,54.85) v2(33.11,54.09) v2(33.11,53.32) v2(42.15,55.91) v2(42.15,55.03) v2(43.16,55.91) v2(43.16,55.03) v2(44.43,55.91) v2(44.43,55.03) v2(45.58,55.03) v2(46.59,55.03) v3(34.38,54.97)
BATLED0#: length 254.6
  TOP w0.203: U32.29 141.05,54.93 141.18,54.8 141.18,53.45 140.93,53.2 v1(140.67,53.2)
  IN3 w0.254: v2(22.82,164.19) 22.82,161.15 18.37,156.7 11.9,156.7 11.06,155.86 11.06,152.72 13.47,150.31 13.47,143.7 16.85,140.32 16.85,139.05 19.03,136.86 19.03,128.41 21.8,125.64 21.8,121.01 25.1,117.71 26.25,117.71 27.01,116.95 27.01,115.77 31.45,111.32 31.45,102.47 31.02,102.04 31.02,100.61 33.74,97.89 33.74,95.21 34.82,94.13 34.82,87.11 31.29,83.58 31.29,78.35 32.4,77.24 32.4,64.64 31.96,64.2 31.96,57.89 31.54,57.47 31.54,53.24 33.21,51.57 35.56,51.57 36.37,50.76 48.62,50.76 50.4,48.98 55.58,48.98 57.33,47.23 58.31,47.23 58.47,47.38 62.84,47.38 63.36,46.87 65.44,46.87 65.76,46.55 67.66,46.55 68.22,45.99 89.21,45.99 91.21,48 95.19,48 95.96,48.77 104.88,48.77 105.2,49.09 105.96,49.09 106.64,49.77 111.45,49.77 112.81,48.42 119.88,48.42 120.4,48.93 129.44,48.93 130.39,49.88 132.42,49.88 134.12,51.59 136.46,51.59 137.47,52.6 138.15,52.6 138.87,53.32 140.55,53.32 v1(140.67,53.2)
  BOTTOM w0.254: R439.1 v2(22.82,164.19) R432.1 ; v1(139.79,53.2) v1(140.67,53.2)
BATLED1#: length 239.1
  TOP w0.203: U32.25 v1(138.93,56.53)
  IN3 w0.254: v2(23.83,164.19) 23.83,161.15 16.24,153.55 16.24,143.72 20.1,139.86 20.1,128.86 22.95,126.02 22.95,121.65 25.68,118.92 26.69,118.92 30.82,114.79 31.71,114.79 35.48,111.02 35.48,102 35.88,101.6 35.88,100.25 35.38,99.75 35.38,95.89 36.46,94.81 36.46,75.53 34.94,74.01 34.94,54.29 35.89,53.34 44.27,53.34 45.04,52.56 49.16,52.56 51.1,50.62 60.31,50.62 61.79,49.14 63.41,49.14 64.04,48.51 66.12,48.51 66.42,48.21 68.32,48.21 68.9,47.63 81.11,47.63 82.08,48.6 89.5,48.6 91.39,50.49 104.28,50.49 104.52,50.73 105.05,50.73 106.47,52.15 111.41,52.15 113.31,50.24 119.31,50.24 119.67,50.61 128.55,50.61 130.17,52.22 131.85,52.22 134.35,54.72 135.1,54.72 136.01,55.64 136.71,55.64 137.12,56.04 137.12,56.63 137.47,56.98 138.47,56.98 v1(138.93,56.53)
  BOTTOM w0.254: R440.1 v2(23.83,164.19) R433.1
BATT_EN#: length 4.3
  TOP w0.14: v1(29.93,58.66) 30.37,59.1 v1(30.45,59.1)
  TOP w0.305: PR103.2 30.45,59.1 v1(30.45,59.1)
  BOTTOM w0.508: v1(30.45,59.1) 30.45,58.67 29.6,57.82 PJ2.6
BC_CEN: length 9.5
  TOP w0.14: U25.1 226.9,68.32 227.54,67.67 228.81,67.67 229.57,66.91 v1(230.97,66.91) 232.5,65.39 R331.1 231.61,65.02 231.61,65.01 U26.2
BEEP_1: length 4.4
  TOP w0.14: v1(228.43,33.27) R412.2 C509.1 C508.2 230.24,34.65 R409.1
BEEP_2: length 9.5
  TOP w0.14: R409.2 v1(228.18,35.43) 225.5,35.43 223.73,37.19 223.73,38.62 D20.1 D19.1
BL#: length 7
  TOP w0.14: R192.1 63.21,106.79 62.57,106.79 62.06,106.28 v1(62.06,105.27) 62.06,104.91 62.72,104.25 Q18.2 63.97,104.25 64.09,104.12 64.09,103.74 63.95,103.6 Q18.3
BL_ON: length 15.2
  TOP w0.14: Q18.6 65.37,105.31 64.65,106.03 64.65,106.5 R190.1 63.97,107.67 63.97,108.19 v1(63.33,108.82) 60.82,108.82 Q16.3 59.29,106 v1(59.56,105.73) 59.56,105.23 60.66,104.12 D5.2
  BOTTOM w0.14: v1(59.56,105.73) 59.55,105.73 CN7.26
BOARD_ID0: length 6.5
  BOTTOM w0.076: U45.P1 146.89,122.1 147.46,122.67 R559.1
  BOTTOM w0.14: R561.2 150.32,122.93 150.04,123.21 149.53,123.21 149.47,123.15 149.46,123.15 149.41,123.1 148.72,123.1 R559.1
BOARD_ID1: length 19.3
  IN2 w0.114: v1(151.72,123.22) 151.72,124.7 151.09,125.33 149.06,125.33 148.48,124.76 148.48,124.24 147.6,123.36 146.32,123.36 145.98,123.02 145.98,122.28 145.8,122.11 144.92,122.11 144.1,122.92 142.98,122.92 v1(142.36,122.3)
  BOTTOM w0.102: U45.R5 142.19,122.13 v1(142.36,122.3)
  BOTTOM w0.14: v1(151.72,123.22) 151.98,123.48 151.98,124.45 R547.1 153.24,125.09 153.63,124.7 154.51,124.7 R549.2
BOARD_ID2: length 9.7
  IN2 w0.114: v1(147.1,124.85) 147.1,124.16 v1(146.82,123.89)
  BOTTOM w0.076: U45.L4 143.19,123.25 144.29,123.25 144.4,123.15 145.16,123.15 145.25,123.24 145.85,123.24 146.5,123.89 v1(146.82,123.89)
  BOTTOM w0.089: R540.2 148.09,125.84 v1(147.1,124.85)
  BOTTOM w0.14: R540.2 148.29,125.84 148.8,126.35 150.07,126.35 150.32,126.1 R541.1
BOARD_ID3: length 10.4
  TOP w0.14: v1(145.02,130.57) 145.02,131.07 v1(145.63,131.68) 146.01,132.06 147.13,132.06 147.79,132.72 147.79,133.47 R89.1 R88.2
  BOTTOM w0.076: U45.C4 143.21,129.31 143.21,129.78 143.29,129.85 143.29,130.24 143.72,130.67 143.77,130.67
  BOTTOM w0.14: v1(145.02,130.57) 144.53,131.05 144.15,131.05 143.77,130.67
BOARD_ID4: length 9
  BOTTOM w0.076: U45.L3 143.85,123.9 145.79,123.9 146.71,124.81 146.71,125.04 146.88,125.22
  BOTTOM w0.089: 146.88,125.22 148.29,126.62 R536.2
  BOTTOM w0.14: R536.2 148.79,127.36 150.07,127.36 150.32,127.12 R537.1
BT_LED: length 2.7
  BOTTOM w0.14: CN12.16 219.39,76.46 219.03,76.82 TP150.1
BT_POWERON: length 139.7
  TOP w0.14: U32.104 151.44,65.8 152.28,64.96 153.55,64.96 154.14,64.37 154.14,62.87 153.59,62.33 153.08,62.33 v1(152.87,62.11)
  IN1 w0.114: v1(213.67,66.71) 214.84,65.54 214.84,60.66 216.5,59.01 218.37,59.01 219.55,57.82 219.55,54.33 219.83,54.05 219.83,48.97 218.4,47.54 218.4,42.75 216.87,41.22 209.89,41.22 207.69,43.42 201.25,43.42 200.45,42.62 196.45,42.62 194.36,44.71 187.95,44.71 185.05,47.61 180.3,47.61 179.94,47.25 177.6,47.25 175.29,44.94 174.33,44.94 173.44,45.83 172.3,45.83 169.63,48.5 162.4,48.5 161.12,49.78 161.12,53.96 159.55,55.53 159.55,56.18 156.04,59.7 156.04,60.44 155.15,61.32 153.65,61.32 v1(152.87,62.11)
  BOTTOM w0.14: R701.2 214.6,80.63 210.32,80.63 208.83,79.14 208.83,76.32 v1(213.06,72.09) 214.29,70.87 214.29,67.33 v1(213.67,66.71)
BXTALOUT: length 15.3
  BOTTOM w0.102: 55.46,123.7 55.1,124.05 55.1,124.91 54.07,125.94 53.82,125.94 53.3,126.46 53.3,126.86 53.07,127.09 52.43,127.09 52.1,127.42 U43.C10
  BOTTOM w0.14: R613.1 56.23,115.18 v1(57.24,116.19) 57.24,117.46 56.73,117.97 56.73,122.43 55.46,123.7
CARD_3V3: length 64.1
  TOP w0.279: 212.43,91.55 212.68,91.55 212.81,91.42 213.13,91.42 213.48,91.07 U24.13
  TOP w0.508: 212.43,91.55 211.02,91.55 C300.2 210.16,92.05 v1(209.91,91.8)
  IN3 w0.508: v1(204.28,72.25) 207.17,69.35 213.29,69.35 216.29,66.35 216.29,62.24 218.02,60.51 219.9,60.51 222.34,58.07 v1(222.34,47.1)
  BOTTOM w0.508: v1(204.28,72.25) 206.1,74.08 206.1,78.47 205.7,78.88 205.7,79.82 209.08,83.19 209.08,90.74 209.91,91.58 v1(209.91,91.8)
CATERR#: length 3.2
  TOP w0.14: v1(105.68,124.1) 105.68,123.66 TP28.1
  BOTTOM w0.076: U45.K61 107.24,124.68 106.72,124.68 106.49,124.45 106.49,124.27 106.32,124.1 105.67,124.1 v1(105.68,124.1)
CCD_PWR:
  vias: v1(56.37,106.26) v1(56.35,105.65) v1(56.98,106.26) v1(56.98,105.65) v3(54.62,105.98)
CFG0: length 16.4
  TOP w0.14: R153.1 95.03,117.33 97.45,114.92 101.2,114.92 102.09,115.81 104.48,115.81 TP63.1 105.02,116.35 v1(105.02,116.97)
  BOTTOM w0.076: U45.AC60 107.85,117.32 107.38,117.32 107.34,117.36 106.55,117.36 106.39,117.19 106.01,117.19 105.89,117.31 105.35,117.31 v1(105.02,116.97)
CFG1: length 16.2
  TOP w0.14: R136.1 92.88,120.38 93.37,119.89 96.75,119.89 97.15,119.49 TP45.1 100.72,118.93 v1(100.72,118.91)
  BOTTOM w0.076: v1(100.72,118.91) 100.72,118.52 101.49,117.75 104.43,117.75 104.69,117.49 105.94,117.49 106.07,117.36 106.32,117.36 106.61,117.65 U45.AC62
CFG2: length 6.5
  TOP w0.14: TP44.1 101.38,119.44 v1(101.38,118.86)
  BOTTOM w0.076: v1(101.38,118.86) 101.38,118.2 101.66,117.92 104.51,117.92 104.77,117.66 106.19,117.66 U45.AC63
CFG3: length 18.3
  TOP w0.14: v1(103.13,118.65) 103.13,118.25 102.75,117.86 99.97,117.86 98.95,118.88 93.84,118.88 TP46.1 93.11,119.61 90.26,119.61 R142.1
  BOTTOM w0.076: v1(103.13,118.65) 103.13,118.62 103.33,118.42 104.7,118.42 104.97,118.15 105.82,118.15 105.94,118.27 106.07,118.27 U45.AA63
CFG4: length 17.1
  TOP w0.14: R143.1 92.36,119.11 92.87,118.6 98.88,118.6 99.87,117.62 102.94,117.62 103.16,117.84 106.21,117.84 TP55.1 106.49,117.56 107.38,117.56 v1(107.85,118.02)
  BOTTOM w0.102: U45.AA60 108.15,118.32 v1(107.85,118.02)
CFG5: length 4.5
  BOTTOM w0.076: U45.Y62 106.61,119.15 106.32,118.86 106,118.86 105.63,118.48 105.21,118.48 104.89,118.81 104.89,118.96 104.61,119.24 103.23,119.24 TP128.1
CFG6: length 1.4
  TOP w0.14: v1(107.2,119.52) 107.2,120.14 107.03,120.3 TP40.1
  BOTTOM w0.102: U45.Y61 107.5,119.22 v1(107.2,119.52)
CFG7: length 5.1
  TOP w0.14: v1(104.33,118.86) 104.35,118.86 TP53.1
  BOTTOM w0.076: U45.Y60 107.85,118.82 107.38,118.82 107.34,118.86 106.55,118.86 106.39,118.69 106.07,118.69 105.7,118.32 105.04,118.32 104.5,118.86 v1(104.33,118.86)
CFG8: length 19.6
  TOP w0.14: v1(103.49,120.41) 103.18,120.41 102.57,121.01 TP38.1 99.78,121.01 99.07,120.3 97.48,120.3 97.17,120.61 93.67,120.61 92.78,121.5 92.78,121.89 92.52,122.16 90.76,122.16 90.26,121.65 R125.1
  BOTTOM w0.076: v1(103.49,120.41) 103.49,120.2 104.25,119.44 106.39,119.44 106.69,119.74 106.69,119.74 U45.V62
CFG9: length 17.4
  TOP w0.14: R126.1 93.57,120.37 97.07,120.37 97.44,120 99.27,120 99.91,120.63 101.18,120.63 101.3,120.51 102.32,120.51 TP42.1 102.9,119.92 103.67,119.92 v1(104.15,120.41)
  BOTTOM w0.076: v1(104.15,120.41) 104.95,119.6 106.32,119.6 106.49,119.78 106.49,119.95 106.72,120.19 107.24,120.19 U45.V61
CFG10: length 20.1
  TOP w0.14: R135.1 90.13,120.38 90.56,120.81 92.79,120.81 93.47,120.13 96.85,120.13 97.24,119.74 99.4,119.74 99.78,120.13 101.81,120.13 102.56,119.38 106.24,119.38 TP47.1 107.26,118.96 v1(107.82,119.52)
  BOTTOM w0.102: v1(107.82,119.52) 108.15,119.85 U45.V60
CFG11: length 10.3
  BOTTOM w0.076: TP131.1 100.24,119.29 102.32,119.29 102.88,119.85 102.88,120.41 103.34,120.86 104.99,120.86 105.22,120.63 105.22,120.2 105.38,120.04 105.85,120.04 106,120.19 106.39,120.19 106.55,120.35 107.34,120.35 107.38,120.32 107.85,120.32 U45.U60
CFG12: length 1.8
  TOP w0.14: TP32.1 106.33,122.16 105.62,121.45 v1(105.62,121.4)
  BOTTOM w0.076: v1(105.62,121.4) U45.T63
CFG13: length 10.3
  BOTTOM w0.076: U45.T62 106.45,121 105.48,121 105.24,121.24 105.24,121.55 105.01,121.78 104.2,121.78 103.51,121.09 103.29,121.09 102.7,120.51 102.7,120 102.17,119.47 99.55,119.47 99.27,119.19
  BOTTOM w0.14: TP129.1 99.22,119.14 99.27,119.19
CFG14: length 4.4
  TOP w0.14: v1(104.38,122.21) 104.02,122.21 TP33.1
  BOTTOM w0.076: v1(104.38,122.21) 104.43,122.21 104.69,121.94 105.44,121.94 105.54,121.85 107.08,121.85 U45.T61
CFG15: length 1.5
  TOP w0.14: TP41.1 107.85,120.72 v1(107.85,121.02)
  BOTTOM w0.102: v1(107.85,121.02) 108.15,121.32 U45.T60
CFG_RCOMP: length 8.9
  TOP w0.254: R129.2 99.02,121.4 99.4,121.78 v1(100.8,121.78) 102.57,121.78 103.21,121.14 104.21,121.14 104.83,120.51 v1(104.83,120.46)
  BOTTOM w0.178: U45.V63 106.12,119.82 105.11,119.82 104.83,120.1 v1(104.83,120.46)
CK_XDP_N_R: length 2.1
  TOP w0.14: TP3.1 111.69,139.65 111.69,138.84 R82.1
CK_XDP_P_R: length 2.1
  TOP w0.14: TP2.1 111.37,139.68 111.37,138.84 R81.1
CL_CLK: length 3.1
  BOTTOM w0.076: TP135.1 146.84,116.57 144.63,116.57 U45.AF2
CL_DAT: length 3.5
  BOTTOM w0.076: U45.AD2 144.47,117.15 144.95,117.15 145.07,117.02 146.19,117.02 147.02,117.86 TP133.1
CL_RST#: length 4.6
  BOTTOM w0.076: TP140.1 146.69,115.68 146.34,115.68 145.95,116.07 145.2,116.07 144.95,115.82 144.53,115.82 144.36,115.65 143.71,115.65 143.62,115.74 143.2,115.74 U45.AF4
CLK_PCH_PCI3: length 13.7
  TOP w0.14: R223.2 R224.2 142.45,102.78 142.38,102.85 v1(142.38,103.23)
  IN1 w0.114: v1(142.38,103.23) 142.38,103.49 141.82,104.05 141.82,105.01 141.51,105.32 140.95,105.32 138.72,107.55 138.68,107.55 137.66,108.57 137.66,109.45 136.59,110.52 136.59,110.71 v1(136.09,111.22)
  BOTTOM w0.102: v1(136.09,111.22) 136.54,111.67 U45.AN15
CLK_PCH_PCI4: length 11.9
  TOP w0.14: R222.2 140.42,102.36 141.26,103.2 v1(141.26,104.81)
  IN1 w0.114: v1(141.26,104.81) 140.75,104.81 139.85,105.71 139.85,106.09 138.6,107.34 138.46,107.34 137.35,108.45 137.35,109.26 136.11,110.49 v1(136.11,110.6)
  BOTTOM w0.102: v1(136.11,110.6) 136.54,111.02 U45.AP15
CLK_PCI_EC: length 61.5
  TOP w0.14: R222.1 C288.2 140.07,100.32 139.81,100.07 v1(139.81,98.41) 139.81,97.92 136.93,95.04 136.93,89.23 139.53,86.63 139.53,84.97 139.79,84.72 140.32,84.72 140.57,84.46 140.57,84.24 140.32,83.98 139.2,83.98 138.97,83.74 138.97,83.41 139.2,83.17 142.86,83.17 143.11,82.91 143.11,76.82 142.86,76.56 141.74,76.56 141.49,76.31 141.49,75.95 141.74,75.7 143.6,75.7 143.72,75.57 143.72,75.02 143.6,74.89 142.35,74.89 142.13,74.67 142.13,74.37 142.35,74.15 v1(143.6,74.15) ; R348.2 137.76,60.69 v1(138.26,60.69) 138.9,61.33 U32.13
  IN1 w0.114: v1(143.6,74.15) 143.98,73.77 143.98,72.63 142.58,71.23 142.58,70.49 139.38,67.29 139.38,62.19 138.26,61.07 v1(138.26,60.69)
CLK_PCI_LPC: length 213
  TOP w0.14: v1(150.66,72.3) 150.66,73.03 151.39,73.77 151.39,82.08 149.67,83.8 v1(147.79,83.8) 142.1,83.8 140.67,85.23 140.67,86.22 137.45,89.45 137.45,94.82 140.94,98.32 141.45,98.32 141.96,98.82 141.96,100.01 141.64,100.32 C289.2 R223.1 ; v1(207.21,39.33) 207.92,40.04 217.63,40.04 220.94,43.35 220.94,47.09 233.38,59.53 233.38,65.64 230.84,68.18 229.7,68.18 227.29,70.6 227.29,73.92 226.55,74.66 226.55,80.65 227.06,81.16 227.06,88.7 R275.1
  IN1 w0.114: v1(207.21,39.33) 206.73,38.85 194.01,38.85 190.97,41.89 186.65,41.89 184.1,44.43 178.77,44.43 173.69,39.35 163.53,39.35 162.14,40.75 161.46,40.75 160.96,41.24 160.96,43.75 155.41,49.31 155.41,50.8 154.26,51.94 154.26,53.88 153.56,54.58 150.01,54.58 148.22,56.37 146.25,56.37 143.85,58.77 143.35,58.77 142.78,59.34 142.78,59.83 141.55,61.06 141.55,65.68 145.76,69.89 146.69,69.89 147.51,70.71 148.21,70.71 149.22,71.72 150.08,71.72 v1(150.66,72.3)
CLK_PCI_LPC_R: length 5.1
  TOP w0.14: R791.2 225.25,89.15 225.18,89.21 225.18,89.44 225.99,90.26 226.22,90.26 v1(226.4,90.08) 226.53,90.2 226.97,90.2 R275.2
  BOTTOM w0.14: v1(226.4,90.08) 226.7,90.38 226.85,90.38 227.01,90.21 CN12.71
CLK_PCIE_LAN_REQ#: length 85.9
  TOP w0.14: v1(178.01,92.57) 179.79,92.57 180.55,91.8 187.16,91.8 192.29,86.67 197.16,86.67 199.46,84.38 199.46,83.08 204.32,78.22 205.44,78.22 206.59,77.07 206.59,73.22 208.88,70.93 209.97,70.93 R307.2 210.57,71.35 210.91,71.69 210.91,73.39 Q26.1
  IN1 w0.114: v1(178.01,92.57) 177.3,92.57 172.84,97.03 165.93,97.03 161.64,101.32 161.64,104.62 160.87,105.39 160.87,109.74 160.44,110.16 160.44,110.98 160.18,111.24 159.93,111.24 156.68,114.49 156.68,115.81 v1(156.04,116.44)
  BOTTOM w0.14: v1(156.04,116.44) 155.91,116.32 R600.1
CLK_PCIE_LANN: length 140
  TOP w0.14: U24.28 210.5,84.21 210.38,84.33 204.44,84.33 204.09,83.98 204.09,83.66 v1(204.2,83.55)
  IN3 w0.089: v1(204.2,83.55) 204.03,83.72 204.03,84.54 203.03,85.54 199.51,85.54 196.82,88.24 184.63,88.24 167.82,105.05 167.82,114.9 156.02,126.7 156.02,127.64 152.36,131.3 152.36,135.37 149.13,138.6 149.13,140.1 146.44,142.78 140.38,142.78 140.07,142.47 138.38,142.47 136.62,140.71 126.4,140.71 125.84,141.27 122.96,141.27 119.72,138.03 119.72,134.64 119.22,134.15 119.22,132.57 119.47,132.33 119.73,132.33 v1(119.87,132.19)
  BOTTOM w0.076: U45.C41 120.08,128.96 119.8,129.24 119.8,129.45 119.47,129.78 119.47,132.27 119.57,132.37 119.69,132.37 v1(119.87,132.19)
CLK_PCIE_LANP: length 140
  TOP w0.14: U24.27 210.45,84.71 210.38,84.65 204.3,84.65 203.77,84.11 203.77,83.73 203.59,83.55 v1(203.44,83.55)
  IN3 w0.089: v1(119.88,132.89) 119.88,132.73 119.72,132.57 119.57,132.57 119.47,132.67 119.47,134.05 119.96,134.54 119.96,137.93 123.06,141.03 125.74,141.03 126.3,140.47 136.72,140.47 138.48,142.22 140.17,142.22 140.48,142.54 146.34,142.54 148.89,140 148.89,138.5 152.12,135.27 152.12,131.2 155.77,127.54 155.77,126.6 167.58,114.8 167.58,104.95 184.53,87.99 196.72,87.99 199.41,85.3 202.93,85.3 203.79,84.44 203.79,83.63 203.72,83.55 v1(203.44,83.55)
  BOTTOM w0.076: U45.B42 119.59,129.1 119.64,129.14 119.64,129.38 119.3,129.72 119.3,132.34 119.5,132.53 119.68,132.53 119.88,132.73 v1(119.88,132.89)
CLK_PCIE_N0: length 11.5
  BOTTOM w0.076: 115.93,134.96 116.02,134.87 116.02,134.38 117.11,133.3 117.87,133.3 118.44,132.73 118.44,130.24 arc(118.44,130.21) 118.45,130.18 118.48,130.04 118.48,130.04 118.5,129.97 118.56,129.85 118.56,129.69 118.53,129.63 118.51,129.57 118.5,129.54 118.5,129.35 118.53,129.25 118.54,129.19 118.95,128.78 U45.C43
  BOTTOM w0.14: TP106.1 116.62,137.58 116.62,137.11 115.93,136.42 115.93,134.96
CLK_PCIE_P0: length 12
  BOTTOM w0.076: U45.C42 119.25,128.9 119.05,129.09 118.87,129.09 118.69,129.27 118.66,129.38 118.66,129.51 118.69,129.57 118.72,129.66 118.72,129.88 118.66,130 118.64,130.08 118.64,130.08 118.61,130.22 arc(118.61,130.23) 118.61,130.24 118.61,132.79 117.94,133.46 117.18,133.46 116.19,134.45 116.19,134.88 116.25,134.94 116.25,134.96
  BOTTOM w0.14: TP107.1 116.94,137.54 116.94,136.98 116.25,136.29 116.25,134.96
CLK_PCIE_REQ0#: length 9.9
  BOTTOM w0.076: 151.34,120.51 R576.2 150.72,120.89 150.02,120.89 149.89,120.76 149.44,120.76 149.31,120.89 148.27,120.89 147.72,121.43 147.02,121.43 146.56,120.97 145.96,120.97 145.76,120.77 145.07,120.77 144.95,120.9 144.47,120.9 U45.U2
  BOTTOM w0.14: 151.34,120.51 TP126.1
CLK_PCIE_REQ1#: length 24.1
  TOP w0.14: v1(156.78,120.71) 155.97,120.71 v1(155.94,120.68)
  IN1 w0.114: v1(155.94,120.68) 155.49,120.68 154.64,121.52 154.64,121.95 153.45,123.15 152.54,123.15 151.72,122.33 150.46,122.33 150.08,121.95 149.34,121.95 148.9,122.39 147.99,122.39 147.81,122.21 147.81,120.79 148.1,120.51 148.1,120.13 147.86,119.89 147.58,119.89 146.88,119.19 144.78,119.19 144.08,119.9 142.98,119.9 v1(142.53,119.45)
  BOTTOM w0.102: U45.Y5 142.19,119.11 v1(142.53,119.45)
  BOTTOM w0.14: R572.2 157.69,120.88 157.19,120.38 156.24,120.38 v1(155.94,120.68) 155.94,120.27 R582.2
CLK_PCIE_REQ2#: length 11.2
  BOTTOM w0.076: 152.29,116.51 152.1,116.7 150.7,116.7 R596.2 149.91,117.49 148.14,117.49 147.79,117.84 147.53,117.84 147.04,117.34 146.83,117.34 146.34,116.86 U45.AD1
  BOTTOM w0.14: 152.29,116.51 152.49,116.32 152.69,116.32 v1(152.89,116.11) 153.09,115.91 154.23,115.91 154.63,116.32 R600.2
CLK_PCIE_REQ3#: length 7.4
  BOTTOM w0.076: U45.N1 145.1,122.85 145.32,123.07 146.67,123.07 146.85,123.25
  BOTTOM w0.14: R545.2 151.1,124.48 150.94,124.32 148.55,124.32 148.29,124.05 R550.2 147.93,123.45 147.05,123.45 146.85,123.25
CLK_PCIE_REQ4#: length 22.6
  IN1 w0.114: v1(155.96,121.75) 155.96,121.98 155.54,122.41 155.11,122.41 153.71,123.8 153,123.8 152.67,124.14 151.01,124.14 150.13,123.25 148.53,123.25 148.31,123.03 147.57,123.03 146.57,122.03 145.47,122.03 144.85,121.41 142.4,121.41 v1(142.35,121.36)
  BOTTOM w0.102: U45.U5 142.19,121.19 v1(142.35,121.36)
  BOTTOM w0.14: R573.2 158.72,122.16 157.69,122.16 157.44,121.9 157.44,121.51 R571.1 155.96,121.72 v1(155.96,121.75) 155.71,121.5 155.71,121.19 155.29,120.77 R577.1
CLK_PCIE_REQ5#: length 9.2
  BOTTOM w0.076: 151.34,121.09 149.95,121.09 149.82,120.96 149.49,120.96 149.36,121.09 148.51,121.09 148.29,121.32 R569.2 147.91,121.52 147.84,121.6 146.31,121.6 145.65,120.94 145.14,120.94 145.01,121.06 144.47,121.06 U45.T2
  BOTTOM w0.14: 151.34,121.09 151.85,121.09 TP123.1
CLK_PCIE_VGA: length 108.3
  IN1 w0.102: v1(34.32,126.22) 34.57,125.98 34.57,125.69 35.8,124.46 45.83,124.46 47.99,122.3 77.99,122.3 96.78,141.09 105.6,141.09 106.19,141.69 116.67,141.69 v1(116.9,141.46)
  BOTTOM w0.076: 119.02,135.11 119.02,135.09 119.1,135.02 119.1,133.99 119.54,133.55 120.32,133.55 120.8,133.07 120.8,131.62 120.72,131.55 120.72,130.68 121,130.4 121,129.92 121.2,129.72 121.22,129.72 121.46,129.48 U45.B39
  BOTTOM w0.102: U43.AE8 v1(34.32,126.22)
  BOTTOM w0.14: v1(116.9,141.46) 117.06,141.63 117.43,141.63 117.56,141.5 117.56,140.19 119.21,138.54 119.21,136.44 119.02,136.25 119.02,135.11
CLK_PCIE_VGA#: length 108.2
  IN1 w0.102: v1(116.9,142.22) 116.61,141.93 106.09,141.93 105.5,141.33 96.68,141.33 77.89,122.54 48.09,122.54 45.93,124.7 35.9,124.7 34.81,125.79 34.81,125.91 v1(35.12,126.22)
  BOTTOM w0.076: U45.A39 121.46,129.94 121.41,129.88 121.27,129.88 121.17,129.99 121.17,130.47 120.89,130.75 120.89,131.48 120.96,131.56 120.96,133.14 120.38,133.71 119.6,133.71 119.26,134.06 119.26,135.02 119.34,135.09 119.34,135.11
  BOTTOM w0.102: U43.AD8 v1(35.12,126.22)
  BOTTOM w0.14: 119.34,135.11 119.34,136.12 119.53,136.31 119.53,138.67 117.88,140.32 117.88,141.63 117.56,141.94 117.18,141.94 v1(116.9,142.22)
CLK_PCIE_WIGIGN: length 161
  TOP w0.14: R790.1 224.94,88.05 224.94,87.67 224.75,87.48 v1(224.49,87.48)
  IN3 w0.089: v1(119.87,130.82) 119.71,130.98 119.26,130.98 118.39,131.86 118.39,134.63 118.84,135.09 118.84,138.43 122.63,142.21 126.09,142.21 126.75,141.55 136.17,141.55 138.76,144.14 140.39,144.14 140.83,143.71 146.72,143.71 149.97,140.46 149.97,138.97 153.37,135.57 153.37,131.56 157.06,127.87 157.06,126.86 160.36,123.55 160.59,123.55 168.66,115.48 168.66,105.41 184.98,89.09 197.2,89.09 198.67,87.61 204.74,87.61 209.76,82.6 209.76,81.52 210.52,80.76 215.8,80.76 216.14,81.09 220.43,81.09 222.35,83.02 222.35,85.1 224.49,87.24 v1(224.49,87.48)
  BOTTOM w0.076: v1(119.87,130.82) 120,130.69 120,130.54 119.77,130.31 119.77,129.86 120.08,129.54 U45.B41
CLK_PCIE_WIGIGP: length 161
  TOP w0.14: R791.1 225.26,87.99 225.26,87.54 224.92,87.2 v1(224.92,87.05)
  IN3 w0.089: v1(224.92,87.05) 224.64,87.05 222.59,85 222.59,82.91 220.53,80.85 216.24,80.85 215.9,80.51 210.42,80.51 209.52,81.42 209.52,82.5 204.64,87.37 198.57,87.37 197.1,88.85 184.88,88.85 168.42,105.31 168.42,115.38 160.49,123.31 160.26,123.31 156.82,126.76 156.82,127.77 153.13,131.46 153.13,135.47 149.73,138.87 149.73,140.36 146.62,143.47 140.73,143.47 140.29,143.9 138.86,143.9 136.27,141.31 126.65,141.31 125.99,141.97 122.73,141.97 119.08,138.33 119.08,134.98 118.63,134.53 118.63,131.96 119.36,131.23 119.8,131.23 119.87,131.3 v1(119.87,131.43)
  BOTTOM w0.076: U45.A41 119.98,130.07 119.93,130.12 119.93,130.24 120.25,130.56 120.25,131.3 120.13,131.43 v1(119.87,131.43)
CLK_PCIE_WLAN_REQ#_R: length 35.6
  TOP w0.14: Q21.3 201.27,91.8 201.38,91.69 R265.1 R250.1 201.76,93.07 202.32,93.62 v1(202.32,94.19)
  IN3 w0.089: v1(222.08,94.22) 220.81,94.22 220.43,93.84 212.05,93.84 211.41,94.47 202.6,94.47 v1(202.32,94.19)
  BOTTOM w0.14: v1(222.08,94.22) 225.73,90.57 225.73,86.53 226.55,85.71 CN12.53
CLK_PCIE_WLANN: length 165.2
  IN3 w0.089: v1(121.51,131.94) 121.51,131.83 121.62,131.71 121.87,131.71 122.02,131.86 122.02,134.54 121.51,135.05 121.51,138.59 123.48,140.56 125.52,140.56 126.08,140 137,140 138.58,141.58 140.22,141.58 140.57,141.93 145.68,141.93 148.29,139.31 148.29,138.31 150.86,135.75 150.86,134.45 151.2,134.11 151.2,131.21 155.16,127.25 155.16,125.57 156.43,124.3 157.4,124.3 161.49,120.21 161.49,118.11 162.65,116.95 164.64,116.95 167.07,114.52 167.07,104.78 184.32,87.53 196.37,87.53 200.24,83.66 202.03,83.66 202.9,82.8 207.09,82.8 210.16,79.73 214.43,79.73 214.97,79.19 216.46,79.19 217.38,80.11 224.44,80.11 225.01,80.68 225.01,83.52 225.79,84.3 229.22,84.3 229.5,84.58 229.5,84.77 v1(229.19,85.07)
  BOTTOM w0.076: U45.B38 122.02,129.01 121.95,128.94 121.78,128.94 121.69,129.02 121.69,129.24 121.88,129.42 121.88,130.13 121.12,130.89 121.12,131.48 121.51,131.87 v1(121.51,131.94)
  BOTTOM w0.14: CN12.49 228.69,84.71 228.78,84.62 229.32,84.62 229.42,84.72 229.42,84.85 v1(229.19,85.07)
CLK_PCIE_WLANP: length 165.2
  IN3 w0.089: v1(121.5,131.32) 121.65,131.47 121.97,131.47 122.26,131.76 122.26,134.64 121.75,135.15 121.75,138.49 123.58,140.32 125.42,140.32 125.98,139.76 137.1,139.76 138.68,141.33 140.32,141.33 140.67,141.69 145.58,141.69 148.05,139.21 148.05,138.21 150.62,135.65 150.62,134.35 150.96,134.01 150.96,131.11 154.92,127.15 154.92,125.47 156.33,124.06 157.3,124.06 161.25,120.11 161.25,118.01 162.55,116.71 164.54,116.71 166.83,114.42 166.83,104.68 184.22,87.28 196.27,87.28 200.14,83.42 201.93,83.42 202.8,82.55 206.99,82.55 210.06,79.49 214.33,79.49 214.87,78.95 216.56,78.95 217.48,79.87 224.54,79.87 225.26,80.58 225.26,83.42 225.89,84.06 229.32,84.06 229.74,84.48 229.74,84.86 v1(229.96,85.07)
  BOTTOM w0.076: U45.C37 122.39,128.98 122.39,129.22 122.04,129.56 122.04,130.2 121.28,130.96 121.28,131.1 v1(121.5,131.32)
  BOTTOM w0.14: v1(229.96,85.07) 229.74,84.86 229.74,84.59 229.45,84.3 228.78,84.3 228.69,84.21 CN12.47
CLK_PCIE_XDPN: length 51.4
  TOP w0.14: R82.2 111.69,137.23 111.69,135.47 111.94,135.21 113.14,135.21 113.39,135.47 113.39,139.64 113.83,140.08 114.94,140.08 115.38,139.64 115.38,136.38 115.63,136.13 116.47,136.13 v1(116.93,136.59) 117.38,136.13 117.84,136.13 118.26,135.71 118.26,133.92 118.51,133.66 119.16,133.66 119.41,133.92 119.41,137.05 119.07,137.4 117.3,137.4 116.86,137.84 116.86,139 117.3,139.44 121.36,139.44 121.8,139 121.8,135.54 122.18,135.16 125.57,135.16 126.01,134.72 126.01,133.77 125.57,133.33 122.67,133.33 122.4,133.07 122.4,131.75 122.61,131.54 122.75,131.54 v1(122.89,131.68)
  BOTTOM w0.076: U45.B35 124.08,129.54 124.2,129.54 124.42,129.75 124.42,130.32 124.07,130.67 123.76,130.67 123.28,131.15 123.28,131.3 v1(122.89,131.68)
CLK_PCIE_XDPP: length 51.4
  TOP w0.14: R81.2 111.37,137.23 111.37,135.34 111.81,134.9 113.27,134.9 113.71,135.34 113.71,139.51 113.97,139.76 114.8,139.76 115.06,139.51 115.06,136.25 115.5,135.81 116.43,135.81 v1(116.93,135.32) 117.42,135.81 117.71,135.81 117.94,135.58 117.94,133.79 118.38,133.35 119.29,133.35 119.73,133.79 119.73,137.18 119.2,137.72 117.43,137.72 117.18,137.97 117.18,138.87 117.43,139.13 121.23,139.13 121.48,138.87 121.48,135.41 122.05,134.85 125.43,134.85 125.69,134.59 125.69,133.91 125.43,133.65 122.53,133.65 122.08,133.2 122.08,131.61 122.47,131.22 122.72,131.22 v1(122.89,131.05)
  BOTTOM w0.076: v1(122.89,131.05) 123.15,131.05 123.69,130.5 124,130.5 124.25,130.25 124.25,129.82 124.13,129.7 124.06,129.7 123.97,129.79 U45.A35
CLK_PEGA_REQ#: length 295.8
  TOP w0.14: v1(22.56,118.73) 22.69,118.6 R147.2 24.26,117.92 27.44,117.92 Q11.3
  IN1 w0.114: v1(153.88,116.34) 154.52,116.34 155.34,117.16 155.34,119.88 155.58,120.13 155.91,120.13 v1(156.42,119.62)
  IN3 w0.089: v1(153.88,116.34) 153.88,115.05 154.9,114.03 155.2,114.03 156.59,112.64 156.59,110.15 156.98,109.76 156.98,105.47 157.31,105.14 157.31,103.49 157.04,103.22 157.04,101.75 156.36,101.07 156.36,99.03 157.59,97.8 157.59,97.07 164.12,90.54 164.12,87.86 164.88,87.09 164.88,85.57 167,83.46 167,77.44 166.4,76.84 166.4,75.13 160.22,68.94 157.57,68.94 156.73,68.1 153.53,68.1 151.98,66.54 151.98,63.48 151.49,63 151.49,58.91 150.71,58.12 150.71,57.18 148.75,55.23 147.71,55.23 146.84,54.36 142.96,54.36 141.09,52.49 139.58,52.49 139.04,51.94 137.8,51.94 136.79,50.93 134.4,50.93 132.69,49.23 130.69,49.23 129.72,48.26 120.66,48.26 120.15,47.76 110.67,47.76 109.31,49.12 106.97,49.12 106.28,48.43 105.47,48.43 105.15,48.12 96.23,48.12 95.46,47.34 91.48,47.34 89.48,45.34 67.94,45.34 67.39,45.9 66.54,45.9 65.74,45.1 62.83,45.1 61.2,46.73 58.74,46.73 57.9,45.89 50.64,45.89 48.66,47.88 48.66,48.88 47.5,50.04 36.16,50.04 35.29,50.92 32.94,50.92 30.89,52.97 30.89,57.74 31.31,58.16 31.31,64.47 31.72,64.89 31.72,73.62 31.13,74.21 31.13,77.58 30.63,78.08 30.63,83.85 34.17,87.38 34.17,93.86 33.09,94.94 33.09,97.62 30.37,100.34 30.37,102.74 29.38,103.73 29.38,112.74 23.52,118.6 22.69,118.6 v1(22.56,118.73)
  BOTTOM w0.14: v1(156.42,119.62) 156.42,119.87 156.65,120.1 157.36,120.1 157.72,120.46 158.91,120.46 159.22,120.76 R573.1
CLK_SCLK: length 308.8
  TOP w0.14: v1(157.69,79.67) 156.24,79.67 155.57,80.34 155.57,83.51 TP89.1 154.64,84.44 154.64,85.71 153.94,86.41 153.94,90.15 152.99,91.09 152.99,91.42 153.32,91.75 153.32,94.27 152.8,94.79 152.04,94.79 151.84,94.99 R241.1 151.21,95.49 150.96,95.74 Q20.1 ; v1(108.54,48.64) 108.54,48.65 107.32,49.87 97.93,49.87 96.79,51.01 89.77,51.01 89.05,51.73 81.13,51.73 v1(80.91,51.95)
  IN1 w0.114: v1(219.41,50.66) 218.78,51.29 218.78,53.6 219.19,54.01 219.19,57.67 218.21,58.64 215.42,58.64 214.38,59.68 214.38,64.29 209.08,69.58 207.43,69.58 205.62,71.39 203.54,71.39 202.78,72.15 202.78,76.39 200.57,78.6 191.3,78.6 187.75,82.15 182.33,82.15 180.83,83.66 177.42,83.66 172.58,88.5 165.99,88.5 165.23,87.74 162.01,87.74 160.87,86.6 160.87,83.42 158.45,81.01 158.45,80.43 v1(157.69,79.67)
  IN3 w0.089: v1(80.91,51.95) 80.48,52.38 80.14,52.38 79.58,51.82 78.42,51.82 77.6,51 73.35,51 73.09,51.26 71.49,51.26 70.72,52.03 65.71,52.03 65.44,52.3 64.33,52.3 63.79,52.83 63.79,53.44 62.71,54.52 62.71,55.02 62.02,55.71 62.02,58.29 61.67,58.65 61.67,59.06 62.15,59.54 62.15,63.87 62.42,64.15 62.42,66 63.17,66.75 63.17,69.34 63.08,69.43 63.08,70.85 63.71,71.48 63.71,72.62 65.2,74.1 68.72,74.1 78.27,83.65 79.92,83.65 80.56,84.3 80.56,84.65 81.21,85.3 v1(81.87,85.3)
  BOTTOM w0.14: v1(157.69,79.67) 158.02,79.67 159.08,78.61 JDIM1.202 159.08,73.6 157.26,71.79 154.7,71.79 154.4,71.48 153.46,71.48 153.12,71.15 145.16,71.15 142.74,68.73 137.29,68.73 136,70.02 128.75,70.02 126.63,72.15 117.41,72.15 116.25,73.31 103.49,73.31 103.04,73.76 95.3,73.76 83.75,85.3 v1(81.87,85.3) ; R772.1 109.43,44.81 108.52,45.73 108.52,48.62 v1(108.54,48.64) ; v1(219.41,50.66) 219.92,50.66 220.69,51.43 C757.1 R755.1
CLK_SDATA: length 308
  TOP w0.14: Q20.4 149.23,92.95 149.11,92.83 R257.1 149.11,91.88 150.52,90.47 152.16,90.47 152.36,90.66 152.82,90.66 153.55,89.94 153.55,84.27 TP88.1 155.18,82.64 155.18,80.17 156.07,79.28 157.39,79.28 v1(157.69,78.98) ; v1(107.91,48.65) 108.34,48.22 108.72,48.22 108.97,48.47 108.97,48.9 107.6,50.26 98.09,50.26 96.95,51.41 90.01,51.41 89.3,52.12 81.8,52.12 81.49,52.43 80.78,52.43 v1(80.3,51.95)
  IN1 w0.114: v1(157.69,78.98) 158.96,80.25 158.96,80.8 161.38,83.21 161.38,86.39 162.22,87.23 165.44,87.23 166.2,87.99 172.56,87.99 177.27,83.29 179.67,83.29 181.31,81.64 187.54,81.64 191.09,78.09 200.36,78.09 202.27,76.18 202.27,71.61 203.32,70.56 205.73,70.56 207.22,69.07 208.87,69.07 213.81,64.14 213.81,54.29 214.01,54.09 214.01,53.3 215.47,51.84 217.22,51.84 v1(218.4,50.66)
  IN3 w0.089: v1(82.3,85.73) 81.16,85.73 80.22,84.8 80.22,84.44 79.78,83.99 78.13,83.99 68.58,74.44 64.72,74.44 63.66,73.39 63.2,73.39 62.7,72.88 62.7,69.33 62.82,69.2 62.82,66.91 62.08,66.17 62.08,64.29 61.81,64.02 61.81,62.37 61.33,61.89 61.33,58.5 61.68,58.15 61.68,55.57 62.37,54.88 62.37,54.37 63.43,53.31 63.43,52.7 64.19,51.95 65.3,51.95 65.56,51.69 70.58,51.69 71.61,50.66 77.74,50.66 78.56,51.48 79.72,51.48 80.2,51.95 v1(80.3,51.95)
  BOTTOM w0.14: v1(107.91,48.65) 108.11,48.45 108.11,45.58 109.05,44.64 109.05,43.8 109.31,43.54 R776.1 ; v1(157.69,78.98) 158.48,78.19 JDIM1.200 158.48,73.56 157.14,72.22 154.14,72.22 153.86,71.94 153.36,71.94 152.96,71.54 144.8,71.54 142.38,69.12 137.45,69.12 136.17,70.41 128.92,70.41 126.79,72.54 118.23,72.54 117.07,73.7 103.65,73.7 103.2,74.15 95.46,74.15 83.88,85.73 v1(82.3,85.73) ; R761.1 C763.1 218.79,50.66 v1(218.4,50.66)
CLKRUN#: length 117
  TOP w0.14: v1(155.86,70.06) 156.36,69.57 156.36,67.99 154.77,66.4 154.77,65.13 154.98,64.93 U32.93 156.95,64.93 v1(157.46,65.44) ; R131.1 150.33,121.36 149.86,121.83 147.48,121.83 146.78,122.53 v1(146.4,122.53) 146.17,122.53 145.73,122.09 145.4,122.09 144.53,121.22 144.53,120.69 144.15,120.31 142.9,120.31 142.81,120.4 v1(142.39,120.4)
  IN3 w0.089: v1(146.4,122.53) 146.95,121.98 147.28,121.98 148.75,120.51 148.75,116.36 150.45,114.66 150.45,114.16 151.6,113.01 151.98,113.01 152.12,112.87 152.35,112.87 153.88,111.34 153.88,108.56 152.99,107.68 152.99,106.49 152.1,105.6 152.1,102.15 152.55,101.7 152.55,100.96 152.97,100.54 152.97,98.95 161.17,90.75 161.17,88.13 162.45,86.84 162.45,82.53 164.55,80.44 164.55,78.14 163.92,77.5 163.92,75.93 163.74,75.76 162.5,75.76 157.8,71.05 156.85,71.05 v1(155.86,70.06)
  BOTTOM w0.102: U45.V5 142.19,120.2 v1(142.39,120.4)
  BOTTOM w0.14: v1(157.46,65.44) 158.02,65.44 158.97,64.49 v1(158.97,62.7) 158.97,58.41 158.03,57.47 158.03,49.3 158.84,48.5 158.84,41.64 157.67,40.47 157.67,39.38 158.58,38.46 159.72,38.46 R787.2
COLOR_ENG: length 220.1
  TOP w0.14: U32.87 156.64,62.53 156.81,62.35 156.81,61.55 157.22,61.15 v1(157.69,61.15)
  IN2 w0.114: v1(27.14,97.39) 27.31,97.22 30.82,97.22 31.79,96.24 31.79,91.6 31.26,91.07 31.26,89.51 29.63,87.88 29.63,74.18 30.41,73.4 30.41,69.81 31.73,68.49 31.73,60.66 38.44,53.96 51.58,53.96 56.06,49.48 59.14,49.48 61.52,47.1 63.07,47.1 63.25,46.92 65.29,46.92 66.25,45.96 68.03,45.96 68.98,45.01 90.13,45.01 90.95,45.83 98.76,45.83 100.1,47.17 103.9,47.17 104.23,46.85 112.1,46.85 113.46,48.21 125.66,48.21 128.36,50.91 136.1,50.91 137.63,49.39 151.67,49.39 152.33,50.05 154.92,50.05 155.66,50.78 155.66,56.12 157.28,57.74 157.28,60.73 v1(157.69,61.15)
  IN3 w0.089: v1(38.95,98.99) 39.15,98.99 39.61,99.45 44.69,99.45 45.32,100.08 52.53,100.08 v1(53.03,99.58)
  BOTTOM w0.14: v1(27.14,97.39) 27.14,98.71 27.66,99.24 38.7,99.24 v1(38.95,98.99) ; v1(53.03,99.58) 53.02,99.58 53.04,99.61 53.04,99.67 R670.2
COMBO MIC JD: length 37.6
  TOP w0.14: U34.48 232.21,43.22 v1(231.78,43.65) 231.63,43.8 v1(230.97,43.8) ; C515.2 240.09,25.54 v1(240.24,25.38) 240.5,25.13 R425.1
  IN1 w0.114: v1(231.78,43.65) 234.5,43.65 237.07,46.21 242.53,46.21 243.29,45.45 243.29,41.51 242.53,40.75 242.53,33.26 242.08,32.81 242.08,28.24 241.26,27.42 241.26,26.4 v1(240.24,25.38)
COMBO_MIC: length 9.4
  TOP w0.381: CN21.4 244.86,21.66 v1(242.78,23.73) 242.4,24.11 D25.1 R425.2 R424.1 241.77,26.26 R421.2 R420.2
CPU_DRAMRST#: length 87.6
  TOP w0.14: R376.1 R375.2 114,53.32 114.56,52.77 114.56,51.7 114.16,51.29 v1(114.13,51.29)
  IN1 w0.114: v1(136.6,109.05) 136.99,108.66 136.99,108.06 138.16,106.89 138.74,106.89 139.63,106 139.63,105.31 141.74,103.2 141.74,102.96 143.47,101.24 143.47,96.1 145.63,93.94 145.63,89.75 141.33,85.45 141.33,84.85 139.64,83.16 139.04,83.16 138.26,82.38 138.26,76.06 136.05,73.85 136.05,63.56 136.46,63.15 136.46,61.25 133.54,58.32 133.54,57.23 132.63,56.32 129.95,56.32 127.18,53.55 126.29,53.55 125.01,52.27 118.62,52.27 117.64,51.29 v1(114.13,51.29)
  BOTTOM w0.102: v1(136.6,109.05) 136.29,108.75 U45.AV15
CRT_11: length 2.4
  TOP w0.14: CN3.11 104.1,166.44 TP1.1
CRT_AUXN: length 58.4
  IN1 w0.114: v1(145.11,133.73) 145.11,134.31 145.33,134.54 145.33,135.91 143.76,137.49 141.7,137.49 137.65,141.54 128.76,141.54 126.59,143.71 121.08,143.71 118.92,145.87 114.93,145.87 112.44,148.36 112.44,151.71 111.96,152.19 111.27,152.19 v1(111.08,152.38) 110.91,152.21 109.07,152.21 108.44,152.84 108.19,152.84 v1(107.98,153.04)
  BOTTOM w0.076: U45.B6 141,129.73 141.33,129.73 141.56,129.96 141.56,130.29 142.29,131.01 143.43,131.01 143.89,131.47 143.89,132 144.88,132.99 144.88,133.49 v1(145.11,133.73)
  BOTTOM w0.127: C574.2 110.83,152.64 v1(111.08,152.38) 111.34,152.64 R476.2 ; v1(107.98,153.04) 107.8,152.86 U40.17
CRT_AUXN_C: length 2.8
  BOTTOM w0.127: U40.19 107.64,152.06 107.74,151.95 108.37,151.95 108.67,152.26 109.17,152.26 C574.1
CRT_AUXP: length 58.3
  IN1 w0.114: v1(144.61,134.1) 144.41,134.3 144.41,134.44 144.5,134.53 145.02,134.53 145.12,134.63 145.12,135.82 143.67,137.27 141.61,137.27 137.56,141.33 128.67,141.33 126.5,143.49 120.99,143.49 118.83,145.65 114.84,145.65 112.23,148.27 112.23,151.62 111.87,151.98 111.31,151.98 v1(111.08,151.75) 110.84,152 108.98,152 108.35,152.63 108.17,152.63 v1(107.98,152.43)
  BOTTOM w0.076: v1(144.61,134.1) 144.43,134.1 144.36,134.02 144.36,133.79 144.43,133.71 144.64,133.71 144.71,133.64 144.71,133.05 143.72,132.06 143.72,131.54 143.36,131.17 142.22,131.17 141.4,130.35 141.4,130.03 141.26,129.89 141.13,129.89 141.07,129.95 U45.A6
  BOTTOM w0.127: v1(107.98,152.43) 107.88,152.54 107.68,152.54 107.6,152.46 U40.18 ; C575.2 110.96,151.62 v1(111.08,151.75) 111.21,151.62 R482.2
CRT_AUXP_C: length 2.8
  BOTTOM w0.127: U40.20 107.63,151.66 107.7,151.72 108.46,151.72 108.76,152.03 109.14,152.03 C575.1
CRT_B1: length 7.8
  TOP w0.127: CN3.3 107.78,166.94 v1(107.78,165.08) 107.78,164.88 107.38,164.48 U2.6 U2.5 107.38,161.79 C30.2 L4.2
CRT_BLU: length 8.2
  TOP w0.127: v1(105.24,157.41) 107.61,157.41 108.3,158.1 R13.1 C40.2 L4.1
  BOTTOM w0.127: v1(105.24,157.41) 105.24,157.21 v1(104.86,156.83) 104.57,156.54 U40.8
CRT_CLK: length 7.1
  BOTTOM w0.076: U45.D9 139.88,128.89 140.25,129.25 140.25,129.62 140.58,129.95 140.58,130.31 141.1,130.83 141.35,130.83 141.94,131.43 141.94,132.04 143.6,133.7 R515.2
CRT_DATA: length 6.6
  BOTTOM w0.076: U45.D11 138.97,128.84 139.4,129.27 139.4,129.55 139.66,129.81 139.66,130.33 140.47,131.14 140.47,131.99 141.69,133.21 141.69,133.33 141.94,133.59 R514.2
CRT_G1: length 7.7
  TOP w0.127: L3.2 C29.2 105.49,162.36 105.88,162.76 U2.2 U2.9 105.88,165.71 105.75,165.85 105.75,167.2 CN3.2
CRT_GRE: length 5.8
  TOP w0.127: L3.1 C39.2 R12.1 106.27,158.23 v1(105.88,157.84)
  BOTTOM w0.127: U40.9 104.97,156.3 105.88,157.21 v1(105.88,157.84)
CRT_HPD: length 69.2
  IN1 w0.114: v1(143.09,135.11) 142.58,134.6 140.17,134.6 139.15,135.62 138.01,135.62 135.98,137.65 135.98,138.92 135.51,139.39 127.85,139.39 125.78,141.46 119.85,141.46 118.45,142.86 105.75,142.86 105.16,142.27 98.03,142.27 v1(97.62,141.87)
  IN3 w0.089: v1(97.62,141.87) 97.62,146.92 99.27,148.57 v1(99.27,149.84)
  BOTTOM w0.076: 142.99,133.84 142.99,133.49 142.13,132.64 141.88,132.64 141.06,131.81 141.06,131.02 140.29,130.25 U45.A8
  BOTTOM w0.127: U40.40 99.8,151.26 99.02,150.48 R484.2 99.03,149.84 v1(99.27,149.84) ; v1(143.09,135.11) 142.99,135.01 142.99,133.84
CRT_R1: length 9.1
  TOP w0.127: CN3.1 105.01,166.97 v1(105.01,165.34) 105.01,165.21 105.38,164.84 U2.10 U2.1 105.38,162.94 104.73,162.29 103.72,162.29 103.45,162.03 C28.2 L2.2
CRT_RED: length 8.9
  TOP w0.127: v1(104.83,159.57) 104.83,159.21 R11.1 C38.2 L2.1
  BOTTOM w0.127: U40.11 105.77,155.86 106.1,156.19 106.1,156.55 106.38,156.83 106.38,158.86 105.67,159.57 v1(104.83,159.57)
CRT_TXN0: length 20.8
  BOTTOM w0.076: U45.C51 113.94,128.61 113.85,128.52 113.74,128.52 113.62,128.63 113.62,129.09 113.54,129.17 113.54,129.2 113.51,129.25 113.48,129.35 113.48,129.54 113.49,129.57 113.54,129.69 113.54,129.85 113.53,129.87 113.51,129.91 113.33,130.09 113.33,130.85 111.93,132.25 111.93,135.05 111.88,135.1 111.88,135.11
  BOTTOM w0.14: 111.88,135.11 111.88,137.26 v1(111.36,137.78) 111.88,138.3 111.88,139.27 107.01,144.15 107.01,145.15 C599.2
CRT_TXN0_C: length 3.8
  BOTTOM w0.14: U40.27 105.37,148.61 105.43,148.55 105.43,148.21 107.01,146.62 107.01,146.43 106.88,146.3 C599.1
CRT_TXN1: length 21.1
  BOTTOM w0.076: U45.C53 111.88,128.77 111.69,128.97 111.69,129.22 111.92,129.45 111.92,130.72 110.33,132.31 110.33,132.84 108.89,134.28 108.89,135.04 108.84,135.09 108.84,135.11
  BOTTOM w0.14: 108.84,135.11 108.84,136.14 v1(108.34,136.64) 108.84,137.13 108.84,140.41 104.73,144.52 104.73,145.27 C597.2
CRT_TXN1_C: length 3.3
  BOTTOM w0.14: U40.30 104.17,148.5 104.23,148.45 104.23,147.43 104.85,146.81 104.85,146.67 C597.1
CRT_TXP0: length 20.8
  BOTTOM w0.076: U45.C50 114.5,128.64 114,129.14 113.8,129.14 113.7,129.24 113.66,129.31 113.65,129.38 113.65,129.51 113.67,129.57 113.71,129.66 113.71,129.88 113.65,130 113.5,130.15 113.5,130.92 112.1,132.32 112.1,135.04 112.15,135.09 112.15,135.11
  BOTTOM w0.14: 112.15,135.11 112.15,137.3 v1(112.63,137.78) 112.15,138.26 112.15,139.38 107.27,144.26 107.27,145.14 C600.2
CRT_TXP0_C: length 3.8
  BOTTOM w0.14: C600.1 107.43,146.3 107.28,146.44 107.28,146.74 105.7,148.32 105.7,148.52 105.77,148.6 U40.26
CRT_TXP1: length 21.1
  BOTTOM w0.076: 109.1,135.11 109.1,135.09 109.05,135.04 109.05,134.35 110.5,132.9 110.5,132.38 112.09,130.79 112.09,129.49 112.39,129.19 112.39,129.06 112.28,128.95 112.15,128.95 U45.B54
  BOTTOM w0.14: C598.2 105.36,145.65 105.11,145.65 105,145.54 105,144.63 109.1,140.52 109.1,137.14 v1(109.61,136.64) 109.1,136.13 109.1,135.11
CRT_TXP1_C: length 3.3
  BOTTOM w0.14: U40.29 104.57,148.53 104.49,148.45 104.49,147.55 105.11,146.92 105.11,146.68 C598.1
CRTHSYNC: length 16.5
  TOP w0.127: U5.4 100.45,161.26 v1(101,161.81) ; CN3.13 108.7,165.56 v1(109.18,165.08) 109.96,164.31 U3.10 U3.1 109.96,162.94 109.69,162.67 109.69,161.79 C33.2 109.18,161.79 v1(109.18,162.16)
  IN1 w0.114: v1(109.18,162.16) 109.18,162.42 108.67,162.92 102.45,162.92 101.33,161.81 v1(101,161.81)
CRTVDD5: length 17.9
  TOP w0.203: v1(110.39,162.4) 110.46,162.47 U3.2 U3.9 110.46,164.82 v1(110.32,164.96)
  TOP w0.508: C36.1 C31.1 110.39,161.83 v1(110.39,162.4) ; R3.2 v1(114.64,159.75) ; CN3.9 109.85,165.43 v1(110.32,164.96)
  BOTTOM w0.508: v1(114.64,159.75) 114.13,159.24 Q36.1 110.57,160.01 C36.1 ; R448.2 109.56,160.88 109.8,160.64 C36.1 ; C36.1 C31.1 110.39,161.83 v1(110.39,162.4)
CRTVSYNC: length 24.9
  TOP w0.127: v1(112.73,162.14) 112.73,161.66 C34.2 112.61,161.54 111.46,162.69 U3.4 U3.7 111.46,164.82 v1(111.59,164.96) 111.59,165.34 110.99,165.94 CN3.14 ; U6.4 v1(101.29,158.34)
  IN1 w0.114: v1(101.29,158.34) 101.69,158.73 102.45,158.73 102.7,158.48 107.53,158.48 108.29,159.24 109.43,159.24 110.96,157.72 112.73,157.72 113.19,158.18 113.19,161.68 v1(112.73,162.14)
CS_BST1: length 2.8
  BOTTOM w0.14: PC93.1 141.06,151.65 v1(141.69,151.65)
  BOTTOM w0.178: PC93.1 140.67,150.48 140.73,150.42 PU7.7
CS_BSTR1: length 1.9
  BOTTOM w0.178: PR134.2 140.04,150.73 140.04,150.61 140.33,150.31 PU7.6
CS_SW1:
  vias: v1(133.28,148.17) v1(133.59,148.75) v1(133.61,147.58) v1(138.08,145.6) v1(138.9,145.6) v2(137.12,146.41) v2(137.12,145.65) v2(137.69,145.07) v2(138.49,145.07) v2(139.33,145.07) v3(134.35,145.42)
D/C#: length 184.2
  TOP w0.14: U32.107 150.24,66.7 149.34,65.8 149.34,64.83 v1(148.88,64.37) ; PR44.2 v1(30.18,89.21)
  IN1 w0.114: v1(141.36,59.62) 140.67,59.62 136.23,55.18 136.23,53.83 135.67,53.27 135.16,53.27 133.96,52.08 131.25,52.08 128.5,49.32 119.92,49.32 118.36,47.77 111.05,47.77 109.02,49.79 97.09,49.79 96.62,50.26 90.14,50.26 89.27,49.39 82.05,49.39 81.69,49.75 77.9,49.75 77.29,49.14 72.1,49.14 70.64,50.61 67.95,50.61 67.38,51.18 65.61,51.18 64.95,51.84 63.77,51.84 63.57,52.04 61.82,52.04 60.71,53.15 55.57,53.15 52.5,50.09 50.16,50.09 49.72,49.65 38.4,49.65 36.66,47.91 31.95,47.91 29.88,49.97 29.88,64.87 30.5,65.49 30.5,66.44 29.99,66.95 29.99,68.35 30.63,68.99 30.63,73.23 31.05,73.64 31.05,75 29.66,76.39 29.66,88.69 v1(30.18,89.21)
  IN2 w0.114: v1(141.36,59.62) 141.36,61.5 142.66,62.8 142.66,64.2 143.39,64.93 143.39,65.34 143.09,65.64 143.09,66.15 143.47,66.53 143.98,66.53 145.2,65.31 145.7,65.31 146.16,64.85 146.16,64.37 146.51,64.02 148.53,64.02 v1(148.88,64.37)
DAC_VDDC: length 10.6
  TOP w0.508: L8.2 C54.2 C53.2 C52.2 104.86,155.94 105.24,156.32 v1(105.62,156.32)
  IN2 w0.508: v1(104.21,156.86) 104.75,156.32 v1(105.62,156.32)
  BOTTOM w0.14: U40.10 105.37,156.07 v1(105.62,156.32)
  BOTTOM w0.203: v1(104.21,156.86) 104.21,156.19 104.17,156.16 U40.7
  BOTTOM w0.508: v1(104.21,156.86) 104.21,157.19 104.49,157.47 C562.2 C551.2
DC_TEST_A3_B3: length 0.7
  BOTTOM w0.089: U45.B3 143.57,129.95 U45.A3
DC_TEST_A61_B61: length 0.7
  BOTTOM w0.076: U45.B61 107.44,129.49 U45.A61
DC_TEST_AY2_AW2: length 0.7
  BOTTOM w0.076: U45.AY2 144.16,107.56 U45.AW2
DC_TEST_AY3_AW3: length 0.7
  BOTTOM w0.076: U45.AY3 143.5,107.5 U45.AW3
DC_TEST_AY61_AW61: length 0.7
  BOTTOM w0.102: U45.AW61 107.42,108.02 U45.AY61
DC_TEST_AY62_AW62: length 0.7
  BOTTOM w0.102: U45.AW62 106.85,107.53 U45.AY62
DC_TEST_B62_B63: length 0.7
  BOTTOM w0.076: U45.B63 106.33,129.35 U45.B62
DC_TEST_C1_C2: length 0.7
  BOTTOM w0.076: U45.C1 144.3,128.94 U45.C2
DDCCLK: length 29.3
  TOP w0.127: CN3.15 113.28,165.88 111.96,164.56 U3.6 U3.5 111.96,162.97 112.07,162.85 113.06,162.85 v1(113.37,162.54) 113.62,162.29 C35.2 R3.1 v1(114.64,162.16)
  IN3 w0.089: v1(114.64,162.16) 113.22,160.74 113.22,156.7 v1(111.18,154.67)
  BOTTOM w0.127: R467.1 110.48,154.52 111.03,154.52 v1(111.18,154.67) 111.41,154.44 113.35,154.44 114.51,153.28 114.51,150.85 113.4,149.74 110.48,149.74 R488.1
DDCDAT: length 26.6
  TOP w0.127: v1(106.89,162.29) 106.88,162.3 U2.4 U2.7 106.88,165.99 CN3.12
  IN3 w0.089: v1(108.54,162.29) 108.54,162.16 110.5,160.21 110.5,154.37 v1(111.21,153.65)
  BOTTOM w0.127: v1(108.54,162.29) 108.42,162.16 R448.1 C544.1 106.89,162.17 v1(106.89,162.29) ; R472.1 110.56,153.88 110.98,153.88 v1(111.21,153.65) 111.36,153.81 113.09,153.81 113.88,153.02 113.88,151.11 113.14,150.38 110.56,150.38 R483.1
DDR3_DRAMRST#: length 112.1
  TOP w0.102: v1(70.82,55.31) 69.76,56.37 U28.T2 ; v1(101.76,53.83) 101.76,53.88 101.76,53.88 U30.T2 ; U31.T2 114.97,55.28 115.63,54.62 v1(115.63,54.47)
  TOP w0.14: v1(110.32,54.47) 110.32,69.54 108.24,71.61 105.5,71.61 104.6,72.51 C362.2 104.6,73.97 v1(104.78,74.16) ; U29.T2 82.96,56.83 81.36,55.22 81.36,54.47 81.66,54.18 v1(81.66,53.08) ; R376.2 115.38,54.22 v1(115.63,54.47) 115.93,54.17 C460.1
  IN1 w0.114: v1(70.82,55.31) 70.82,54.72 71.81,53.73 v1(72.6,53.73) 72.8,53.53 79.88,53.53 80.33,53.08 v1(81.66,53.08) 81.9,53.33 84.69,53.33 85.18,52.84 86.85,52.84 87.84,53.83 v1(87.94,53.83) 88.07,53.96 93.55,53.96 94.45,53.07 101,53.07 v1(101.76,53.83) 102.14,53.45 109.31,53.45 v1(110.32,54.47) 110.47,54.47 111.11,53.83 114.99,53.83 v1(115.63,54.47)
  BOTTOM w0.102: U53.T2 119.77,56.04 117.56,53.83 116.55,53.83 115.91,54.47 v1(115.63,54.47) ; v1(72.6,53.73) 72.6,54.19 74.56,56.14 U50.T2 ; v1(87.94,53.83) 87.94,57.55 U51.T2
  BOTTOM w0.14: v1(104.78,74.16) 105.08,74.46 JDIM1.30 ; U52.T2 108.55,55.74 109.03,55.74 109.55,55.22 109.55,55.11 110.19,54.47 v1(110.32,54.47)
DDR_PG_CTRL: length 7.4
  BOTTOM w0.076: 105.65,108.07 105.65,108.26 105.79,108.41 106.65,108.41 106.66,108.43 107.07,108.43 107.52,108.87 U45.AV61
  BOTTOM w0.14: v3(102.35,105.22) 102.46,105.33 R649.2 103.74,106.16 105.65,108.07
DDR_VTTREF: length 3.1
  TOP w0.208: PU6.5 199.2,56.86 v1(199.86,57.51) 199.93,57.59 PC68.1
DDR_VTTT_PG_CTRL: length 219.7
  TOP w0.14: R280.2 91.78,88 ; 91.78,88 91.78,88.38 92.16,88.76 92.16,92.06 93.7,93.6 U23.4 ; 91.78,88 91.78,87.49 91.65,87.36 Q25.2 91.65,85.44 91.33,85.12 86.21,85.12 84.77,83.68 81.24,83.68 80.48,84.44 v1(79.59,84.44)
  IN3 w0.089: v1(79.59,84.44) 78.09,84.44 68.43,74.79 64.58,74.79 63.52,73.73 63.04,73.73 62.19,72.88 62.19,69.71 61.74,69.26 61.74,64.43 61.46,64.16 61.46,62.52 60.98,62.03 60.98,59 60.77,58.78 60.77,55.95 62.02,54.7 62.02,54.23 62.95,53.3 v1(62.95,52.94) ; v1(196.3,49.39) 195.89,48.98 166.15,48.98 164.31,50.82 159.98,50.82 158.24,52.56 156.42,52.56 155.79,51.93 150.99,51.93 148.93,49.87 144.66,49.87 142.94,48.14 138.31,48.14 136.31,46.14 135.54,46.14 133.91,44.51 132.26,44.51 131.83,44.94 124.42,44.94 123.93,44.45 105.39,44.45 v1(105.24,44.31)
  BOTTOM w0.14: PR212.1 195.4,50.28 v1(196.3,49.39) ; v1(105.24,44.31) 105.24,45.58 103.09,47.73 89.79,47.73 87.28,45.22 68.44,45.22 66.51,47.16 66.51,48.98 64.9,50.59 64.09,50.59 62.95,51.72 v1(62.95,52.94)
DEVSLP0: length 210.8
  TOP w0.14: R289.1 29.18,77.22 29.18,51.45 30.28,50.35 32.63,50.35 33.53,51.25 36.91,51.25 38.06,52.4 38.52,52.4 39.67,51.25 55,51.25 56.46,52.71 v1(58.91,52.71) ; R132.1 150.86,121.76 150.32,121.76 150,122.08 147.79,122.08 146.92,122.95 146,122.95 145.56,122.51 v1(145.55,122.51)
  IN2 w0.076: 142.81,123.07 142.6,122.87 139.99,122.87 139.91,122.79
  IN2 w0.114: 142.81,123.07 142.91,123.17 144.89,123.17 v1(145.55,122.51) ; 139.91,122.79 139.78,122.66 139.78,121.31 138.39,119.93 137.01,119.93 136.55,120.39 133.46,120.39 131.41,118.33 130.74,118.33 130.73,118.32 124.24,118.32 123.04,117.12 113.56,117.12 111.97,115.53 110.28,115.53 109.59,116.22 108.83,116.22 105.53,112.93 98.47,112.93 96.82,111.27 96.82,109.75 92.12,105.05 90.47,105.05 87.26,101.84 84.29,101.84 84.03,101.58 84.03,100.59 82.46,99.02 80.04,99.02 75.7,94.68 72.35,94.68 v1(72.17,94.86)
  IN3 w0.089: v1(72.17,94.86) 72.17,93.68 71.24,92.76 71.24,83.83 70.56,83.14 70.56,81.13 68.03,78.6 63.79,78.6 62.79,77.61 61.45,77.61 60.05,76.21 59.56,76.21 58.14,74.79 58.14,73.37 57.29,72.51 57.29,68.23 57.87,67.64 57.87,66.07 57.96,65.99 57.96,62.98 56.88,61.9 56.88,54.75 v1(58.91,52.71)
  BOTTOM w0.076: U45.P2 144.47,122.4 145.43,122.4 v1(145.55,122.51)
