# Allegro board DA0Z8CMB8D0-D-gina-165.brd (continued)
## Nets (continued)
PCH_SLP_S5#: R735.2 U45.AP5
PCH_SLP_SUS#: Q24.2 U32.71 U45.AP4
PCH_SLP_WLAN#: TP79.1 U45.AM5
PCH_SPI_CLK: C193.1 R112.2 U45.AA3
PCH_SPI_CLK_EC: R102.1 U32.105
PCH_SPI_CS0#: R76.2 R85.2 U14.1 U45.Y7
PCH_SPI_CS1#: TP48.1 U45.Y4
PCH_SPI_IO2: R74.1 U45.Y6
PCH_SPI_IO3: R105.1 U45.AF1
PCH_SPI_SI: R111.2 U45.AA2
PCH_SPI_SI_EC: R100.1 R314.1 U32.102
PCH_SPI_SO: R78.1 U45.AA4
PCH_SPI_SO_EC: R75.1 R720.1 U32.103
PCH_SUSACK#: R620.2 U32.2
PCH_SUSCLK: R689.1 U45.AE6
PCH_SUSPWARN#: R323.1 R616.2 U32.128
PCH_SUSPWRACK: R615.1 R616.1 R650.1 U45.AV4
PCH_VCC_1_1_21: R145.2 U45.AG13
PCH_VDDEN: R217.2 U45.C6
PCH_WIFI_SUSCLK#: CN12.50 R689.2
PCI_PIRQA#: R115.1 U45.U6
PCI_PIRQB#: R570.1 U45.P4
PCI_PIRQC#: R538.1 U45.N4
PCI_PIRQD#: R551.1 U45.N2
PCI_PLTRST#: R335.1 U20.1 U20.2 U27.1 U45.AG7
PCI_PME#: TP61.1 U45.AD4
PCIE_CLKREQ_WIGIG#: Q22.4 R252.2 R572.1
PCIE_CLKREQ_WLAN#: Q21.4 R250.2 R550.1
PCIE_IREF: R509.2 U45.B27
PCIE_LAN_WAKE#: R228.1 R238.1 R258.2 R267.2 R309.1 U45.AJ5
PCIE_RCOMP: R510.1 U45.A27
PCIE_REQ_LAN#: Q26.3 R306.2 R307.1 U24.36
PCIE_RX3+_LAN: C330.2 U45.F11
PCIE_RX3-_LAN: C332.2 U45.G11
PCIE_RX4+_WLAN: CN12.41 U45.G13
PCIE_RX4-_WLAN: CN12.43 U45.F13
PCIE_RXN3_C: C332.1 U24.31
PCIE_RXP3_C: C330.1 U24.30
PCIE_TX3+: C626.1 U45.B30
PCIE_TX3+_LAN: C626.2 U24.25
PCIE_TX3-: C627.1 U45.C29
PCIE_TX3-_LAN: C627.2 U24.26
PCIE_TX4+: C612.1 U45.A29
PCIE_TX4+_WLAN: C612.2 CN12.35
PCIE_TX4-: C613.1 U45.B29
PCIE_TX4-_WLAN: C613.2 CN12.37
PCIE_WAKE#_R: CN12.55 Q21.6 R245.1 R246.1
PCIERST#: R703.2 R706.2 R732.2 U27.4
PCLK_TPM: C290.2 R224.1 U56.21
PD#: D17.2 D18.2 R397.2 U34.47
PDN#: CN12.54 R700.1 R701.1
PEG_RX0: C147.1 U45.E10
PEG_RX1: C144.1 U45.E8
PEG_RX2: C132.1 U45.G10
PEG_RX3: C158.1 U45.F6
PEG_RX#0: C153.1 U45.F10
PEG_RX#1: C138.1 U45.F8
PEG_RX#2: C128.1 U45.H10
PEG_RX#3: C164.1 U45.E6
PEG_RXN0_C: C153.2 U43.AB9
PEG_RXN1_C: C138.2 U43.AC10
PEG_RXN2_C: C128.2 U43.AC11
PEG_RXN3_C: C164.2 U43.AB12
PEG_RXP0_C: C147.2 U43.AC9
PEG_RXP1_C: C144.2 U43.AB10
PEG_RXP2_C: C132.2 U43.AD11
PEG_RXP3_C: C158.2 U43.AC12
PEG_TX0: C632.1 U43.AG6
PEG_TX1: C615.1 U43.AF7
PEG_TX2: C638.1 U43.AE9
PEG_TX3: C617.1 U43.AG9
PEG_TX#0: C633.2 U43.AG7
PEG_TX#1: C614.1 U43.AE7
PEG_TX#2: C637.1 U43.AF9
PEG_TX#3: C616.1 U43.AG10
PEGX_RST#: Q15.2 R124.1 R179.2 R183.1
PEX_CLKREQ#: Q11.1 R147.1 R148.1 U43.AC6
PEX_PLLVDD: C84.1 C134.1 C143.2 R67.2 U43.AA14 U43.AA15
PEX_TERMP: R493.2 U43.AF25
PEX_TSTCLK: R83.2 U43.AF22
PEX_TSTCLK#: R83.1 U43.AE22
PLTRST#: R198.1 R215.1 R694.2 R702.2 R740.2 R785.1 U20.4 U22.2 U32.22
PLTRST#_TPM: R784.1 R785.2 U56.16
PM_EXTTS#1: JDIM1.198 R297.2
PROC_DETECT: TP116.1 U45.D61
PROCHOT_EC: Q29.2 R367.2 U32.17
PS_FB_CLAMP: R603.1 U43.F3
PWR_DEBUG: R127.1 TP35.1
PWR_DEBUG_R: R109.2 R127.2 U45.H59
PWRLED#: R31.1 R44.1 U32.24
R_PEG_TX0: C632.2 U45.C22
R_PEG_TX1: C615.2 U45.A23
R_PEG_TX2: C638.2 U45.C21
R_PEG_TX3: C617.2 U45.A21
R_PEG_TX#0: C633.1 U45.C23
R_PEG_TX#1: C614.2 U45.B23
R_PEG_TX#2: C637.2 U45.B21
R_PEG_TX#3: C616.2 U45.B22
R_SPK2: TP102.1 U34.23
R_SPK+: R431.1 U34.45
R_SPK+_1: C518.1 CN22.1 R431.2
R_SPK-: R430.1 U34.44
R_SPK-_1: C517.1 CN22.2 R430.2
RAM_ID0: R646.2 R647.1 U45.AT3
RAM_ID1: R214.2 R227.1 U45.AM3
RAM_ID2: R637.2 R638.1 U45.AM2
RAM_ID3: R641.2 R642.1 U45.AH4
REGOUT: L17.1 U24.48
RF_EN: CN12.56 U32.66
RJ45-TX0+: CN1.1 L5.3 U9.4 U9.5
RJ45-TX0-: CN1.2 L5.2 U9.3 U9.6
RJ45-TX1+: CN1.3 L7.3 U9.2 U9.7
RJ45-TX1-: CN1.6 L7.2 U9.1 U9.8
RJ45-TX2+: CN1.4 L23.2 U37.4 U37.5
RJ45-TX2-: CN1.5 L23.3 U37.3 U37.6
RJ45-TX3+: CN1.7 L26.2 U37.2 U37.7
RJ45-TX3-: CN1.8 L26.3 U37.1 U37.8
ROM_CS: R171.1 U43.D12
ROM_SCLK: R583.2 R589.1 U43.C12
ROM_SI: R584.1 R590.1 U43.B12
ROM_SO: R585.1 R591.2 U43.A12
RSMRST#: R678.1 R679.2 U32.112
RTC_RST#: C711.1 J2.1 R726.2 R730.2 U45.AU7
RTC_X1: C664.2 R655.1 U45.AW5 Y5.1
RTC_X2: C665.2 R655.2 U45.AY5 Y5.2
RX_DVDD18: C561.2 C568.2 C570.2 C585.1 C588.1 L28.2 U40.12 U40.14 U40.24 U40.44 U40.46
S5_ON: PQ26.2 PQ35.2 PQ37.2 PR175.1 R315.1 U32.100
S5D: PC84.2 PQ29.3 PQ45.2 PQ53.4 PR121.2 PR122.2
SATA_IREF: R512.1 U45.A12
SATA_LED#: R575.2 U45.U3
SATA_RCOMP: R513.2 U45.C12
SATA_RXN0: C685.2 U45.J5
SATA_RXN0_C: C685.1 CN11.5
SATA_RXP0: C684.2 U45.H5
SATA_RXP0_C: C684.1 CN11.6
SATA_TXN0: C686.2 U45.B15
SATA_TXN0_C: C686.1 CN11.3
SATA_TXP0: C687.2 U45.A15
SATA_TXP0_C: C687.1 CN11.2
SB_ACDC: PR54.1 U32.21
SCL/LED_CR_NC: TP93.1 U24.42
SD_CD#: CN19.11 R748.2
SD_CLK: C777.1 CN19.5 R779.2
SD_CMD: CN19.2 R762.2
SD_DAT0: C779.1 CN19.7 R783.2
SD_DAT1: CN19.8 R786.2
SD_DAT2: CN19.9 R753.2
SD_DAT3: CN19.1 R758.2
SD_WP: CN19.10 R788.2
SDA/SPIDI: R295.1 TP94.1 U24.44
SENSEA: R410.1 U34.13
SIO_EXT_SCI#: R528.1 U32.23 U45.G2
SIO_EXT_SMI#: R160.1 U32.15 U45.K4
SIO_RCIN#: R139.1 U32.4 U45.V4
SKU_ID0: R587.2 R588.1 U45.Y1
SKU_ID1: R101.1 R104.2 U45.N5
SM_INTRUDER#: R665.2 U45.AU6
SM_RCOMP_0: R639.2 U45.AU60
SM_RCOMP_1: R645.1 U45.AV60
SM_RCOMP_2: R640.2 U45.AU61
SMB0ALERT#: R636.2 U45.AL2
SMB1ALERT#: R651.2 U45.AU4
SMB_ME0_CLK: R622.2 U45.AN1
SMB_ME0_DAT: R619.2 U45.AK1
SMB_ME1_CLK: Q19.4 R242.2 R260.2 U45.AU3
SMB_ME1_DAT: Q19.1 R240.2 R243.2 U45.AH3
SMB_PCH_CLK: Q20.6 R255.2 U45.AP2
SMB_PCH_DAT: Q20.3 R244.2 U45.AH1
SMBALERT#: R643.1 U45.AN2
SP5: R786.1 U24.18
SP6: R783.1 U24.19
SP7: R779.1 U24.20
SP8: R762.1 U24.21
SP9: R758.1 U24.22
SP10: R753.1 U24.23
SP12: R788.1 U24.35
SP13: R748.1 U24.54
SP_PLLVDD: C166.2 C218.2 C230.2 C237.2 L14.2 U43.M6 U43.N6
SPD_A0: R763.2 R764.1 U55.1
SPD_A1: R768.2 R771.1 U55.2
SPD_A2: R773.2 R777.1 U55.3
SPD_CLK_SCLK: R772.2 U55.6
SPD_CLK_SDATA: R776.2 U55.5
SPI_CLK_8M: R102.2 R112.1 U14.6
SPI_CS0#_UR_ME: R80.2 R85.1 U32.101
SPI_HOLD_IO3_ME: R105.2 R106.1 U14.7
SPI_SI_8M: R100.2 R111.1 U14.5
SPI_SO_8M: R75.2 R78.2 U14.2
SPI_WP_IO2_ME: R74.2 R77.2 U14.3
SPKR: D19.2 R580.2 U45.V2
SRTC_RST#: C710.1 R722.2 U45.AV6
STRAP0: R607.1 R627.2 U43.D1
STRAP1: R606.1 R626.1 U43.D2
STRAP2: R618.2 R623.2 U43.E4
STRAP3: R605.1 R625.1 U43.E3
STRAP4: R608.1 R628.1 U43.D3
SUSACK#_R: R615.2 R620.1 U45.AK2
SUSB#: R736.2 U32.82 U45.AT4
SUSC#: R734.2 U32.83 U45.AJ6
SUSLED#: R32.1 R45.1 U32.28
SUSON: PR111.1 R312.1 U32.123
SYS_COM_REQ: R137.1 TP39.1 U45.U1
SYS_HWPG: D37.1 PR199.2
SYS_PEX_RST_MON#: R170.1 TP22.1 U43.E9
SYS_PWROK: R261.1 R601.1 R673.1 R683.1 R687.1 U47.4
SYS_PWROK_R: C660.2 R601.2 R666.1 U45.AG2
SYS_RESET#: R195.2 R581.1 R728.2 U45.AC3
SYS_SHDN#: C769.1 D35.1 PQ34.3 PR191.2 PR197.2 PU5.6 Q9.3 SW2.3
SYSTEM_AGND: PR82.1 PR187.2 PR190.2 PR195.1 PR198.1
TD_IREF: R511.2 U45.B12
TEMP_MBAT: PR98.2 PR101.1 U32.73
TERM0: C528.1 D1.2 R6.2 R7.2 R449.2 R455.2
TESTLOW_AK8: R225.2 U45.AK8
TESTLOW_AL8: R233.2 U45.AL8
TESTLOW_C34: R505.2 U45.C34
TESTLOW_C35: R504.2 U45.C35
TESTMODE: R116.1 U43.AD9
THERM+: TP10.1 U43.F12
THERM-: TP11.1 U43.E12
THRMTRIP#: Q9.1 R96.1 U45.D60
TP_DC_TEST_A4: TP110.1 U45.A4
TP_DC_TEST_A60: TP112.1 U45.A60
TP_DC_TEST_A62: TP115.1 U45.A62
TP_DC_TEST_AV1: TP144.1 U45.AV1
TP_DC_TEST_AW1: TP145.1 U45.AW1
TP_DC_TEST_AW63: TP147.1 U45.AW63
TP_DC_TEST_AY60: TP146.1 U45.AY60
TP_DC_TEST_B2: TP111.1 U45.B2
TP_GND: CN7.3 CN7.6 R194.2
TP_INT: CN7.2 Q17.1 R187.1 R188.2
TP_INT_PCH: Q17.3 R156.1 R188.1 U45.R6
TP_PWR: C274.1 C277.2 CN7.31 R230.2
TPCLK: R385.1 R386.2 U32.89
TPCLK_R: C475.2 CN18.3 R385.2
TPD_INT#: Q30.3 U32.68
TPD_INT#_D: Q30.1 R130.1 U45.U7
TPDATA: R384.1 R387.2 U32.90
TPDATA_R: C474.2 CN18.4 R384.2
TX0N_R: R2.1 U4.2
TX0P_R: R1.1 U4.1
TX1N_R: R29.1 U7.4
TX1P_R: R27.1 U7.3
TX2N_R: R438.1 U35.3
TX2P_R: R434.1 U35.4
TX3N_R: R464.1 U36.1
TX3P_R: R460.1 U36.2
ULT_RVSD_61: TP24.1 U45.L59
ULT_RVSD_62: TP15.1 U45.J58
ULT_RVSD_63: TP31.1 U45.N58
ULT_RVSD_64: TP56.1 U45.AC58
ULT_RVSD_65: TP58.1 U45.AB23
ULT_RVSD_66: TP59.1 U45.AD23
ULT_RVSD_67: TP66.1 U45.AA23
ULT_RVSD_68: TP73.1 U45.AE59
ULT_RVSD_69: TP29.1 U45.P60
ULT_RVSD_70: TP27.1 U45.P61
ULT_RVSD_71: TP25.1 U45.N59
ULT_RVSD_72: TP125.1 U45.N61
ULT_RVSD_73: TP37.1 U45.T59
ULT_RVSD_74: TP72.1 U45.AD60
ULT_RVSD_75: TP75.1 U45.AD59
ULT_RVSD_76: TP49.1 U45.AA59
ULT_RVSD_77: TP54.1 U45.AE60
ULT_RVSD_78: TP57.1 U45.AC59
ULT_RVSD_79: TP71.1 U45.AG58
ULT_RVSD_80: TP34.1 U45.U59
ULT_RVSD_81: TP50.1 U45.V59
URDBG: TP105.1 U40.28
USB3_RXN0: R296.2 U45.G20
USB3_RXN0_R: CN13.5 D10.1 R296.1
USB3_RXN1: R249.2 U45.E18
USB3_RXN1_R: CN8.5 D6.1 R249.1
USB3_RXP0: R302.2 U45.H20
USB3_RXP0_R: CN13.6 D11.1 R302.1
USB3_RXP1: R256.2 U45.F18
USB3_RXP1_R: CN8.6 D7.1 R256.1
USB3_TXN0: C370.1 U45.C33
USB3_TXN0_C: C370.2 R311.2
USB3_TXN0_R: CN13.8 D12.1 R311.1
USB3_TXN1: C305.1 U45.B33
USB3_TXN1_C: C305.2 R276.2
USB3_TXN1_R: CN8.8 D8.1 R276.1
USB3_TXP0: C377.1 U45.B34
USB3_TXP0_C: C377.2 R321.2
USB3_TXP0_R: CN13.9 D13.1 R321.1
USB3_TXP1: C308.1 U45.A33
USB3_TXP1_C: C308.2 R281.2
USB3_TXP1_R: CN8.9 D9.1 R281.1
USB_BC_EN: R329.2 R792.1 U26.4 U49.4
USB_BC_ON: R329.1 U26.1 U32.97
USB_CHARGE_ON: R326.2 U32.96
USB_OC0#: RP2.9 U45.AL3 U48.3 U49.3
USB_OC1#: RP2.8 U18.3 U19.3 U45.AT1
USB_OC2#: RP2.7 U45.AH2
USB_OC3#: RP2.6 U45.AV3
USBCOMP: R207.1 U45.AJ10 U45.AJ11
USBON#: U18.4 U19.4 U32.79 U48.4
USBP0+: U25.6 U45.AM8
USBP0+_C: R711.2 U25.3
USBP0+_R: CN13.3 D31.1 R711.1
USBP0-: U25.7 U45.AN8
USBP0-_C: R712.2 U25.2
USBP0-_R: CN13.2 D32.1 R712.1
USBP1+: R690.2 U45.AT7
USBP1+_R: CN8.3 D29.1 R690.1
USBP1-: R692.2 U45.AR7
USBP1-_R: CN8.2 D30.1 R692.1
USBP2+: R621.1 U45.AP8
USBP2+_R: CN6.8 R621.2
USBP2-: R617.1 U45.AR8
USBP2-_R: CN6.7 R617.2
USBP3+: R72.2 U45.AT10
USBP3+_R: CN5.3 D3.1 R72.1
USBP3-: R73.2 U45.AR10
USBP3-_R: CN5.2 D4.1 R73.1
USBP4+: CN12.3 U45.AL15
USBP4-: CN12.5 U45.AM15
USBP5+: R675.1 U45.AN13
USBP5+_R: CN7.5 R675.2
USBP5-: R667.1 U45.AM13
USBP5-_R: CN7.4 R667.2
USBP6+: R685.1 U45.AN11
USBP6+_R: CN7.8 R685.2
USBP6-: R682.1 U45.AP11
USBP6-_R: CN7.7 R682.2
USBP7+: CN17.4 U45.AP13
USBP7-: CN17.5 U45.AR13
USBPWR1: C706.1 C707.1 CN13.1 U49.1
USBPWR2: C127.1 C163.1 CN5.1 U19.1
USBPWR3: C691.1 C692.1 CN8.1 U48.1
USBPWR4: C256.2 CN6.1 CN6.2 CN6.3 CN6.4 U18.1
VA1: PC21.2 PC22.2 PC24.2 PC31.1 PD1.2 PD9.1 PJ1.1 PJ1.2 PQ9.1 PQ9.2 PQ9.3 PQ11.1 PR43.1
VA2: PD2.1 PD2.2 PQ9.5
VDD33/18: C325.2 C333.2 C334.2 R285.2 U24.33
VGA_COMP: C562.1 U40.6
VGA_OVT#: Q15.1 R185.1 U43.A6
VGA_RST: R459.2 U40.5
VGA_RST#: C190.1 R124.2 U43.AC7
VGPU_EN: PR170.2 R557.1 R560.2 U45.V1
VGPU_PSI: PR174.2 R629.1 U43.B4
VGPU_PWMVID: PR74.2 U43.E7
VGPU_PWRGD: PR57.2 R218.2 U21.1
VL: PC65.2 PR158.1 PR159.1 PU5.13
VMA_CLK0: R87.1 U13.J7 U16.J7 U41.J7 U43.D24 U44.J7
VMA_CLK0#: R87.2 U13.K7 U16.K7 U41.K7 U43.D25 U44.K7
VMA_CLK1: R68.1 U11.J7 U12.J7 U38.J7 U39.J7 U43.N22
VMA_CLK1#: R68.2 U11.K7 U12.K7 U38.K7 U39.K7 U43.M22
VMA_DM0: U13.E7 U41.E7 U43.D19
VMA_DM1: U16.E7 U43.D14 U44.E7
VMA_DM2: U16.D3 U43.C17 U44.D3
VMA_DM3: U13.D3 U41.D3 U43.C22
VMA_DM4: U12.E7 U39.E7 U43.P24
VMA_DM5: U11.E7 U38.E7 U43.W24
VMA_DM6: U11.D3 U38.D3 U43.AA25
VMA_DM7: U12.D3 U39.D3 U43.U25
VMA_DQ0: U13.F2 U41.F8 U43.E18
VMA_DQ1: U13.E3 U41.F7 U43.F18
VMA_DQ2: U13.H3 U41.H7 U43.E16
VMA_DQ3: U13.G2 U41.H8 U43.F17
VMA_DQ4: U13.H7 U41.H3 U43.D20
VMA_DQ5: U13.F7 U41.E3 U43.D21
VMA_DQ6: U13.H8 U41.G2 U43.F20
VMA_DQ7: U13.F8 U41.F2 U43.E21
VMA_DQ8: U16.F8 U43.E15 U44.F2
VMA_DQ9: U16.H8 U43.D15 U44.G2
VMA_DQ10: U16.H7 U43.F15 U44.H3
VMA_DQ11: U16.F7 U43.F13 U44.E3
VMA_DQ12: U16.H3 U43.C13 U44.H7
VMA_DQ13: U16.E3 U43.B13 U44.F7
VMA_DQ14: U16.G2 U43.E13 U44.H8
VMA_DQ15: U16.F2 U43.D13 U44.F8
VMA_DQ16: U16.C2 U43.B15 U44.C8
VMA_DQ17: U16.C3 U43.C16 U44.D7
VMA_DQ18: U16.A2 U43.A13 U44.B8
VMA_DQ19: U16.A3 U43.A15 U44.A7
VMA_DQ20: U16.A7 U43.B18 U44.A3
VMA_DQ21: U16.B8 U43.A18 U44.A2
VMA_DQ22: U16.D7 U43.A19 U44.C3
VMA_DQ23: U16.C8 U43.C19 U44.C2
VMA_DQ24: U13.C8 U41.C2 U43.B24
VMA_DQ25: U13.D7 U41.C3 U43.C23
VMA_DQ26: U13.A7 U41.A3 U43.A25
VMA_DQ27: U13.B8 U41.A2 U43.A24
VMA_DQ28: U13.A2 U41.B8 U43.A21
VMA_DQ29: U13.A3 U41.A7 U43.B21
VMA_DQ30: U13.C2 U41.C8 U43.C20
VMA_DQ31: U13.C3 U41.D7 U43.C21
VMA_DQ32: U12.H7 U39.H3 U43.R22
VMA_DQ33: U12.H8 U39.G2 U43.R24
VMA_DQ34: U12.F7 U39.E3 U43.T22
VMA_DQ35: U12.F8 U39.F2 U43.R23
VMA_DQ36: U12.G2 U39.H8 U43.N25
VMA_DQ37: U12.H3 U39.H7 U43.N26
VMA_DQ38: U12.E3 U39.F7 U43.N23
VMA_DQ39: U12.F2 U39.F8 U43.N24
VMA_DQ40: U11.F2 U38.F8 U43.V23
VMA_DQ41: U11.H3 U38.H7 U43.V22
VMA_DQ42: U11.G2 U38.H8 U43.T23
VMA_DQ43: U11.E3 U38.F7 U43.U22
VMA_DQ44: U11.F7 U38.E3 U43.Y24
VMA_DQ45: U11.F8 U38.F2 U43.AA24
VMA_DQ46: U11.H8 U38.G2 U43.Y22
VMA_DQ47: U11.H7 U38.H3 U43.AA23
VMA_DQ48: U11.B8 U38.A2 U43.AD27
VMA_DQ49: U11.A7 U38.A3 U43.AB25
VMA_DQ50: U11.D7 U38.C3 U43.AD26
VMA_DQ51: U11.C8 U38.C2 U43.AC25
VMA_DQ52: U11.C3 U38.D7 U43.AA27
VMA_DQ53: U11.A3 U38.A7 U43.AA26
VMA_DQ54: U11.A2 U38.B8 U43.W26
VMA_DQ55: U11.C2 U38.C8 U43.Y25
VMA_DQ56: U12.A2 U39.B8 U43.R26
VMA_DQ57: U12.A3 U39.A7 U43.T25
VMA_DQ58: U12.C2 U39.C8 U43.N27
VMA_DQ59: U12.C3 U39.D7 U43.R27
VMA_DQ60: U12.B8 U39.A2 U43.V26
VMA_DQ61: U12.A7 U39.A3 U43.V27
VMA_DQ62: U12.D7 U39.C3 U43.W27
VMA_DQ63: U12.C8 U39.C2 U43.W25
VMA_RDQS0: U13.G3 U41.G3 U43.F19
VMA_RDQS1: U16.G3 U43.C14 U44.G3
VMA_RDQS2: U16.B7 U43.A16 U44.B7
VMA_RDQS3: U13.B7 U41.B7 U43.A22
VMA_RDQS4: U12.G3 U39.G3 U43.P25
VMA_RDQS5: U11.G3 U38.G3 U43.W22
VMA_RDQS6: U11.B7 U38.B7 U43.AB27
VMA_RDQS7: U12.B7 U39.B7 U43.T27
VMA_WDQS0: U13.F3 U41.F3 U43.E19
VMA_WDQS1: U16.F3 U43.C15 U44.F3
VMA_WDQS2: U16.C7 U43.B16 U44.C7
VMA_WDQS3: U13.C7 U41.C7 U43.B22
VMA_WDQS4: U12.F3 U39.F3 U43.R25
VMA_WDQS5: U11.F3 U38.F3 U43.W23
VMA_WDQS6: U11.C7 U38.C7 U43.AB26
VMA_WDQS7: U12.C7 U39.C7 U43.T26
VR_SVID_ALERT#: PR2.2 PU1.32 R565.2 R568.2 R578.2
VR_SVID_CLK: PR3.2 PU1.31 R579.2
VR_SVID_DATA: PR6.2 PU1.1 R558.2
VREFC_VMA1: C649.2 R563.1 R564.2 U13.M8 U16.M8 U41.M8 U44.M8
VREFC_VMA3: C48.2 R28.1 R30.2 U11.M8 U12.M8 U38.M8 U39.M8
VREFD_VMA1: C200.2 R122.1 R123.2 U13.H1 U16.H1 U41.H1 U44.H1
VREFD_VMA3: C569.2 R461.1 R465.2 U11.H1 U12.H1 U38.H1 U39.H1
VRON: PR9.1 R491.1 U32.69
VRON_CPU: PR11.1 R507.2 U45.F60
VSYNC: U6.2 U40.3
WIGIG_RST#: R707.2 U32.126
WIGIG_RX1+_WLAN: CN12.65 U45.G15
WIGIG_RX1-_WLAN: CN12.67 U45.F15
WIGIG_TX1+_WLAN: C624.2 CN12.59
WIGIG_TX1-_WLAN: C625.2 CN12.61
WIGIG_TX3+: C624.1 U45.A31
WIGIG_TX3-: C625.1 U45.B31
WK_GPIO27: R686.1 R688.1 U45.AN5
WLAN_CLK_SCLK: CN12.60 TP148.1
WLAN_CLK_SDATA: CN12.58 TP149.1
WLAN_LED1#: CN12.6 TP152.1
WLAN_RST: CN12.52 R702.1 R703.1 R704.1
WLAN_WAKE#: R259.2 R266.2 R316.2
WRST#: C416.1 D16.2 R353.1 U32.14
X-TX0N: L5.1 U4.5
X-TX0P: L5.4 U4.6
X-TX1N: L7.1 U7.7
X-TX1P: L7.4 U7.8
X-TX2N: L23.4 U35.8
X-TX2P: L23.1 U35.7
X-TX3N: L26.4 U36.6
X-TX3P: L26.1 U36.5
XDP_BPM#0: TP19.1 U45.J60
XDP_BPM#1: TP17.1 U45.H60
XDP_BPM#2: TP118.1 U45.H61
XDP_BPM#3: TP119.1 U45.H62
XDP_BPM#4: TP21.1 U45.K59
XDP_BPM#5: TP117.1 U45.H63
XDP_BPM#6: TP23.1 U45.K60
XDP_BPM#7: TP16.1 U45.J61
XDP_DBRESET_N: R195.1 R196.1 TP84.1
XDP_PRDY#: TP20.1 U45.J62
XDP_PREQ#: TP30.1 U45.K62
XDP_RST_R_N: R215.2 TP85.1
XDP_TCK0: R152.2 R597.1 TP62.1 U45.E60
XDP_TCK1: R602.2 TP139.1 U45.AE62
XDP_TDI: R151.2 TP64.1 U17.5 U45.AD61
XDP_TDI_CPU: U17.6 U45.F63
XDP_TDO: R162.1 R166.1 TP65.1 U17.2
XDP_TDO_CPU: R103.2 U17.3 U45.F62
XDP_TMS: R150.2 TP68.1 U17.9 U45.AD62
XDP_TMS_CPU: U17.8 U45.E61
XDP_TRST#: R644.2 U17.11 U45.AU62 U45.E59
XDP_TRST_N: TP121.1 U17.12
XTAL24_IN: C630.1 R501.1 U45.A25 Y3.3
XTAL24_OUT: C631.1 R501.2 U45.B25 Y3.1
XTAL_SSIN: R634.1 U43.A10
N03288: PC31.2 PQ9.4 PQ11.6 PR43.2 PR45.1
N05582: PQ22.4 PR95.2 PR100.1
N05646: PQ11.2 PQ11.3
N05670: PQ11.5 PQ20.2 PR44.1
N05802: PL7.1 PR207.1 PR208.2
N06510: PC63.1 PR93.2
N90670: PC59.1 PJ2.3 PR87.1
N243495: PD2.3 PR69.1 PR188.2
N1295644: PC27.1 PR41.2
N1295718: PC30.1 PR42.2
N1295854: PC36.2 PR50.2
N1295864: PC40.2 PR56.2
N1295902: PC49.2 PR75.1
N1296006: PC46.1 PR78.1 PR183.1 PR185.2
N1354566: PR180.1 PR181.2
N1354570: PC45.1 PR76.1 PR77.2 PR182.1 PR184.2
N6957176: PQ19.3 PR79.2
N6957188: PQ27.3 PR120.2
N6993431: PQ1.3 PQ2.2 PQ3.2 PR25.1 PR26.2
N7038240: PC17.1 PR30.1
N7038508: PC14.1 PR29.2
N7165711: PC1.2 PR1.2
N7169591: PC56.2 PR91.2
N7169727: PC51.1 PR83.2
N7169889: PR85.2 PR199.1 PU5.7
N7170033: PC61.1 PD7.3
N7170041: PC60.2 PC61.2 PR86.2
N7170053: PC71.2 PD6.1 PD7.2
N7170185: PC60.1 PD6.3
N7170201: PC76.1 PR106.2
N7170291: PC57.1 PR92.1
N7226956: PQ15.3 PR184.1
N7226960: PQ15.2 PR64.1
N7318719: PQ14.3 PQ42.2 PQ43.2 PR51.1 PR52.2
N7318835: PC39.2 PQ14.2 PR60.2 PR67.1
N7318863: PQ43.3 PR162.2
N7320221: PQ28.3 PR123.2
N16379436: C44.1 CN2.13
N16382763: C43.1 CN2.14
N16778199: PC66.1 PR105.2
N16780395: PC74.1 PR108.2
N16789555: PR216.2 PU10.13
N16789557: PC150.2 PL10.1 PU10.10 PU10.11 PU10.12
N16789582: PC142.2 PR116.1 PU10.7
N16789596: PC150.1 PR216.1
N16789602: PC143.1 PU10.9
N16789606: PR215.1 PU10.8
N16789612: PC81.1 PR116.2
N16789664: PC85.2 PR218.1 PU10.15
N16824426: R199.2 R201.2 U21.2
N16824795: PC62.1 PJ2.4 PR96.1
N16824800: PJ2.5 PR98.1
N16857822: PQ20.3 PR100.2
N16870904: PQ21.3 PR102.1
N16876480: PC42.1 PR71.1
N16876574: PC37.1 PR53.2
N16928869: PQ13.2 PQ13.5 PR55.1 PU9.5
N16928948: PQ13.6 PR58.2 PR59.1
N16929910: PQ33.3 PR160.2
N16930588: PC20.2 PQ7.2 PR36.1 PR37.2
N16965635: PC13.2 PQ1.2 PR27.1 PR28.2
N16965655: PQ2.3 PR23.2
N16965660: PQ6.2 PQ7.3 PQ8.2 PR38.1 PR39.2
N16965669: PQ8.3 PR40.2
N16991480: PC125.2 PD5.1 PR201.1
N17028529: PD1.1 PR48.2 PR189.1
N17036761: PR48.1 PR73.1
N17045614: PR200.2 PU9.8
N17046311: PR202.2 PU9.9
N17177387: PR206.2 PU9.13
N17177693: PR205.2 PU9.12
N19138106: R174.2 U43.F22
N19138109: R173.2 U43.J22
N21262847: R604.2 U43.F6
N21263014: TP13.1 U43.E10
N21263017: TP18.1 U43.F10
N21996152: R183.2 U22.4
N47973729: PC102.2 PR152.1 PR156.2 PU8.8
N47973733: PD8.1 PQ36.1 PR161.1
N47973739: PQ36.3 PR156.1
N47973743: PQ36.2 PQ37.3 PR161.2
N47973784: PC103.2 PQ34.2 PR152.2 PU8.1
N47973813: PQ35.3 PR157.1
N57484549: PR130.2 PU1.3
N58590962: PC93.2 PR134.1
N58590994: PL1.4 PR13.1
N58590998: PL1.3 PR12.1
N58591014: PR150.2 PR151.2
N58591351: PC8.1 PR10.2
N99212489: TP80.1 U45.AP32
N100073348: Q21.1 R246.2 R258.1 R259.1
N100359802: R318.1 U25.4
N100359806: R326.1 R328.1 U25.8
N100631500: R649.1 U23.2
N100631544: Q25.1 R709.1 R710.1
N101127130: C307.2 Q23.2 R277.1 R278.1
N101127328: Q24.3 R278.2
N101265975: Q9.2 R95.2
N101265981: Q8.1 R95.1
N101538019: R90.2 U15.4 U17.1 U17.4 U17.10 U17.13
N101575958: CN14.2 R736.1
N101575960: CN14.4 R735.1
N101575962: CN14.6 R733.1
N101575964: CN14.9 R730.1
N101575966: CN14.11 R729.1
N101575968: CN14.13 R728.1
N101575970: CN14.15 R727.1
N101575974: CN14.5 R734.1
N101626067: Q40.2 R705.2
N101626411: Q35.2 R446.2
N101844959: R216.1 R217.1 U46.3
N102027952: C304.2 R268.2 R279.1
N102027954: C304.1 R272.2
N102030206: C419.1 R357.2
N102030208: C419.2 R358.1 R363.1
N102031602: C368.1 R304.2
N102031606: C368.2 R305.2 R322.1
N102339557: R766.2 R770.2 U55.7
N102398732: R724.1 R732.1 R740.1 U24.37
N102398784: R253.2 U24.12
N102398859: Q28.3 R319.2 R320.2 R324.2
N102401187: C490.2 U34.35
N102401192: C496.1 U34.34
N102401200: C490.1 U34.37
N102401219: C504.1 U34.27
N102401227: C500.1 C501.1 C505.1 U34.28
N102401293: C497.1 U34.7
N102401296: R411.1 U34.15
N102401352: C486.1 U34.39
N102411350: Q1.3 R19.2 R20.2 R21.2 R22.2 R23.2 R24.2 R25.2 R26.2
N102411428: D28.1 R474.2
N102411440: D2.1 R50.2
N102412865: R386.1 R387.1 R388.2 R389.2
N102412910: Q31.3 Q32.2 R394.2
N102456718: CN11.9 R289.2
N102475350: Q27.3 R294.2 R308.2 R309.2
N102714628: LED1.3 R31.2
N102714638: LED1.4 R32.2
N102714670: LED2.3 R432.2
N102714672: LED2.4 R433.2
N102802469: C409.2 R348.1
N102803185: R317.2 U32.98
N102803215: R316.1 U32.99
N102803358: C410.1 U32.12
N103095748: C8.2 U4.7 U4.8 U7.5 U7.6 U35.5 U35.6 U36.7 U36.8
N103354651: C405.2 Q28.2 R330.1 R338.2
N103544523: R390.2 R391.2 U33.5
N103592822: TP76.1 U45.AG4
N103592936: R653.1 R656.2 R661.1 R673.2
N104221226: CN7.28 R670.1
N104265063: R292.1 U24.39
N104772550: C492.1 Q33.3 Q34.2 R399.1
N104772583: C493.1 Q33.2 R401.1
N105679711: R403.1 U34.31
N105679807: R406.1 U34.30
N107600611: C564.2 C565.2 C567.1 L25.2 U40.13 U40.48
N107600701: C589.1 L29.2 U40.35 U40.36
N107600890: R488.2 U40.23
N107600892: R483.2 U40.21
N107600911: TP104.1 U40.41
N107600921: TP103.1 U40.47
N107600925: R489.2 U40.37
N107600984: R475.2 U40.43
N107600986: R481.2 U40.42
N107673215: CN12.8 TP151.1
N107719715: R759.2 U54.7
N107748212: R775.1 U56.6
N107748371: C770.1 C775.2 R765.2 R767.2 U56.5
N107748376: R781.2 R784.2 U56.9
N107748380: R778.2 R780.1 U56.7
N107748411: R769.2 U56.27
N107748554: R787.1 U56.15
N107786893: TP154.1 U56.28
N107797019: TP109.1 U45.C49
N107797035: TP108.1 U45.B50
N107797045: TP114.1 U45.A53
N107797061: TP113.1 U45.B53
N108089770: U45.C17 U45.D17
N108089885: TP4.1 U45.C15
N108089886: TP14.1 U45.J6
N108089887: TP9.1 U45.H6
N108089888: TP6.1 U45.B14
N108090887: Q22.1 R248.2 R266.1 R267.1
N108498600: PR17.1 PR20.1 PR22.2
N108831390: Q14.3 R177.2 R181.2 R184.1 R189.1
N108831783: Q13.3 R163.1 R167.1 R178.2 R180.1
N108845535: C70.1 Q5.2 Q6.3 R64.1
N108845564: C85.1 Q6.2 R71.1
N109256954: TP157.1 U45.G17
N109256956: TP158.1 U45.C30
N109256958: TP160.1 U45.C31
N109256960: TP159.1 U45.F17
N109501275: Q42.2 R794.2 R796.1
N111445857: PQ16.2 PQ24.2 PQ26.3 PQ29.2 PR124.2 PR125.1
N111445887: PQ16.3 PR84.2
N111445895: PQ24.3 PR117.2
N996593011: SW1.1 TP99.1
N996593012: SW1.4 TP100.1
N1024208981: SW2.1 TP155.1
N1024208982: SW2.4 TP156.1
N1077195233: TP153.1 U54.9
N10284479361: TP98.1 U32.35
N102844793109: TP97.1 U32.19

Pads without a net: CN3 4; CN7 30 37 38; CN11 8; CN12 9 10 11 12 13 14 15 17 19 20 21 22 23 32 34 36 38 40 42 44 46 48 62; CN14 16 17 18 19 20; CN16 3; CN17 2; JDIM1 77 122 125; NOREF 1; NOREF#4 1; NOREF#6 1; NOREF#10 1; NOREF#11 1; NOREF#12 1; PL3 3 4; PL4 3 4; PU1 21 22; PU8 7; RP2 1 2 3 4; U10 1; U11 J1 J9 L1 L9 M7; U12 J1 J9 L1 L9 M7; U13 J1 J9 L1 L9 M7; U15 1; U16 J1 J9 L1 L9 M7; U23 1; U24 14 15 16 17 34 55 56 57; U28 J1 J9 L1 L9; U29 J1 J9 L1 L9; U30 J1 J9 L1 L9; U31 J1 J9 L1 L9; U34 14 16 19 20 21 22; U38 J1 J9 L1 L9 M7; U39 J1 J9 L1 L9 M7; U41 J1 J9 L1 L9 M7; U42 1; U43 AA1 AA2 AA3 AA4 AA5 AA6 AB1 AB2 AB3 AB4 AB5 AB6 AB13 AB15 AB16 AB18 AB19 AB21 AC3 AC4 AC13 AC14 AC15 AC16 AC17 AC18 AC19 AC20 AC21 AD1 AD2 AD3 AD4 AD5 AD7 AD10 AD14 AD17 AD20 AD23 AE1 AE3 AE4 AE10 AE12 AE13 AE15 AE16 AE18 AE19 AE21 AE23 AE24 AF2 AF3 AF4 AF10 AF12 AF13 AF15 AF16 AF18 AF19 AF21 AF24 AG3 AG12 AG13 AG15 AG16 AG18 AG19 AG21 AG22 AG24 AG25 B2 B3 B6 B19 C1 C2 C3 C5 C7 C18 D4 D6 D10 D11 D16 D17 D18 E6 F4 F5 F7 F9 G1 G2 G3 G4 G5 G6 G7 H3 H4 J1 J2 J3 J4 J5 J26 K1 K2 K3 K4 K5 K6 L3 L4 M1 M2 M3 M4 M5 N1 N2 N3 N4 N5 P3 P4 R1 R2 R3 R4 R5 T1 T2 T3 T4 T5 T6 T24 U3 U4 U6 U24 V1 V2 V3 V4 V5 V6 V24 V25 W1 W2 W3 W4 Y3 Y4; U44 J1 J9 L1 L9 M7; U45 A5 A17 A37 A51 AB21 AC2 AC4 AC20 AF20 AL1 AL11 AM10 AM11 AN10 AP7 AT2 AU10 AU12 AU15 AU44 AU63 AV2 AV10 AV44 AV50 AV62 AV63 AW10 AW14 AW49 AY8 AY14 AY42 AY43 B5 B17 B37 B43 B51 C5 C62 C63 D1 D15 D58 E1 E5 E13 E15 F5 F22 H8 H18 H22 J8 J20 J21 K10 K18 K21 L11 L60 M20 M21 N23 N60 P20 R20 R23 T23 U10 V21 W23 Y20 Y22; U50 J1 J9 L1 L9; U51 J1 J9 L1 L9; U52 J1 J9 L1 L9; U53 J1 J9 L1 L9; U54 2 3; U56 1 2 3 8 12 13 14

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 5497 vias
v2: diameter 0.61, hole 0.356, TOP to BOTTOM, 1014 vias
v3: diameter 0.66, hole 0.33, TOP to BOTTOM, 88 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.5V_VSNS: length 4.1
  BOTTOM w0.14: v1(130.77,49.13) 130.91,48.99 PR213.1
  BOTTOM w0.254: PR213.1 PR214.2 132.96,48.52 132.76,48.33 PU10.6
2.469V: length 8.5
  BOTTOM w0.508: PR159.2 97.62,112.89 v3(97.88,113.14) 98.37,113.64 PR155.1 97.32,114.72 96.73,115.3 96.73,116.32 96.48,116.57 PU8.3
3V_LDO: length 3.1
  TOP w0.203: PU5.3 197.42,68.18 v1(197.44,68.21)
  TOP w0.508: v1(197.44,68.21) 197.6,68.36 PC52.1
  BOTTOM w0.381: PR191.1 198.04,68.21 v1(197.44,68.21)
3V_MAIN_PWGD: length 117.3
  TOP w0.14: R70.1 15.06,143.88 v1(15.07,143.87) 15.83,143.11 15.83,139.36 PR28.1 18.17,139.06 v1(18.87,139.06) ; R70.1 14.06,144.64 13.8,144.89 Q5.3 ; R70.1 13.22,143.88 R66.2
  IN2 w0.114: v1(49.46,76.92) 49.74,76.64 49.74,72.88 49.36,72.5 46.95,72.5 46.57,72.12 41.49,72.12 41.03,72.58 32.85,72.58 31.77,73.66 30.96,73.66 30.2,74.41 30.2,87.65 31.83,89.27 31.83,90.83 32.36,91.37 32.36,96.48 30.67,98.17 25.86,98.17 25.14,98.89 25.14,110.75 23.17,112.71 22.64,112.71 21.29,114.05 21.29,116.7 21.93,117.33 21.93,129.81 19.9,131.84 19.9,138.03 v1(18.87,139.06)
  BOTTOM w0.14: v1(49.46,76.92) 48.97,76.43 PR166.2
51211V_DRVH: length 10.8
  IN2 w1.016: v2(182.3,74.18) 182.47,74.01 190.75,74.01 191.12,73.64 v2(192.11,73.64)
  BOTTOM w0.14: v2(192.11,73.64) v1(191.35,73.64)
51211V_DRVL: length 10.4
  IN2 w1.016: v2(192.54,76.39) 191.55,76.39 191.03,75.87 183.43,75.87 v2(183.19,76.11)
  BOTTOM w0.14: v2(192.54,76.39) v1(192.54,77.15)
51211V_EN: length 4.2
  TOP w0.279: PU4.3 v1(197.09,74.41)
  BOTTOM w0.254: PR172.2 196.97,74.29 v1(197.09,74.41) 197.21,74.28 PR171.2 198.2,74.23 PR175.2
51211V_FB: length 5.3
  TOP w0.14: v1(200.24,76.06) 199.48,76.06 PR61.2
  TOP w0.254: PU4.4 196.67,74.91 196.94,75.17
  TOP w0.279: 196.94,75.17 197.21,75.45 PR63.1
  TOP w0.381: PR63.1 198.15,75.62 198.93,76.4 PR61.2
51211V_SW: length 17.3
  TOP w0.14: PR53.1 v1(175.85,78.7)
  TOP w0.762: v2(174.74,77.89) PR53.1
  IN3 w1.016: v2(177.81,74.05) 179.1,72.75 184.48,72.75 185.29,73.57 189.75,73.57 190.84,74.66 v2(191.86,74.66)
51211V_TRIP: length 4.4
  TOP w0.14: PR68.2 198.65,74.79 v1(200.11,74.79)
  TOP w0.254: PU4.2 197.06,73.91
  TOP w0.279: 197.06,73.91 197.77,73.91 PR68.2
51211V_TST: length 2.8
  TOP w0.279: PU4.5 196.12,75.91 v1(196.45,76.23)
  BOTTOM w0.508: PR165.2 197.82,76.31 196.53,76.31 v1(196.45,76.23)
51211V_VBST:
  vias: v1(191.78,72.86)
+1.5V: length 284.1
  TOP w0.508: v2(149.69,44.31) 149.46,44.54 144.59,44.54 v3(144.44,44.69) 144.29,44.84 PR123.1 ; v1(137.12,138.67) 136.74,138.67 136.48,138.41 136.48,137.5 R84.1 ; v1(151.7,143.49) 154.01,143.49 155.79,141.72 155.79,141.08 v1(156.04,140.83)
  IN2 w0.508: v1(137.12,138.67) 138.9,140.45 147.41,140.45 147.91,140.95 149.97,140.95 150.83,141.82 150.83,142.86 151.47,143.49 v1(151.7,143.49) ; v1(191.47,92.69) 191.35,92.57 186.39,92.57 172.81,106.16 172.81,115.17 156.17,131.81 156.17,140.06 156.04,140.19 v1(156.04,140.83)
  IN2 w1.016: v2(195.54,39.35) v2(196.55,39.35) 197.62,38.29 210.52,38.29 211.91,39.67 219.67,39.67 221.76,41.77 223.02,41.77 225.57,44.32 225.57,45.13 227.61,47.16 227.61,47.67 231.86,51.93 v1(233.38,51.93) 237.07,51.93 237.96,51.04
  IN3 w0.508: v1(204,76.82) 204.56,76.82 205.06,76.31 205.83,76.31 208.77,73.36 213.47,73.36 218.91,67.93 224.62,67.93 228.94,63.61 228.94,60.82 233.38,56.37 v1(233.38,51.93)
  IN3 w1.016: v2(149.69,44.31) 151.34,42.66 154.52,42.66 155.53,41.64 158.61,41.64 161.02,39.23 165.44,39.23 170.52,44.31 175.22,44.31 176.74,45.83 189.06,45.83 v2(195.54,39.35) v2(196.55,39.35)
  BOTTOM w0.381: PR214.1 132.96,50.86 133.43,51.33 136.32,51.33 139.53,48.12 143.19,48.12 144.01,47.29
  BOTTOM w0.508: v1(191.47,92.69) 192.13,93.35 195.23,93.35 200.49,88.1 200.49,86.89 202.14,85.24 202.14,82.69 203.29,81.54 203.29,77.53 v1(204,76.82)
  vias: v1(237.83,50.12) v1(238.46,50.12)
+1.05V: length 339.3
  TOP w0.254: R401.2 144.78,42.48 141.11,42.48 v1(140.98,42.61) ; PR81.2 56.03,68.87 56.03,68.94 56.01,68.96 v1(56.01,68.94) ; U15.5 83.41,127.87 83.15,127.61 C156.1
  TOP w0.305: v1(64.93,77.63) 64.93,77.4 64.6,77.07 63.84,77.07 62.06,75.29 62.06,73.74 61.78,73.46 61.78,72.1 60.88,71.2 60.88,70.05 60.55,69.72 59.87,69.72 59.35,70.24 58.71,70.24 56.9,68.44 56.46,68.44 PR81.2
  TOP w0.381: C175.2 133.22,124.32 133.42,124.52 134.6,124.52 134.98,124.9 v1(134.98,125.18)
  TOP w0.508: v1(92.87,129.17) 91.04,129.17 88.99,127.11 v1(84.29,127.11) C156.1 83.15,126.87 v1(82.64,126.35) ; R232.1 137.25,98.31 v1(136.18,97.24)
  IN1 w0.254: v1(66.63,45.42) 66.63,45.15 67.17,44.61 90.6,44.61 91.44,45.44 101.41,45.44 103.26,43.6 114,43.6 114.75,42.85 118.26,42.85 118.83,43.42 123.15,43.42 123.66,43.93 123.66,44.33 124.25,44.92 128.25,44.92 129.52,43.65 133.78,43.65 134.83,42.61 v1(140.98,42.61)
  IN2 w0.254: v1(66.63,45.42) 66.57,45.49 62.72,45.49 59.02,49.19 55.94,49.19 52.7,52.43 v1(52.28,52.43) ; v1(56.01,68.94) 56.01,68.35 55.71,68.06 54.14,68.06 52.03,65.95 52.03,60.69 56.22,56.5 v1(56.22,56.24) ; v1(64.93,77.63) 65.26,77.96 75.26,77.96 76.03,78.72 80.35,78.72 84.34,82.71 v1(84.34,91.3)
  IN2 w0.432: v1(136.18,97.24) 136,97.24 133.58,99.66 133.58,105.93 133.14,106.37 133.14,106.83 130.52,109.45 130.52,114.34 132.41,116.23 132.84,116.23 133.56,116.95 133.56,117.71 133.97,118.12 134.73,118.12 135.07,118.46 v1(135.52,118.46)
  IN2 w0.508: v1(92.87,129.17) 92.87,129.85 93.81,130.79 93.81,134.22 100.29,140.7 106.9,140.7 v1(107.53,140.07)
  IN3 w0.254: v1(52.28,52.43) 54.57,52.43 56.22,54.09 v1(56.22,56.24)
  IN3 w0.508: v1(86.11,103.79) 86.96,102.94 v1(86.96,99.76) 86.96,93.92 v1(84.34,91.3)
  BOTTOM w0.203: v1(134.07,121.8) 134.04,121.84 U45.R21 ; U45.AG14 136.73,115.94 136.47,116.2 136.47,116.2 136.36,116.2 136.08,116.48 136.08,117.2 135.52,117.76 v1(135.52,118.46) ; v1(134.68,121.8) 134.68,121.75 133.95,121.02 U45.T21
  BOTTOM w0.254: U45.J17 135.23,125.18 v1(134.98,125.18)
  BOTTOM w0.508: v1(136.18,97.24) 134.37,99.04 104.61,99.04 103.84,98.28 92.36,98.28 90.92,99.73 86.98,99.73 v1(86.96,99.76) ; R495.1 v1(107.53,140.07) ; 160.87,112 161.35,112 162.64,110.71 PR160.1 ; v1(86.11,103.79) 85.94,103.96 85.94,108.06 82.64,111.36 v1(82.64,126.35) ; v1(143.6,138.16) 143.6,137.65 143.72,137.53 L30.1
  vias: v1(129.29,120.91) v1(129.9,120.91) v1(135.29,121.8) v1(139.91,142.88) v1(140.04,143.49) v2(157.44,115.81) v2(157.44,115.1) v2(157.44,114.39) v2(158.15,115.81) v2(158.15,115.1) v2(158.15,114.39)
+1.05V_DCPSUS1: length 41
  TOP w0.254: C229.1 136.99,118.9 137.03,118.9 137.37,118.55 v1(137.37,117.84)
  TOP w0.508: R264.2 142.33,92.9 v1(142.35,92.92) 143.04,92.92 v1(143.47,93.35)
  IN1 w0.254: v1(140.5,117.56) 139.99,117.56 139.2,118.35 137.88,118.35 v1(137.37,117.84)
  IN2 w0.254: v1(137.37,117.84) 137.37,117.46 137.02,117.1 137.02,116.34 136.23,115.55 136.13,115.55 134.96,114.39 134.96,113.78 135.34,113.39
  IN2 w0.508: v1(143.47,93.35) 143.32,93.2 142.02,93.2 137.69,97.53 137.69,104.15 135.34,106.5 135.34,113.39
  BOTTOM w0.305: v1(140.5,117.56) 140.24,117.3 U45.AD8 U45.AD10 139.29,117.13 138.08,117.13 v1(137.37,117.84)
+1.05V_DCPSUS2: length 28.5
  TOP w0.457: v1(137.17,114.28) 137.12,114.28 C252.1
  TOP w0.508: R263.1 v1(141.06,93.05) 141.64,93.63 142.83,93.63 142.88,93.68 142.88,93.68 v1(143.01,93.81)
  IN2 w0.254: 137.27,109.97 137.12,110.12 137.12,114.23 v1(137.17,114.28)
  IN2 w0.508: v1(143.01,93.81) 143.21,94.01 143.21,94.47 142.83,94.85 142.09,94.85 138.91,98.04 138.91,104.39 137.27,106.03 137.27,109.97
  BOTTOM w0.254: v1(137.17,114.28) 137.22,114.28 U45.AH13
+1.05V_DCPSUS3: length 11.3
  TOP w0.508: v1(137.04,125.18) 136.84,125.18 136.23,124.57 v1(136.05,124.57) 135.6,124.57 C178.1 134.97,123.13 v1(134.91,123.07) ; C174.2 130.51,124.32 v1(129.88,123.68) 130.27,123.29 R119.2
  IN3 w0.508: v1(129.88,123.68) 131.02,123.68 131.1,123.76 134.5,123.76 134.91,123.35 v1(134.91,123.07)
  BOTTOM w0.254: U45.J13 137.41,124.85 137.08,125.18 v1(137.04,125.18)
+1.05V_DCPSUS4: length 37.8
  TOP w0.381: C216.1 139.28,120.51 139.58,120.2 139.58,119.63 140.39,118.81 v1(140.39,118.5)
  TOP w0.508: R262.2 v1(139.79,93.07) 140.95,94.24 v1(142.58,94.24)
  IN2 w0.254: v1(140.39,118.5) 138.41,118.5 137.88,117.97 137.88,117.46 137.37,116.96 137.37,116.06 136.69,115.38 136.69,109.91 136.05,109.28 136.05,107.86 136.74,107.17 136.74,105.85 138.3,104.29 138.3,102.47
  IN2 w0.508: v1(142.58,94.24) 141.84,94.24 138.3,97.78 138.3,102.47
  BOTTOM w0.254: U45.AB8 140.39,118.18 v1(140.39,118.5)
+1.05V_GFX: length 7.7
  TOP w0.508: 25.49,141.97 24.85,142.6 20.66,142.6 20.41,142.36 PR23.1 ; v1(37.73,127.35) 37.6,127.22 C160.1 ; v1(37.65,129.65) 37.65,129.4 37.6,129.35 C150.1
  vias: v1(33.51,139.46) v1(33.49,138.64) v1(34.3,138.6) v1(35.13,137.81) v1(35.1,136.11) v1(35.1,135.34) v1(35.1,134.48) v1(35.1,133.66) v1(35.1,132.86) v1(35.14,131.17) v1(39.33,113.52) v1(39.96,113.52) v1(43.9,113.01) v2(24.09,141.11) v2(24.09,140.34) v2(24.85,141.11) v2(24.85,140.34) v2(25.61,141.11) v2(25.61,140.34)
+1.05V_S5: length 134.3
  TOP w0.381: PR61.1 198.1,76.66 198.1,76.72 v1(197.67,77.15)
  TOP w0.508: C326.2 32.1,82.92 v1(31.97,83.05) ; v1(92.67,115.81) 92.66,115.81 91.91,116.56 R164.1 ; R166.2 88.37,114.51 v1(89.77,114.51) ; R119.1 129.49,122.67 v1(129.75,122.41) ; v1(144.51,92.67) 143.47,91.63 143.47,90.79 ; R151.1 v1(90.92,117.84) ; R150.1 v1(88.22,117.84)
  IN1 w0.508: v1(129.75,122.41) 128.25,120.91 128.25,119.87 127.72,119.34 127.72,117.84 126.83,116.95 v1(126.83,116.39)
  IN2 w0.127: 128.39,114.06 128.48,114.16 128.86,114.16 129.4,113.62 129.4,109.46 ; 127.64,114.12 127.49,113.97 127.49,109.81 127.97,109.33 129.37,109.33
  IN2 w0.203: 128.47,113.98 128.47,114.03 128.38,114.12 ; 128.47,113.98 128.47,113.29 128.49,113.27 128.49,109.58 ; 128.47,113.98 128.39,114.06
  IN2 w0.457: 128.38,114.12 127.58,114.12 127.07,114.63 127.07,115.1 126.83,115.34 v1(126.83,116.39)
  IN2 w0.508: v1(144.51,92.67) 143.52,91.68 141.56,91.68 136.74,96.5 135.8,96.5 133.01,99.3 133.01,104.89 132.37,105.52 131.78,105.52 131.28,106.03 131.28,107.04 129.63,108.7 ; v1(90.92,117.84) v1(88.22,117.84)
  IN3 w0.508: v1(90.26,98.76) 90.26,99.17 89.04,100.39 89.04,106.41 86.19,109.25 86.19,111.11 89.59,114.51 v1(89.77,114.51) 90.66,115.4 92.26,115.4 v1(92.67,115.81) 92.67,116.09 v1(90.92,117.84) ; v2(173.95,81.52) 175.47,79.99 189.82,79.99 192.08,77.73 196.05,77.73 196.55,77.23 197.6,77.23 v1(197.67,77.15)
  BOTTOM w0.508: v1(90.26,98.76) 90.26,97.09 ; R594.2 98.37,117.98 98.09,117.98 93.91,122.16 90.26,122.16 88.99,120.89 88.99,120.13 88.63,119.77 88.1,119.77 87.67,119.34 87.67,118.4 v1(88.22,117.84)
  vias: v1(80.2,95.84) v1(80.63,96.38) v1(80.81,95.74) v1(81.09,96.88) v1(81.26,96.25) v1(81.75,96.81) v1(144.1,89.77) v1(144.53,89.34) v1(153.76,90.97) v1(154.29,91.27) v1(154.26,90.48) v1(154.64,89.93) v1(154.75,90.87) v1(155.28,90.53) v1(155.25,89.93) v1(155.86,89.93) v2(26.12,137.14) v2(26.12,136.38) v2(26.12,135.62) v2(26.88,136.38) v2(26.88,135.62) v2(165.19,114.03) v2(165.19,113.27) v2(165.19,112.51) v2(165.19,111.74) v2(165.95,113.39) v2(165.95,112.63) v2(165.95,111.87) v2(165.95,111.11) v2(165.95,110.35) v2(172.42,82.28) v2(172.42,81.52) v2(173.19,82.28) v2(173.19,81.52) v2(173.95,82.28) v3(95.97,93.2)
+1.05V_VCCST: length 82.9
  TOP w0.203: PR2.1 144.49,154.67 v1(144.99,154.67) 145.49,154.67 PR3.1
  TOP w0.254: v1(141.82,153.55) 142.72,152.65 PR6.1 ; 127.37,155.16 U10.5
  TOP w0.381: R109.1 97.65,126.35 97.76,126.35 98.26,126.86 R103.1 99.42,126.98 v1(100.29,126.12)
  TOP w0.508: v1(126.91,154.64) 126.59,154.97 C51.1 127.23,155.3 127.37,155.16 ; R96.2 98.9,130.16 100.11,130.16 v1(101.33,131.38) ; v1(92.77,133.54) 93.61,133.54 Q8.3
  IN2 w0.762: 143.32,152.76 134.3,152.76 133.54,153.53 128.02,153.53 v1(126.91,154.64) 126.25,155.3 125.54,155.3 125.03,154.8 120.23,154.8 115.91,150.48 115.91,145.35 106.94,136.38 105.22,136.38 104.48,135.65 v1(104.48,135.49)
  IN3 w0.508: v1(101.33,131.38) 100.01,131.38 97.93,133.46 95.97,133.46 95.59,133.08 93.23,133.08 v1(92.77,133.54)
  BOTTOM w0.203: v1(144.99,154.67) 145.49,154.67 PR3.1
  BOTTOM w0.254: v1(141.82,153.55) 141.92,153.55 142.64,152.83 PC91.1 ; U45.AE23 131.81,116.15 U45.AE22 U45.AC22
  BOTTOM w0.457: R506.2 104.35,135.37 v1(104.48,135.49)
  BOTTOM w0.508: R548.2 102.71,124.31 v1(103.21,123.81) ; R578.1 98.56,120.38 v1(98.21,120.74) ; R554.1 98.76,123.68 v1(98.53,123.45) ; R499.2 103.01,136.64 v1(103.11,136.74)
  vias: v1(129.88,116.06) v1(131.15,116.14)
+1.5VAVDD2: length 6.6
  TOP w0.203: C488.1 236.18,44.81 235.78,44.42 U34.40
  TOP w0.508: C488.1 236.4,45.44 236.81,45.86 236.81,47.63 C479.1 R392.1
+1.35V_GFX: length 159.5
  TOP w0.102: v1(41,157) U11.N1
  TOP w0.254: U13.G7 63.34,142.96 63.34,142.12 63.43,142.03 63.43,140.86 v1(63.41,140.83)
  TOP w0.305: U12.N9 46.44,156.6 v1(46.33,156.71) ; U11.H2 40.62,152.6 v1(41,152.23) ; v1(65.55,126.91) 65.92,127.28 U16.K2 ; v1(35.39,153.8) 35.79,154.2 U11.K8 ; v1(54.55,158.99) 54.55,158.89 54.15,158.49 53.56,158.49 U12.R1 ; U13.H9 v1(64.72,144.36) ; U13.A8 58.73,143.97 v1(59.12,144.35) ; U13.N1 68.33,138.39 v1(68.69,138.75) ; v1(35.39,146.61) 35.78,147 U11.A8 ; U13.D9 61.13,144.75 v1(60.75,144.36) 60.72,144.36 U13.C9 ; v1(35.38,148.23) 35.01,148.6 U11.C9 34.93,148.67 v1(34.45,148.67) ; v1(63.91,127.67) 64.3,127.28 U16.H2 ; U11.R1 41.49,158.2 v1(41.89,157.8) ; U16.R9 70.37,133.32 71.87,133.32 71.96,133.23 v1(71.89,133.23) ; U16.B2 59.53,127.26 v1(59.17,126.89) 58.76,126.48 U16.A1 ; v1(63.94,131.66) 63.56,131.28 U16.G7 ; U13.E9 62.48,145.3 v1(63,145.3) ; U11.G7 36.59,151.8 v1(36.17,152.21) ; U13.K8 65.93,143.99 v1(65.57,144.36) ; v1(34.11,152.68) 34.19,152.6 U11.H9 ; v1(40.98,146.55) 41.4,146.97 U11.A1 ; U16.D9 61.13,132.97 v1(60.67,133.44) 60.33,133.11 60.33,132.88 U16.C9 ; v1(52.84,153.81) 52.47,154.19 U12.K2 ; U16.N9 68.71,132.5 v1(68.72,132.5) ; v1(46.47,153.01) U12.H9 ; v1(63.87,133.44) 64.33,132.98 U16.H9 ; v1(65.54,138.78) 65.92,139.15 U13.K2 ; v1(59.13,132.49) 58.73,132.1 U16.A8 ; v1(65.44,149.32) R63.2 ; v1(52.06,152.18) 52.47,152.59 U12.H2 ; U11.E9 34.63,150.2 v1(34.4,150.44) ; U13.F1 v1(62.73,137.71) ; U11.B2 U11.C1 v1(41,149) U11.D2 ; v1(47.27,153.78) 47.27,153.82 47.65,154.2 U12.K8 ; U12.B2 52.47,147.79 v1(52.88,147.39) 53.26,147 U12.A1 ; U13.R1 69.93,138.28 v1(69.54,137.89) ; v1(62.32,133.44) 61.93,133.06 U16.E9 ; v1(49.03,152.01) 48.82,151.8 U12.G7 ; v1(46.24,160.29) 46.26,160.26 46.26,158.81 U12.R9 ; v1(65.53,132.48) U16.K8
  TOP w0.381: v1(60.41,156.48) 60.21,156.69 R35.2 ; v1(53.86,157.4) 53.86,157.19 U12.N1 ; R49.2 67.08,154.91 R41.2 67.32,155.67 v1(67.7,156.05) ; U11.D9 34.95,149.45 34.47,149.45 v1(34.4,149.51) ; v1(41,153.8) U11.K2 ; v1(63.93,138.75) U13.H2 ; R36.2 62.31,156.23 v1(61.88,156.23) ; v1(52.06,149.01) 52.45,149.4 U12.D2 v1(52.87,149) U12.C1 ; U12.F1 53.26,151 v1(52.84,150.59) ; R42.2 68.46,155.18 v1(68.92,155.64) ; U11.F1 v1(41.82,150.58) ; v1(65.29,121.5) R122.2
  TOP w0.508: v1(71.08,155.56) 71.08,155.06 C56.2 ; C226.2 7.7,118.85 v1(7.83,118.98) ; v1(63.94,159.75) 63.51,159.32 R15.2 ; v1(70.06,155.56) 69.94,155.43 R39.2 ; C55.1 72.12,155.41 v1(71.97,155.56) ; v1(29.78,157.52) 30.3,157.52 R28.2 ; v1(62.32,160.13) 62.37,160.08 R10.2 ; R174.1 R173.1 ; R173.1 R172.1 ; R173.1 v1(58.51,113.78) ; R17.2 65.8,159.29 v1(66,159.5) ; C5.2 v1(60.41,169.02) ; C2.2 v1(34.63,169.02) ; 71.71,97.01 70.65,95.95 v1(70.65,86.14) ; C13.2 C12.2 ; C57.2 v1(24.08,153.41)
  IN2 w0.381: v1(14.69,130.54) 17.74,130.54 20.66,127.62 20.66,119.87 19.52,118.73 19.52,116.95 19.01,116.44 15.91,116.44 v1(15.02,117.33)
  IN3 w0.508: v1(69.4,81.75) 69.4,82.97 70.65,84.21 v1(70.65,86.14)
  BOTTOM w0.18: v1(46.47,153.01) 47.25,153.01
  BOTTOM w0.305: U12.C1 v1(52.87,149) U39.D9 ; U12.N9 46.49,156.6 46.33,156.76 ; 46.33,156.76 46.26,156.83 46.26,157.6 46.87,158.2 U12.R9 46.36,158.71 46.36,160.05 46.24,160.18 v1(46.24,160.29) ; 46.33,156.76 v1(46.33,156.71) ; v1(65.57,144.36) 65.93,143.99 U13.K8 ; U38.A8 40.6,146.93 v1(40.98,146.55) ; U11.C1 v1(41,149) U38.D9 ; v1(41,157) U11.N1 ; U41.D9 60.54,137.76 v1(60.46,137.76) 60.33,137.89 U13.C1 ; U12.R1 53.47,158.41 54.06,158.41 54.54,158.89 54.54,158.99 v1(54.55,158.99) ; v1(65.54,138.78) 65.92,139.15 U13.K2 ; U38.D2 U11.C9 34.93,148.67 v1(34.45,148.67) ; 47.25,153.01 47.66,152.6 U39.H2 ; U41.E9 62.02,138.35 62.66,137.71 v1(62.73,137.71) ; U38.A1 35,147 v1(35.39,146.61) ; U13.R1 69.93,138.28 v1(69.54,137.89) ; v1(63,145.3) 62.73,145.03 U41.F1 ; v1(71.89,133.23) 71.94,133.23 71.85,133.32 70.37,133.32 U16.R9 ; U11.R1 41.49,158.2 v1(41.89,157.8) ; v1(34.4,150.44) 34.96,151 U38.F1 ; U41.B2 59.51,143.95 v1(59.12,144.35) 58.73,144.73 U41.A1 ; v1(35.39,153.8) 35.79,154.2 U11.K8 ; U41.H9 v1(63.93,138.75) ; U38.B2 35.8,147.81 v1(35.38,148.23) ; U13.C9 60.35,144.75 v1(60.75,144.36) 61.13,143.97 U41.D2 ; U41.H2 64.33,143.97 v1(64.72,144.36) ; v1(52.06,152.18) 51.69,151.8 U39.G7 ; v1(59.16,138.75) 58.75,139.15 U41.A8 ; U44.H2 64.33,132.06 v1(63.94,131.66) ; U16.N9 68.71,132.5 v1(68.72,132.5) ; v1(63.41,140.83) 63.41,140.08 U41.G7 ; R63.2 v1(65.44,149.32) ; v1(63.91,127.67) 63.91,127.71 U44.G7 ; v1(47.95,141.41) 47.96,141.4 U43.H26 ; U13.N1 68.33,138.39 v1(68.69,138.75) ; U12.K2 v1(52.84,153.81) ; U16.K2 v1(65.55,126.91) ; U12.K8 47.64,154.2 47.27,153.83 v1(47.27,153.78) ; U38.H2 35.8,152.59 v1(36.17,152.21) ; v1(65.53,132.48) U16.K8
  BOTTOM w0.381: v1(50.84,138.65) 50.84,138.6 U43.E23 ; 52.49,140.25 U43.C25 ; 52.49,140.25 v1(52.49,140.25) ; 52.49,140.25 U43.B26 ; U38.E9 41.44,150.2 v1(41.82,150.58) ; v1(45.04,138.65) 45.46,139.06 U43.L24 ; v1(52.84,150.59) 52.88,150.59 U39.E9 ; v1(53.86,157.4) 53.86,157.19 U12.N1 ; v1(63.36,152.62) 63.76,152.62 R473.2 R471.2 ; v1(15.02,117.33) 15.16,117.19 PR154.1 ; R42.2 68.46,155.18 v1(68.92,155.64) ; R41.2 67.32,155.67 v1(67.7,156.05) ; U43.L26 45.43,140.66 v1(45.04,140.27) ; R122.2 v1(65.29,121.5) ; U39.H9 53.33,152.6 v1(53.76,152.18) ; R435.2 v1(61.35,162.4) R443.2
  BOTTOM w0.4: U39.A8 52.49,147 v1(52.88,147.39) ; U43.H24 47.97,139.06 48.39,139.49 48.38,139.49 48.38,139.48 v1(48.37,139.48) ; v1(50.89,141.03) 50.74,140.88 50.67,140.88 U43.E26
  BOTTOM w0.508: R458.2 62.37,160.08 v1(62.32,160.13) ; v1(29.8,158.23) 30.21,158.23 R28.2 ; R463.2 59.38,156.48 v1(60.41,156.48) ; PR162.1 70.06,81.65 69.95,81.75 v1(69.4,81.75) ; C55.1 72.12,155.41 v1(71.97,155.56) ; C590.2 v1(82.97,147.56) ; C584.2 v1(82.97,148.7) ; C56.2 71.08,155.06 v1(71.08,155.56)
  vias: v1(32.09,161.78) v1(32.09,160.89) v1(32.09,159.75) v1(32.27,157.32) v1(33.39,161.94) v1(34.38,161.02) v1(34.43,159.73) v1(34.4,158.23) v1(34.43,156.79) v1(34.5,162.8) v1(35.42,162.8) v1(38.44,137.02) v1(39.28,137.02) v1(42.81,136.11) v1(43.44,136.11) v1(44.21,136.11) v1(46.27,151.01) v1(46.31,149.54) v1(46.31,148.93) v1(46.28,147) v1(47.26,147.37) v1(47.56,137.02) v1(49.21,136.97) v1(49.26,136.13) v1(49.26,135.32) v1(49.26,134.48) v1(49.25,132.01) v1(49.24,131.18) v1(49.26,130.34) v1(58.53,163.87) v1(58.96,163.41) v1(59.22,164.05) v1(59.9,164.07) v1(60.03,164.7) v1(60.54,164.07) v1(60.72,126) v1(61.53,126) v1(63.26,123.92) v1(63.73,124.41) v1(64.27,124.68) v1(64.78,125.19) v1(68.03,148.4) v1(68.23,145.34) v1(68.33,125.89) v1(68.54,148.02) v1(68.72,124.68) v1(69.48,148.73) v1(69.93,125.84) v1(69.99,124.68) v1(70.09,145.27) v1(70.49,123.66) v1(70.8,147.56) v1(71.38,123.66) v1(72.27,123.66) v1(73.03,127.85) v1(73.03,127.09) v1(73.03,126.2) v1(73.03,125.31) v1(73.49,124.44) v1(73.49,123.68) v1(73.49,123.05) v1(73.54,128.49) v1(74.43,128.49) v1(74.69,148.94) v1(75.17,128.49) v1(75.45,148.81) v1(75.96,148.43) v1(76.34,146.88) v1(76.62,148.45) v1(77.25,137.94) v1(77.48,135.6) v1(77.68,134.98) v1(78.11,135.6) v2(14.56,136.38) v2(14.56,135.62) v2(15.33,136.38) v2(15.33,135.62) v2(16.09,136.38) v2(16.09,135.62) v2(16.85,136.38) v2(16.85,135.62) v2(17.61,136.38) v2(17.61,135.62) v2(72.5,100.01) v2(72.96,102.37) v2(72.96,101.61) v2(73.21,100.01) v2(73.69,102.37) v2(73.69,101.61) v2(74.48,102.37) v2(74.48,101.61) v2(75.14,102.02) v3(56.81,159.95)
+1.35V_SUS: length 412.9
  TOP w0.178: U28.K8 74.95,62.93 76.46,62.93 v1(76.67,62.72) ; v1(89.74,62.45) 89.24,62.45 88.93,62.14 88.15,62.14 U29.K8 ; v1(81.62,62.72) 81.62,62.47 81.95,62.13 82.57,62.13 U29.K2 ; U30.K8 106.96,62.93 107.89,62.93 v1(108.01,62.8)
  TOP w0.208: v1(197.19,57.72) 197.3,57.61 PU6.9
  TOP w0.229: v1(99.53,64.3) 100.09,63.73 101.37,63.73 U30.H2 ; U28.K2 69.75,62.53 69.34,62.93 68.4,62.93 v1(67.95,63.38) ; v1(100.54,62.95) 100.57,62.93 101.36,62.93 U30.K2 ; U28.N1 68.87,60.05 68.29,60.05 v1(67.9,60.44)
  TOP w0.254: 75.33,64.15 U28.H9
  TOP w0.279: U23.5 97.38,92.3 96.61,93.07
  TOP w0.305: v1(74.94,64.54) 75.33,64.15 ; v1(120.16,64.56) 120.57,64.15 U31.H9 ; U31.K8 119.39,62.15 119.38,62.15 119.35,62.13 v1(119.33,62.13) ; v1(76.41,57.31) 76.41,57.95 75.83,58.53 U28.R9 ; v1(107.78,66.11) U30.E9 ; v1(113.43,68.61) 113.91,68.13 U31.C1 U31.D2 ; U30.A8 106.84,70.01 v1(106.84,70.21) ; v1(114.58,62.14) U31.K2 ; U28.D2 U28.C1 68.37,68.13 v1(68.09,68.41) ; v1(106.16,65.33) U30.G7 ; U30.R9 108.4,57.49 v1(108.4,57.31) ; U28.B2 69.35,69.33 v1(69.33,69.33) ; U31.A1 113.45,69.73 v1(113.38,69.65) ; v1(76.65,59.51) 76.13,60.03 75.45,60.03 U28.N9 ; U30.N9 107.37,60.13 v1(107.76,59.74) ; v1(101.33,69.33) 101.35,69.33 U30.B2 ; U30.A1 100.93,69.7 100.19,69.7 v1(100.17,69.73) ; U28.R1 68.52,58.09 v1(68.52,57.28) ; v1(81.43,68.41) 81.71,68.13 U29.C1 U29.D2 ; v1(88.99,66.11) U29.E9 ; U30.N1 100.21,60.13 99.83,60.51 v1(99.83,60.63) ; U29.H9 89.43,64.13 v1(89.75,63.81) ; v1(120.95,59.74) 120.95,59.74 U31.N9 ; v1(120.99,66.11) U31.E9 ; v1(68.53,66.1) 68.9,65.73 U28.F1 ; v1(81.75,66.14) U29.F1 ; v1(114.54,69.33) 114.56,69.33 U31.B2 ; U31.H2 v1(114.58,63.74) ; U31.R9 121.37,57.73 v1(121.37,57.2) ; U28.C9 v1(75.78,67.71) ; v1(100.53,66.13) 100.93,65.73 U30.F1 ; v1(120.99,66.91) U31.D9 ; v1(88.96,59.73) 88.96,59.73 U29.N9 ; U29.R9 89.11,58.53 v1(89.62,58.02) ; U28.A8 v1(75.04,70.21) ; U31.F1 114.11,65.73 v1(113.74,66.1) ; v1(107.78,67.71) U30.C9 ; U29.A8 88.04,70.01 v1(88.04,70.21) ; v1(107.78,66.91) U30.D9 ; v1(75.78,66.11) U28.E9 ; v1(107.91,64.68) U30.H9 ; v1(113.14,60.49) 113.14,60.41 113.55,60 114.04,60 U31.N1 ; U29.H2 v1(82.57,63.74) ; v1(74.16,65.36) 74.16,65.33 U28.G7 ; U28.A1 68.68,69.45 v1(68.11,69.45) ; v1(87.37,65.33) U29.G7 ; U30.D2 U30.C1 100.5,68.13 v1(100.22,68.41) ; U29.N1 81.96,59.93 81.37,59.93 ; U29.B2 82.56,69.33 v1(82.53,69.33) ; U28.D9 v1(75.78,66.91) ; v1(113.78,58.91) U31.R1 ; v1(119.37,65.33) U31.G7 ; v1(88.99,67.71) U29.C9 ; v1(88.99,66.91) U29.D9 ; v1(120.99,67.71) U31.C9 ; v1(69.36,63.73) U28.H2 ; v1(100.42,58.66) 100.54,58.53 U30.R1 ; v1(81.37,69.73) U29.A1
  TOP w0.381: v1(69.33,52.43) 69.33,51.95 C467.1 ; C440.1 86.23,54.22 v1(86.6,54.59) ; v1(61.05,54.09) 61.05,54.59 61.32,54.87 R365.2
  TOP w0.457: C449.1 73.3,54.3 v1(73.92,54.92) ; C465.2 89.87,54.74 v1(89.94,54.8) ; v1(100.42,58.66) 100.42,58.91 100.03,59.29 98.38,59.29 97.48,58.39 C418.2 ; C392.1 v1(91.91,66.01) 89.08,66.01 v1(88.99,66.11) ; v1(123.67,58.8) 123.81,58.66 C415.1 ; C384.1 121.85,67.93 121.62,67.71 v1(120.99,67.71) ; C380.1 v1(91.78,68.81) 90.63,68.81 89.53,67.71 v1(88.99,67.71) ; v1(91.65,71.6) C367.2 ; C435.1 C434.1 ; C450.1 75.59,54.4 76.03,54.85 v1(76.03,55.1) ; v1(98.38,67.42) 97.99,67.03 C388.1 ; v1(123.66,54.84) C432.1 ; C441.1 87.23,54.92 v1(87.21,54.95) ; v1(122.77,63.1) 122.77,64.12 123.53,64.88 C398.1 ; v1(100.17,69.73) 99,69.73 98.27,70.46 C373.1 ; v1(91.65,54.8) 91.69,54.84 C431.2 ; C413.1 97.61,59.54 98.7,60.63 v1(99.83,60.63) ; C376.1 v1(91.78,70.21) 89.07,70.21 v1(88.99,70.13) ; v1(123.28,57.26) 123.28,57.01 124.05,56.24 C425.2 ; C386.1 v1(91.78,67.41) 90.26,67.41 89.75,66.91 v1(88.99,66.91) ; C421.1 124.02,57.49 v1(123.91,57.38) ; C393.1 121.41,65.9 121.2,66.11 v1(120.99,66.11) ; v1(100.22,68.41) 99.11,68.41 98.2,69.32 C379.1 ; v1(101.53,70.72) 100.53,71.73 C366.1 ; C383.1 v1(97.74,68.17) ; C442.1 91.27,54.29 v1(90.76,54.8) ; v1(88.6,54.8) C459.1 ; C395.1 v1(97.74,65.63)
  TOP w0.508: v1(120.99,66.91) 121,66.91 C389.1 ; v1(65.87,66.3) 65.22,65.65 C396.1 ; v1(62.29,68.28) 62.66,68.28 R325.2 ; v1(89.62,58.02) 90.13,57.51 C420.1 ; v1(97.42,55.41) 97.35,55.47 C428.1 ; C374.2 65.29,70.95 v1(65.77,70.47) ; v1(91.27,72.5) 90.13,72.5 89.74,72.89 C364.1 ; C365.1 65.86,73.02 v1(66,72.88) ; v1(82.51,54.97) 82.38,54.85 C434.1 ; C424.1 92.16,56.24 v1(91.53,56.87) ; v1(88.96,59.73) 89.56,59.73 90.77,58.52 92.52,58.52 C417.1 ; v1(96.8,53.52) 96.79,53.53 C433.1 ; 87.84,83.3 88.86,84.31 Q25.3 92.03,84.31 92.67,84.95 92.67,86.97 ; C422.1 97.61,57.12 v1(99.12,58.63) ; C347.1 78.83,76.55 v1(78.83,77.2) ; R282.2 92.67,86.97 ; 92.67,86.97 92.67,87.16 92.91,87.4 92.91,88.59 92.67,88.83 92.67,91.93 93.81,93.07 v3(94.95,93.07) 95.46,93.07 95.46,93.07 96.61,93.07 ; C385.1 v1(65.87,67.94) ; R333.1 v1(63.46,63.48)
  IN3 w0.508: v1(197.19,57.72) 197.19,57.9 196.55,58.53 193.13,58.53 191.35,60.31 178.01,60.31 177.25,59.55 v1(177,59.55)
  IN3 w1.016: v2(200.21,54.87) 199.22,55.86 199.22,58.28 198.08,59.42 193.63,59.42 191.86,61.2 176.87,61.2 v2(175.22,59.55)
  BOTTOM w0.178: v1(108.01,62.8) 108.02,62.81 108.02,63.3 107.61,63.71 107.03,63.71 106.61,64.13 U52.H2 ; v1(67.95,63.38) 68.1,63.23 68.51,63.23 68.81,62.93 69.36,62.93 U28.K2
  BOTTOM w0.203: U29.K8 87.78,62.53 88.18,62.13 88.93,62.13 89.24,62.45 v1(89.74,62.45) ; v1(76.67,62.72) 76.67,62.72 76.08,62.13 75.2,62.13 74.8,62.53 U28.K8 ; U30.K8 106.58,62.53 106.97,62.13 107.65,62.13 108.02,62.51 108.02,62.79 v1(108.01,62.8)
  BOTTOM w0.229: U29.K2 82.57,62.13 81.95,62.13 81.62,62.47 v1(81.62,62.72) ; v1(88.99,66.11) 89.49,65.6 89.49,65.13 88.89,64.53 88.17,64.53 U51.H2 ; v1(67.9,60.44) 68.31,60.03 68.86,60.03 U28.N1 ; U30.K2 101.36,62.93 100.57,62.93 v1(100.54,62.95) ; U50.H2 74.56,64.15 v1(74.94,64.54)
  BOTTOM w0.254: JDIM1.105 129.98,84.98 v1(129.51,85.45) ; JDIM1.82 123.08,74.47 123.4,74.15 v1(123.66,74.15) ; JDIM1.81 v1(122.78,85.33) 122.78,85.37 ; JDIM1.112 132.08,74.29 v1(132.17,74.2) ; U45.AY35 123.94,107.41 123.94,106.89 124.38,106.45 v1(124.4,106.45) ; v1(133.73,85.37) 133.58,85.21 JDIM1.117 ; JDIM1.87 124.58,85.18 v1(124.67,85.28) ; JDIM1.100 128.48,74.33 v1(128.61,74.2) ; JDIM1.76 121.28,74.42 v1(121.5,74.2) ; v1(120.55,85.43) 120.98,85.01 JDIM1.75 ; v1(126.35,85.37) 126.38,85.34 JDIM1.93 ; JDIM1.123 135.38,85.32 v1(135.33,85.37) ; v1(130.39,74.02) 130.28,74.13 JDIM1.106 ; U45.AY40 120.83,107.31 120.8,107.29 120.8,106.85 121.19,106.46 v1(121.24,106.46) ; JDIM1.88 124.88,74.41 v1(124.62,74.15) ; JDIM1.118 133.88,74.42 v1(133.61,74.15) ; JDIM1.94 126.68,74.25 v1(126.58,74.15) ; JDIM1.111 131.78,85 131.53,85.25 v1(131.15,85.25) ; v1(135.64,74.2) 135.68,74.24 JDIM1.124
  BOTTOM w0.305: U29.N9 88.96,59.73 v1(88.96,59.73) ; v1(70.16,65.33) U50.G7 ; U30.N1 100.21,60.13 99.83,60.51 v1(99.83,60.63) ; v1(120.18,67.74) U53.D2 ; U30.R1 100.54,58.53 v1(100.42,58.66) ; v1(88.99,70.13) 88.97,70.13 U51.A1 ; U51.F1 88.61,65.73 v1(88.99,66.11) ; v1(119.33,62.13) 119.35,62.13 119.38,62.15 119.39,62.15 U31.K8 ; v1(68.09,68.41) 68.37,68.13 U28.C1 U50.D9 U50.E9 v1(68.53,66.1) ; U31.K2 v1(114.58,62.14) ; U52.F1 107.4,65.73 v1(107.78,66.11) ; U50.A8 69.73,69.73 69.41,70.05 69.41,70.05 v1(69.33,70.13) ; v1(88.2,69.33) 88.16,69.33 U51.B2 ; v1(75.86,70.26) 75.84,70.26 75.36,69.78 U50.A1 ; v1(83.38,65.31) U51.G7 ; v1(114.72,70.21) 114.72,69.97 U53.A8 ; v1(120.16,64.56) 120.13,64.52 120.13,64.51 119.77,64.15 U53.H2 ; U45.AR48 115.64,110.23 v1(115.55,110.23) ; v1(108.4,57.31) 108.4,57.49 U30.R9 ; v1(115.03,106.39) 114.91,106.39 114.45,106.85 114.45,107.37 U45.AY50 ; U45.AP43 118.76,111.21 v1(118.44,110.88) ; v1(120.99,66.11) 120.61,65.73 U53.F1 ; v1(122.45,115.02) U45.AJ37 ; v1(82.54,70.26) 82.54,70.18 82.96,69.75 U51.A8 ; U28.R9 75.83,58.53 76.41,57.95 v1(76.41,57.31) ; v1(115.36,65.31) 115.74,64.93 U53.G7 ; U53.H9 114.19,64.13 v1(114.58,63.74) ; v1(120.99,67.71) U31.C9 ; v1(75.78,66.11) 75.4,65.73 U50.F1 ; v1(81.43,68.41) 81.71,68.13 U29.C1 U51.D9 U51.E9 82.14,66.53 v1(81.75,66.14) ; U30.N9 107.37,60.13 v1(107.76,59.74) ; v1(88.18,67.74) U51.D2 ; v1(102.17,65.32) U52.G7 ; U52.A8 101.59,69.9 101.59,70.13 101.53,70.19 v1(101.53,70.72) ; U29.N1 81.96,59.93 81.37,59.93 v1(81.11,60.18) ; v1(113.43,68.61) 113.91,68.13 U31.C1 U53.D9 U53.E9 v1(113.74,66.1) ; U45.AN33 124.84,111.6 v1(124.66,111.6) ; U31.R9 121.37,57.73 v1(121.37,57.2) ; v1(69.36,63.73) 68.96,64.13 U50.H9 ; U28.N9 75.45,60.03 76.13,60.03 v1(76.65,59.51) ; U52.H9 99.69,64.13 v1(99.53,64.3) ; U53.A1 120.97,70.13 v1(121,70.13) ; v1(120.95,59.74) 120.57,60.12 U31.N9 ; v1(81.75,58.86) 82.08,58.53 U29.R1 ; U45.AY44 117.68,106.92 v1(118.21,106.39) ; v1(107.79,70.13) 107.76,70.13 U52.A1 ; v1(68.52,57.28) 68.52,58.07 68.96,58.5 U28.R1 ; v1(74.97,67.74) U50.D2 ; U51.H9 82.18,64.13 v1(82.57,63.74) ; v1(113.14,60.49) 113.14,60.41 113.55,60 114.04,60 U31.N1 ; U29.R9 89.11,58.53 v1(89.62,58.02) ; v1(107.78,67.71) U30.C9 ; v1(106.98,67.74) U52.D2 ; U29.C9 v1(88.99,67.71) ; v1(126.33,115.02) 126.35,114.99 U45.AJ31 ; v1(100.22,68.41) 100.5,68.13 U30.C1 U52.D9 U52.E9 100.93,66.53 v1(100.53,66.13) ; U28.C9 v1(75.78,67.71) ; v1(74.94,69.31) U50.B2 ; v1(120.17,68.53) U53.B2 ; U31.R1 v1(113.78,58.91) ; v1(125.05,115.02) U45.AJ33 ; v1(106.97,69.34) U52.B2
  BOTTOM w0.33: v1(128.18,85.27) JDIM1.99
  BOTTOM w0.356: U45.AH26 129.3,114.79 128.81,115.27 v1(128.56,115.27)
  BOTTOM w0.457: v1(77.15,54.97) 77.35,54.77 C733.1 ; C755.1 v1(89.94,54.8) ; C727.1 123.79,55.85 122.64,57.01 v1(122.64,57.26) ; v1(123.91,57.38) C723.1 ; v1(121,70.13) 121.58,70.13 121.63,70.09 123.66,70.09 123.91,69.83 C704.1 ; C708.1 122.76,68.55 121.91,67.71 v1(120.99,67.71) ; v1(88.6,54.8) 88.6,54.77 88.54,54.71 C754.1 ; v1(120.99,66.91) 122.76,66.91 122.88,67.03 C712.1 ; v1(69.33,70.13) 72.22,73.02 C694.1 ; C696.1 74.57,70.69 v1(75.04,70.21) ; v1(87.21,54.95) 87.21,54.85 87.27,54.79 C747.1 ; C698.1 88.28,71.61 88.04,71.38 v1(88.04,70.21) ; C695.1 73.43,71.55 v1(72.6,70.72) ; C746.1 86.22,54.21 v1(86.6,54.59) ; 67.14,52.05 v1(67.14,52.43) ; C697.1 76.6,71 v1(75.86,70.26) ; v1(122.77,63.1) 123.54,62.33 C718.1 ; C715.1 123.16,65.38 122.43,66.11 v1(120.99,66.11) ; v1(90.76,54.8) 91.21,54.35 C748.1 ; C734.1 v1(92.72,53.4) ; C745.1 C744.1 82.26,54.21 C738.1 81.78,54.69 v1(81.78,54.97) ; v1(76.03,55.1) 76.03,54.85 75.71,54.53 C756.2
  BOTTOM w0.508: C713.1 65.36,66.66 65.72,66.3 v1(65.87,66.3) ; C719.1 124.41,60.81 123.73,60.13 v1(121.83,60.13) ; v1(65.87,67.94) 65.74,67.8 C709.1 ; C703.1 65.51,70.21 v1(65.77,70.47) ; 66.63,51.77 65.35,51.77 C764.1 ; v1(66,72.88) 65.53,72.41 C700.1 ; C702.1 65.5,71.35 65.63,71.22 v1(66.12,71.22) ; v1(113.12,55.1) 113.88,54.34 C742.1 ; C736.1 v1(65.87,55.1) ; v1(68.53,66.1) 67.78,65.35 67.78,63.56 v1(67.95,63.38) ; C720.1 124.05,59.28 123.91,59.42 121.27,59.42 v1(120.95,59.74) ; v1(89.74,62.45) 89.74,63.81 v1(89.75,63.81) 90.69,63.81 v1(91.65,62.85) ; v1(96.8,53.52) C735.1 ; v1(77.05,64.63) 77.05,63.1 v1(76.67,62.72) ; C728.1 C734.1 ; C705.2 65.36,69.07 v1(65.74,68.69)
  vias: v1(62.95,65.9) v1(63.28,72.27) v1(63.25,71.66) v1(67.14,54.97) v1(91.14,69.45) v1(91.14,68.18) v1(91.14,66.79) v1(91.14,65.39) v1(98.13,54.85) v1(98.76,54.85) v1(99.4,54.85) v1(100.16,54.72) v1(101.18,54.82) v1(102.19,54.85) v1(106.89,55.1) v1(107.53,55.1) v1(108.37,55.1) v1(109.05,55.1) v1(109.18,96.5) v1(112.1,55.1) v1(119.21,115.68) v1(119.72,54.82) v1(120.05,70.21) v1(121.18,54.82) v1(121.81,54.82) v1(122.44,54.82) v1(124.67,85.89) v1(133.44,96.63) v1(137.88,72.75) v1(137.88,71.99) v1(137.88,71.23) v1(137.88,70.47) v1(137.88,69.71) v1(138.52,72.75) v1(138.52,71.99) v1(138.52,71.23) v1(138.52,70.47) v1(138.52,69.71) v1(139.15,72.75) v1(139.15,71.99) v1(139.15,71.23) v1(139.15,70.47) v1(139.79,71.99) v1(139.79,71.23) v1(150.66,50.17) v1(151.27,50.17) v1(151.9,50.2) v2(73.24,88.63) v2(73.29,87.84) v2(74,88.63) v2(74.02,87.82) v2(74.81,88.96) v2(74.81,88.22) v2(75.22,91.25) v2(75.23,90.48) v2(75.22,89.75) v2(75.52,88.93) v2(164.6,62.54) v2(164.63,61.48) v2(164.68,60.56) v2(164.68,59.55) v2(164.68,58.4) v2(164.68,57.26) v2(164.68,56.24) v2(164.68,55.1) v2(165.41,62.59) v2(165.41,61.53) v2(165.59,60.59) v2(165.59,59.57) v2(165.67,58.45) v2(165.64,57.29) v2(165.72,56.3) v2(165.69,55.1) v2(165.69,53.96) v2(166.33,59.17) v2(166.33,57.77)
