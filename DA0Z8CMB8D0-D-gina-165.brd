# Allegro board DA0Z8CMB8D0-D-gina-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AGND_DDR: length 9.9
  TOP w0.14: PR113.1 198.38,50.07 v1(198.21,49.89)
  TOP w0.208: PU6.7 v1(198.1,58.18)
  TOP w0.381: PR99.2 197.45,60.11 ; 197.45,60.11 197.45,60.27 197.16,60.56 196.21,60.56 PC69.2 ; 197.45,60.11 197.82,60.49 v1(198.23,60.49) 198.59,60.49 198.76,60.31 PC67.2 PC68.2 ; PR113.1 198.21,50.93 v1(197.82,51.32) 197.46,50.95 PR112.1
GND: length 1866.1
  TOP w0.14: v1(157.97,81.77) 156.88,81.77 v1(156.73,81.62)
  TOP w0.203: U32.1 139,66.13 v1(138.9,66.02) ; v1(121.4,64.3) 120.81,63.71 120.15,63.71 U31.J8 ; v1(230.77,41.17) 230.82,41.12 U34.4 ; v1(144.53,69.25) 144.24,68.95 U32.122 ; v1(196.43,57.72) 196.9,57.25 PU6.10 ; v1(147.41,66.53) 147.84,66.97 U32.113 ; v1(148.04,50.91) 148.24,51.11 U32.49 ; v1(141.41,56.47) 141.41,56.09 141.05,55.73 U32.27 ; U32.91 v1(154.73,64.13)
  TOP w0.208: PU6.4 199.67,55.81 v1(200.11,56.24)
  TOP w0.229: U31.J2 114.84,63.33 114.44,62.93 114,62.93 113.73,63.2 v1(113.73,63.8) ; v1(69.15,57.21) 69.15,57.54 U28.T1 ; v1(89.09,63.61) 88.98,63.72 88.16,63.72 U29.J8
  TOP w0.254: PQ13.1 46.52,77.88 46.9,77.5 v1(46.9,77.43) ; PC58.1 54.08,62.84 v1(54.16,62.75) ; v1(68.69,137.94) 68.66,137.91 67.97,137.91 U13.M1 ; v1(68.69,137.94) v1(68.69,137.32) ; v1(68.69,137.94) 69.1,138.35 U13.P1 ; U12.M9 46.32,155.8 45.7,156.42 v1(45.7,156.71) ; U10.3 129.51,156.46 v1(128.96,157.01) ; PU3.22 53.66,76.42 v2(53.11,75.87) ; U12.P1 53.27,157.5 53.66,157.88 54.24,157.88 54.49,157.63 v1(54.49,157.45) ; PQ13.4 44.15,79.45 v1(44.15,79.74) ; PC38.1 52.74,79.95 v1(52.84,80.04)
  TOP w0.279: 99.02,94.34 99.02,93.84 99.26,93.6 U23.3 ; U20.3 159.39,108.69 158.81,108.11 158.81,107.6 v1(157.92,106.71) ; Q18.1 63.33,105.14 63.65,105.46 v1(63.65,105.58) ; U27.3 133.35,63.62 133.59,63.38 134.45,63.38 v1(134.81,63.03) ; Q18.4 66.78,103.6 v1(67.65,102.73) ; U15.3 v1(82.11,132.3)
  TOP w0.3: U16.B3 60.31,128.86 v1(60.31,129.07)
  TOP w0.305: U26.3 231.46,65.66 v1(231.61,65.52) ; v1(102.17,63.76) 101.76,63.35 U30.J2 ; v1(82.16,57.18) U29.T1 ; v1(61.99,137.61) 61.93,137.66 U13.E1 61.93,138.37 v1(61.53,138.78) ; U30.D3 102.56,67.23 v1(103.06,66.74) ; v1(65.54,127.66) 65.16,127.28 U16.J2 65.11,127.28 v1(64.73,126.9) ; U16.G9 63.51,132.88 63,133.38 ; U28.P1 68.75,59.54 v1(68.44,59.54) ; U28.G8 74.6,64.93 v1(74.98,65.31) U28.G9 ; U13.D8 61.13,143.99 v1(61.51,144.37) U13.E8 ; v1(102.04,100.64) 102.04,97.75 99.02,94.73 99.02,94.34 ; v1(80.88,69) 80.96,68.93 U29.B1 ; U11.T9 34.44,159 v1(34.4,159.05) ; v1(107.79,57.3) 107.37,57.73 U30.T9 ; U13.B9 59.5,144.78 v1(59.5,145.4) 59.23,145.4 58.73,144.9 U13.A9 ; U31.A9 v1(121,69.3) ; v1(52.87,149.82) 53.25,150.2 U12.E1 ; v1(52.87,149.82) 53.27,149.41 U12.D1 ; v1(52.87,149.82) 52.48,150.2 U12.E2 ; v1(41.03,159.68) 41.4,159.31 U11.T1 ; U30.P9 107.36,59.34 106.97,59.73 v1(106.97,59.76) ; U28.T9 75.36,57.73 75.79,57.3 v1(75.78,57.3) ; U31.E8 v1(120.19,66.11) 120.19,66.11 U31.F9 120.57,65.68 v1(120.19,65.31) ; U16.E2 61.93,127.28 v1(61.52,126.86) ; U16.G8 U16.F9 62.8,132.88 63,133.09 63,133.38 ; U30.G1 100.51,64.93 v1(100.36,65.08) ; U31.G8 119.81,64.93 v1(120.19,65.31) ; v1(84.16,69.32) U29.B3 ; U28.M9 v1(75.74,60.54) ; v1(48.05,153.78) U12.J8 ; v1(63.53,125.91) U16.G1 ; U13.G8 63.16,144.32 v1(63.14,144.32) 62.73,144.73 U13.F9 ; v1(58.97,137.87) 59.05,137.87 U13.B1 ; v1(52.09,153.81) 52.47,153.43 U12.J2 ; U11.M9 34.47,155.8 v1(34.38,155.9) ; v1(61.52,126.86) 61.14,126.48 U16.D1 ; v1(61.52,126.86) 61.89,126.48 U16.E1 ; v1(107.79,69.3) U30.A9 ; v1(58.93,141.09) 58.93,140.56 59.53,139.96 U13.B3 ; U31.B1 113.96,69.13 v1(113.01,69.13) ; U22.3 37.36,101.68 v1(37.23,101.8) ; v1(84.26,66.74) 83.76,67.23 U29.D3 ; U30.B1 100.3,68.93 100.22,69 v1(99.68,69) ; v1(48.05,149.81) 47.67,149.43 U12.D8 ; U6.1 v1(97.59,159.64) ; U16.M9 67.53,133.52 v1(67.29,133.76) ; v1(64.74,143.56) U13.J8 ; U29.B9 89.04,68.46 v1(89.37,68.46) ; U30.M1 100.72,60.69 v1(100.44,60.69) ; U29.D1 81.94,67.33 v1(81.57,66.96) 81.57,66.94 81.85,66.66 82.03,66.66 U29.E1 ; U30.F9 v1(107.78,65.31) 107.4,64.93 U30.G9 v1(106.98,65.31) 106.6,64.93 U30.G8 ; U29.E2 82.98,66.53 v1(83.36,66.15) ; U29.G8 87.81,64.93 v1(88.19,65.31) U29.G9 ; U28.A9 v1(75.79,69.3) ; U13.D1 61.13,138.39 v1(61.53,138.78) ; v1(116.26,66.74) 115.77,67.23 U31.D3 ; v1(108.17,68.46) 107.83,68.46 U30.B9 ; U28.B9 v1(75.83,68.46) ; U28.E2 v1(70.14,66.14) ; U12.G8 47.71,151.8 v1(48.11,151.41) ; v1(67.77,68.93) U28.B1 ; U29.P9 88.56,59.34 v1(88.17,59.73) ; v1(69.35,145.63) 69.13,145.41 U13.P9 ; U29.M9 v1(89.06,60.43) ; U13.G1 63.53,137.7 v1(63.59,137.64) ; U28.D1 68.68,67.33 v1(68.29,66.94) 68.55,66.68 68.81,66.68 U28.E1 ; U16.T9 70.73,132.88 71.16,132.88 71.31,132.73 v1(71.41,132.73) ; v1(32.6,87.23) 32.22,87.23 31.71,87.74 31.71,88.05 31.25,88.51 PR45.2 ; U16.J8 65.15,132.08 v1(65.56,131.68) ; v1(88.19,66.91) U29.D8 ; v1(112.98,58.91) U31.T1 ; U16.T1 v1(70.73,125.81) ; U24.24 210.53,86.21 210.4,86.34 v1(210.14,86.34) ; v1(120.19,66.91) U31.D8 ; v1(69.13,125.88) U16.P1 ; U31.E7 118.97,66.55 v1(119.35,66.92) ; v1(68.41,65.03) 68.52,64.93 U28.G1 ; v1(87.34,66.92) 86.96,66.55 U29.E7 ; v1(70.14,63.74) 70.14,63.71 U28.J2 ; U31.M1 v1(113.77,60.53) ; v1(34.43,157.4) U11.P9 ; v1(63,133.48) 63,133.38 ; U11.A9 34.94,147 v1(34.53,147.41) 34.92,147.8 U11.B9 ; U30.D1 100.6,67.33 v1(100.24,66.96) 100.42,66.79 100.7,66.79 U30.E1 ; v1(88.38,57.22) 88.56,57.41 U29.T9 ; U16.P9 68.74,133.27 v1(68.74,133.26) ; v1(106.14,66.92) 105.76,66.55 U30.E7 ; v1(52.88,148.19) 53.26,147.8 U12.B1 ; v1(83.37,63.74) U29.J2 ; U31.D1 113.89,67.33 v1(113.5,66.94) 113.76,66.94 U31.E1 ; v1(70.39,137.86) 70.73,138.2 U13.T1 ; v1(59.09,125.9) 59.53,126.34 U16.B1 ; v1(36.22,149.82) 35.8,149.4 U11.D8 v1(35.38,149.82) ; U29.F9 v1(88.99,65.31) ; U13.G9 63.53,144.73 v1(63.93,144.33) ; v1(99.73,58.61) 100.61,57.73 U30.T1 ; U31.M9 121.11,60.39 v1(121.11,60.33) ; U5.1 v1(97.59,162.56) ; v1(116.16,69.32) U31.B3 ; U29.A9 v1(88.99,69.3) ; v1(120.19,65.31) U31.G9 ; U28.F9 v1(75.78,65.31) ; U30.J8 106.15,63.74 v1(106.13,63.74) ; U30.P1 v1(101.36,58.93) ; U21.3 41.2,105.93 42.35,105.93 v1(42.38,105.9) ; U28.P9 75.36,59.34 75.72,59.34 v1(75.9,59.52) ; v1(107.76,60.53) U30.M9 ; v1(47.26,149.82) 47.44,150 47.47,150 U12.E8 U12.F9 ; v1(61.53,138.78) 61.9,139.15 U13.E2 ; U31.E2 v1(115.36,66.14) ; U12.G1 53.24,151.8 v1(52.84,151.4) ; U29.M1 v1(81.76,60.53) ; U31.P1 114.17,59.33 v1(114.57,58.93) ; v1(74.13,66.92) 73.76,66.55 U28.E7 ; v1(40.21,153.81) 40.6,153.42 U11.J2 ; U30.E2 v1(102.15,66.14) ; v1(41,157.8) U11.P1 ; U29.G1 v1(81.59,64.93) ; v1(106.98,66.91) U30.D8 ; U5.3 v1(97.59,161.26) ; U29.P1 v1(82.56,58.93) ; v1(70.98,69.35) U28.B3 ; v1(71.08,66.71) 70.56,67.23 U28.D3 ; U31.P9 120.17,59.73 v1(120.17,59.75) ; U31.T9 120.74,57.56 v1(120.74,57.2) ; U11.M1 41.74,156.15 41.97,156.71 v1(41.97,157.01) ; v1(65.53,139.51) 65.18,139.15 U13.J2 ; v1(102.96,69.32) U30.B3 ; U31.B9 v1(121.04,68.46) ; v1(74.98,66.11) U28.E8 ; U31.G1 113.75,64.93 v1(113.64,65.03) ; v1(106.98,66.11) U30.E8 ; v1(74.97,63.74) U28.J8 ; U24.32 210.97,82.21 210.72,81.97 v1(210.72,81.62) ; v1(74.98,66.91) U28.D8 ; v1(88.19,66.11) U29.E8 ; U6.3 v1(97.59,158.34) ; v1(68.54,60.52) U28.M1
  TOP w0.381: C50.1 155.28,154.53 v1(155.28,154.42) ; C29.1 v1(106.27,162.28) ; U11.G8 U11.F9 35,151 v1(35.39,150.61) 35.8,150.2 U11.E8 ; R38.1 61.25,156.32 61.17,156.4 61.17,156.68 61.02,156.83 v1(61.02,157.46) ; U2.3 v1(106.38,164.88) ; v1(58.38,156.32) 58.01,156.69 R34.2 ; v2(10.5,140.8) 10.11,140.41 PR25.2 ; U11.G9 v1(34.38,151.8) ; v1(224.49,84.06) 224.37,84.18 C314.1 ; PC59.2 v1(32.63,63.92) ; PC49.1 53.83,69.17 53.77,69.24 v1(53.56,69.24) 53.56,68.72 53.72,68.56 53.72,67.92 PC53.1 ; R323.2 140.16,69.94 v1(139.91,70.19) ; R48.1 58.82,154.53 58.04,153.75 R47.1 57.74,153.7 57.74,153.03 v1(57.72,153) ; C193.2 154.65,123.3 154.42,123.54 154.42,123.68 v1(154.39,123.71) ; v2(10.7,144.76) 10.82,144.88 R66.1 ; v1(50.91,148.56) U12.B3 ; v1(40.94,123.68) 40.51,124.1 C168.1 ; C266.1 160.74,104.95 160.27,104.48 v1(159.6,104.48) ; 61.07,100.43 C281.1 C280.1 60,100.46 59.04,100.46 C279.1 ; 61.07,100.43 61.55,99.95 v1(61.55,99.81) ; 61.07,100.43 C282.1 C283.1 ; 137.83,116.57 138.13,116.87 C239.2 138.13,117.48 v1(138.52,117.87) 138.25,118.13 C231.2 C225.1 ; 137.83,116.57 v1(137.85,116.57) ; 137.83,116.57 138,116.4 C249.1 138,115.71 138.25,115.45 C255.2 ; R304.1 63.9,74.37 v1(63.74,74.53) ; v1(53.86,159) U12.T1 ; U12.G9 46.3,151.8 v1(46.25,151.86) ; v1(53.8,155.62) 53.45,155.62 U12.M1 ; v1(141.69,106.56) 141.38,106.56 140.67,105.85 R207.2 ; v1(58.76,61.93) 58.04,61.21 PQ21.1 ; v1(60.41,163.31) 60.08,162.98 60.08,161.1 R5.1 ; C438.2 61.43,53.41 v1(61.43,53.32) ; v1(178.65,47.67) 178.58,47.67 178.26,47.35 PR119.2 ; C467.2 68.28,51.79 68.69,52.21 v1(68.69,52.43) ; v1(35.42,152.98) 35.8,153.36 U11.J8 ; v1(149.69,100.82) 149.69,100.97 149.22,101.45 R227.2 ; v1(65.64,99.81) 65.64,100.19 65.4,100.43 C285.1 C284.1 64.07,100.46 63.1,100.46 C283.1 ; v1(60.03,60.05) 60.41,59.67 C414.2 ; C140.1 42.27,132.09 v1(42.48,132.29) ; C30.1 108.3,161.76 107.93,162.12 v1(107.93,162.32) ; PC85.1 132.63,40.43 132.17,39.96 v1(132.17,39.91) ; v1(60.51,75.78) 60.72,75.57 PR64.2 ; PC62.2 v1(32.63,62.72) ; R13.2 107.27,158.61 v1(106.89,158.99) ; C40.1 v1(106.89,159.62) ; C279.1 C278.1 57.73,100.43 57.49,100.19 v1(57.49,100.01) ; C279.1 59.04,100.43 59.5,99.97 v1(59.5,99.8) ; v1(55.53,153.3) 56.01,153.77 R46.2 ; U3.3 v1(110.96,164.96) ; U13.T9 70.84,144.75 v1(71.3,145.21) ; C46.1 56.03,155.91 v1(54.49,157.45) ; PC81.2 132.94,50.11 132.68,50.37 v1(132.1,50.37) ; C39.1 R12.2 105.49,158.43 v1(105.11,158.05) ; C283.1 63.13,100.43 63.59,99.97 v1(63.59,99.83) ; R118.2 R120.2 v1(149.69,122.79) ; C42.2 C45.2 58.05,157.83 v1(58.35,158.13) ; C79.1 74.56,147.79 v1(75.07,148.3) ; PC47.2 52.69,70.12 52.48,69.9 v1(51.89,69.9) ; PC63.2 49.42,62.56 v1(49.78,62.92) ; v1(179.48,47.67) 179.48,46.92 PQ25.1 ; C372.2 148.29,71.76 147.63,72.42 v1(147.63,72.75) ; v1(69.35,145.63) 69.22,145.77 C76.2 ; v1(67.53,125.95) U16.M1 ; C49.1 153.48,154.94 v1(153.48,154.39) ; v1(51.32,66.76) 51.49,66.58 PC55.2
  TOP w0.4: v1(38.53,147.33) 39.33,147.33 U11.B3 ; U13.M9 67.53,145.29 v1(67.41,145.41)
  TOP w0.406: R312.2 C371.2 144.87,71.87 v1(144.87,71.99) ; C205.2 135.15,122.53 135.59,122.97 v1(135.59,123.07)
  TOP w0.457: v1(126.07,66.14) 125.94,66.14 125.7,65.9 C393.2 ; v1(16.98,150.73) 17.23,150.48 C70.2 ; v1(126.96,56.32) 126.87,56.24 C425.1 ; v1(84.02,156.98) 83.65,157.35 C44.2 ; v1(142.99,98.82) 142.71,99.09 C290.1 R233.1 ; C192.1 89.03,123.5 v1(89.37,123.83) ; v1(132.99,114.41) 133.3,114.72 C253.2 ; v1(134.19,60.56) C409.1 ; C233.1 148.89,118.14 v1(149.69,118.14) ; v1(151.88,119.95) 152.78,119.95 153.13,119.61 R140.2 ; C96.1 146.39,141.08 146.44,141.13 v1(147.18,141.13) ; v1(59.78,57.13) 59.78,57.14 C423.2 ; v1(125.92,63.43) 125.48,63.86 C401.2 ; v1(136.53,116.66) 136.53,115.99 C252.2 C251.1 135.62,116.12 v1(135.62,116.71) ; C375.2 125.62,70.21 126.03,69.81 v1(126.03,69.78) ; C178.2 134.19,123.23 134.27,123.14 v1(134.27,123.07) ; v1(95.46,62.85) 95.91,63.29 C404.2 ; R37.2 83.3,155.07 v1(83.3,154.67) ; v1(125.05,53.96) 125.38,54.28 C432.2 ; C403.2 93.44,63.36 v1(92.97,62.9) 93.31,62.56 R342.1 ; C288.1 C289.1 v1(141.44,98.92) ; R101.2 147.66,127.87 147.1,127.31 145.83,127.31 145.31,126.79 145.03,126.79 143.72,125.49 v1(143.19,125.49) ; C254.2 131.4,114.92 131.52,115.04 C250.2 132.04,114.67 v1(132.33,114.38) ; C410.2 v1(135.72,61.2) ; v1(144.15,101) 143.72,101.43 R225.1 ; v1(125.99,62.11) 125.54,61.66 R343.1 ; C43.2 82.74,157.73 v1(82.74,156.8) ; R153.2 93.55,116.43 v1(93.79,116.19) ; v1(64.45,65.06) 64.64,64.87 C396.2 ; v1(131.12,117.48) 131.54,117.07 C236.2 ; C384.2 125.56,67.93 125.82,67.67 v1(126.06,67.67) ; v1(126.19,58.53) 126.06,58.66 C415.2 125.49,58.8 124.71,59.58 C412.2 ; v1(126.21,57.61) 126.12,57.51 125.52,57.51 C421.2 ; v1(84.79,154.64) RV1.2
  TOP w0.508: C212.2 138.35,121.5 137.83,121.5 v1(137.78,121.55) ; C14.1 v1(99.39,164.7) ; v1(204.89,42.61) 204.71,42.43 PQ29.1 204.89,41.38 PC84.1 ; R379.1 137.38,52.82 v1(137.88,53.32) ; C211.1 128.58,121.35 v1(127.67,121.35) ; v1(27.28,124.43) R116.2 C190.2 ; v1(119.64,104.53) 120.18,104 C269.1 ; v1(68.54,107.58) 68.54,107.53 R194.1 67.27,107.53 v1(67.27,107.58) ; C390.1 62.82,66.53 v1(62.32,67.04) 62.32,66.56 61.92,66.16 C394.2 ; C514.2 234.9,26.92 v1(234.53,27.29) ; R335.2 131.11,62.26 R341.2 132.41,62.07 133.18,61.3 133.69,61.3 133.79,61.2 C409.1 ; v1(16.34,115.73) 16.21,115.6 16.21,115.56 15.95,115.3 PR35.1 ; v1(145.27,98.79) 145.27,98.71 143.06,96.5 141.56,96.5 141.05,95.99 C292.1 ; C317.2 134.93,82.88 134.93,81.92 135.36,81.5 v1(135.55,81.5) ; D6.2 v1(234.65,94.48) ; C362.1 105.38,73.75 105.42,73.79 v1(105.42,74.15) ; Q34.1 v1(152.71,41.74) ; v1(233.35,86.56) 233.89,87.1 D9.2 ; C496.2 241.77,42.55 v1(241.77,43.11) ; v1(54.24,59.17) 54.24,58.15 54.63,57.76 R357.1 ; SW1.3 160.68,40.81 v1(161.38,40.12) ; C173.1 137.11,123.19 C194.2 136.36,123.18 v1(136.23,123.05) ; C100.1 v1(141.84,138.59) ; v1(150.71,138.82) 151.09,138.44 U14.4 ; v1(118.17,105.39) 118.8,104.76 C268.1 ; v1(107.15,147.68) 107.39,147.93 C75.2 ; C9.1 147.4,165.33 147.15,165.08 v1(146.77,165.08) ; R367.1 v1(135.21,53.7) ; v1(225.1,40.55) 225.69,41.13 C497.2 ; R198.2 158.63,106 v1(157.92,106.71) 157.64,106.71 156.93,107.43 C260.1 ; v1(128.43,117.89) 128.43,117.41 C241.1 ; v1(131.12,145.14) 130.62,145.65 C82.1 ; v1(157.97,81.77) 158.34,82.14 R284.2 ; v1(205.32,54.97) 205.32,55.08 204.96,55.43 PC71.1 ; v1(141.83,137.97) 141.47,137.97 141,137.5 C104.1 ; v1(63.01,50.96) 63.36,50.61 65.29,50.61 65.88,50.01 C476.1 C481.1 67.57,48.24 Q31.1 ; R93.2 v1(157.95,131.42) ; C517.2 236.18,5.95 v1(235.8,5.57) ; R143.2 90.97,119.11 v1(90.89,119.19) ; C473.2 v1(229.96,52.18) ; v1(57.24,101.83) C277.1 C274.2 ; C512.2 v1(228.18,28.05) ; C355.2 123.66,77.2 124.41,77.95 v1(124.63,77.95) ; PC64.1 195.15,61.44 v1(194.27,60.56) ; C313.2 156.96,85.38 v1(156.98,85.4) ; R18.1 v1(66.94,159.5) ; C381.1 166.32,68.95 v1(166.58,68.69) ; C63.2 v1(19.43,151.37) ; v1(131.17,122.97) 132.03,123.83 C175.1 C165.2 ; v1(90.89,121.54) 91,121.65 R126.2 ; C492.2 v1(156.8,43.67) ; Q24.1 155.66,89.01 v1(155.91,89.26) ; v1(158.58,125.97) 158.58,125.67 C176.1 160.06,124.19 v1(160.36,124.19) ; v1(16.98,144.64) 17.11,144.5 C85.2 ; C36.2 111.7,160.28 v1(111.9,160.28) ; R197.1 v1(36.28,105.77) ; R129.1 97.49,121.14 v1(96.58,121.14) ; C163.2 v1(244.66,125.71) ; v1(232.88,13.09) 234.42,13.09 R427.2 ; PQ11.4 31.98,84.33 31.15,83.5 31.15,82.66 31.54,82.27 v1(31.96,82.27) 32.09,82.14 C326.1 ; C398.2 125.56,64.88 v1(126.06,65.38) ; v1(35.09,122.87) 34.65,123.3 C187.2 ; C57.1 v1(24.08,152.63) ; v1(64.73,159.5) 64.65,159.42 R16.1 ; v1(153.5,117.59) C235.1 ; C385.2 v1(65.86,67.16) ; C294.1 213.32,93.97 v1(213.32,94.47) ; v1(202.52,42.61) 202.22,42.91 PR125.2 ; C416.2 137.9,58.27 v1(138.08,58.45) ; C356.2 126.32,76.67 126.07,76.92 126.07,77.45 126.57,77.95 v1(126.68,77.95) ; v1(134.34,44.14) 134.19,43.99 PC83.1 ; HOLE5.1 HOLE5.5 ; HOLE5.1 HOLE5.6 ; HOLE5.1 HOLE5.7 ; PC65.1 199.78,61.45 v1(200.03,61.71) ; C263.2 v1(243.41,110.48) ; PQ19.1 177.58,68.26 v2(179.46,70.14) ; C296.1 v1(215.6,94.47) ; C2.1 v1(34.63,171.05) ; PQ16.1 v1(177.53,72.2) ; v1(126.07,68.31) 126.17,68.31 126.93,69.07 C382.1 ; v1(61.81,164.45) 61.56,164.69 C11.1 ; C336.1 218.9,78.48 v1(218.5,78.88) ; v1(64.86,52.94) 64.97,52.94 64.99,52.97 64.99,53.2 64.86,53.32 C439.1 R366.1 ; v1(206.97,81.98) 207.12,82.13 207.12,82.17 C323.1 C324.2 ; v1(102.83,159.88) 103.2,159.88 C38.1 ; C339.2 138.66,77.94 v1(138.68,77.95) ; PQ8.1 32.5,109.08 v1(32.47,109.1) ; v1(45.55,109.2) 45.55,109.21 R179.1 ; C342.1 222.96,77.2 v1(222.46,77.2) ; C474.1 v1(85.68,50.78) ; R161.1 58.39,116.58 58.38,116.57 v1(58.38,116.32) ; v1(131.91,138.79) 132.16,138.55 C103.1 ; C363.1 124.51,73.24 124.85,73.59 v1(124.85,73.58) ; C491.2 241.39,44.18 v1(241.77,44.18) ; v1(105.75,154.03) 105.75,154.66 C53.1 C54.1 ; v1(183.63,50.73) 183.04,51.32 PR109.2 ; PQ3.1 20.91,137.91 v1(21.29,138.29) ; PC52.2 200.03,68.56 v1(201.71,68.56) ; v1(126.56,81.51) 126.69,81.51 127.21,82.03 C316.1 ; PR103.1 32.72,59.1 32.72,59.09 v1(32.63,59.09) ; v1(142.2,72.25) 142.2,72.21 141.82,71.83 C369.2 ; v1(110.32,146.03) 110.04,146.03 C80.2 ; C256.1 v1(13.17,115.43) ; v1(79.01,48.7) 78.47,48.7 77.28,47.51 C485.1 ; v1(138.53,122.78) 139.18,122.78 C191.1 ; R417.2 234.53,28.82 v1(234.53,28.51) ; C498.1 228.55,41.5 228.89,41.84 v1(228.89,41.94) ; PC44.1 57.47,69.82 v1(56.71,69.05) ; C156.2 82.37,127.61 v1(82.64,127.87) ; C472.2 v1(228.94,52.18) ; R327.1 62.81,67.67 v1(62.29,67.67) ; C287.1 44.82,100.18 v1(44.66,100.34) ; v1(145.98,144.21) 145.98,143.4 C87.1 146.62,143.47 v1(146.62,144.21) ; v1(132.11,77.93) 132,77.93 131.4,77.33 C350.1 ; R152.1 96.22,117.47 v1(97.37,116.32) ; C364.2 91.58,73.14 92.04,72.67 v1(92.04,72.51) ; R396.2 v1(241.77,44.81) ; U18.2 v1(11.26,116.72) ; C7.1 147.4,167.36 v1(147.66,167.62) ; v1(123.28,156.7) 123.28,156.71 C47.1 ; v1(149.56,133.38) 149.57,133.38 149.57,133.46 R89.2 ; v1(103.97,154.03) 104.72,154.79 C52.1 ; R400.1 156.52,42.4 v1(156.78,42.66) ; C161.2 v1(47.46,125.33) 47.19,125.07 C171.2 ; v1(130.01,82.15) 129.63,82.53 C319.1 ; v1(234.53,73.64) 234.41,73.76 D11.2 ; v1(226.4,91.3) 227.04,91.94 C302.2 ; PR70.1 48.11,73.77 48.07,73.72 v2(48.07,73.75) ; D8.2 234.41,89.91 v1(234.52,90.02) ; 223.87,85.59 224.53,85.59 224.7,85.76 v1(224.7,86.42) ; 223.87,85.59 C309.1 ; 223.87,85.59 C311.1 ; PU10.18 134.93,45.1 136.2,43.82 PQ28.1 ; v1(157.69,78.14) 157.56,78 C345.2 ; v1(223.1,75.04) 222.74,75.4 C352.1 222.74,76.29 v1(222.46,76.56) ; C499.2 225.79,39.13 v1(226.02,39.35) ; C293.1 219.54,94.57 v1(219.54,95.49) ; PD4.2 30.01,66.3 v1(29.65,65.94) ; v1(151.98,72.27) 151.6,72.27 150.96,71.64 R314.2 ; C391.1 165.82,65.77 v1(165.57,65.52) ; v1(74.13,154.92) 74.75,154.92 R40.1 ; v1(157.72,126.83) 157.23,126.34 C157.2 ; C273.1 v1(157.44,102.98) ; Y1.4 224.5,94.98 223.73,94.98 v1(223.61,94.85) ; 208.37,44.81 207.22,44.81 v1(207.25,44.84) ; C516.2 232.95,16.49 v1(232.9,16.44) ; R149.1 58.39,118.72 v1(58.12,118.98) ; Q16.1 62.42,107.96 v1(62.44,107.93) ; v1(20.91,143.87) 20.68,144.1 Q7.1 ; v1(106.77,149.46) 106.5,149.73 C72.2 ; R125.2 88.48,121.65 v1(88.35,121.52) ; C348.1 122.13,76.95 121.83,77.25 121.83,77.78 122.23,78.19 v1(122.46,78.19) ; R177.1 v1(38.69,110.6) ; C471.2 v1(232.5,52.82) ; C484.2 231.23,47.74 v1(231.73,47.23) ; C6.1 v1(61.55,171.05) ; C495.2 229.04,43.83 v1(229.04,44.69) ; R290.2 v1(213.06,77.58) ; D12.2 234.41,72 v1(234.53,72.12) ; C41.1 101.94,158.98 v1(101.31,158.98) ; C329.1 224.37,81.9 v1(224.49,82.03) 225.1,82.03 C325.1 ; PQ26.1 205.24,48.45 v1(205.7,48.9) ; C35.1 v1(113.62,160.13) ; R356.1 v1(159.85,58.4) ; v1(111.03,162.32) 111.35,162 C31.2 ; C3.1 v1(35.77,171.05) ; R247.2 220.94,94.73 v1(220.18,95.49) ; v1(234.53,92.03) 234.16,91.67 D7.2 ; C518.2 240.5,5.94 v1(241.13,5.32) ; v1(190.07,77.07) PC41.1 ; v1(28.93,109.1) 28.94,109.1 28.91,109.08 PQ7.1 ; PR36.2 27.39,105.13 v1(27.39,105.01) ; C74.1 90,148.57 v1(90.26,148.32) ; v1(184.49,46.85) 184.36,46.72 PC82.1 ; L19.1 160.18,55.8 160.18,55.56 v1(160.38,55.36) ; v1(135.85,61.83) 136.47,62.46 C407.2 ; C346.1 135.62,76.67 v1(135.09,77.2) ; v1(207.2,49.01) 207.58,48.62 PQ24.1 ; C276.1 112.69,102.44 112.69,105.57 112.63,106.22 112.43,106.42 v1(112.43,106.84) ; C393.2 C389.2 C384.2 ; v1(135.44,153.5) 135.44,153.04 PC5.1 136.1,152.94 v1(136.1,153.5) ; C335.1 v1(215.6,77.58) ; C77.2 v1(24.09,147.68) ; D10.2 v1(234.52,76.57) ; v1(90.92,120.3) 90.99,120.38 R136.2 ; PQ2.1 v1(14.69,140.47) ; v1(38.11,98.82) 37.5,98.82 PC24.1 ; PC72.1 v1(192.72,56.75) ; v1(229.83,45.12) 229.83,45.15 230.01,45.32 C489.2 ; v2(31.27,67.98) 30.56,68.69 PD3.2 ; C300.1 209.9,92.83 209.3,92.24 v1(209.3,91.83) ; C170.1 38.45,125.09 C160.2 ; v1(228.1,94.37) 227.4,93.67 Y1.2 ; C341.1 v1(218.8,76.21) ; C429.2 136.48,55.35 v1(136.48,56.12) ; v1(228.43,44.69) 228.43,44.33 228.18,44.08 C494.2 ; R414.2 233.38,30.34 v1(233.16,30.57) ; C320.1 132.44,82.25 133.19,81.51 v1(133.38,81.51) ; v1(26.76,105.04) 26.76,105.51 PC20.1 ; v1(18.25,122.92) 18.44,122.73 PC18.1 ; v1(233.26,46.72) 233.5,46.72 C487.2 ; v1(139.28,74.05) 139.28,74.08 139.29,74.08 C359.1 139.67,75.04 C357.2 ; C333.1 v1(206.46,79.1) ; D4.2 v1(236.18,143.87) ; v1(222.46,90.51) 222.02,90.07 222.02,89.96 221.96,89.91 C303.1 ; C71.2 103.34,149.84 v1(103.97,150.48) ; PC13.1 15.46,138.04 v1(15.45,138.03) 15.44,138.04 PR27.2 ; PC19.1 v1(26.51,116.44) ; PR38.2 30.57,105.06 v1(30.51,105.01) ; v1(12.15,133.71) 12.15,134.22 11.73,134.64 PC14.2 ; C297.1 217.51,93.72 217.01,94.22 v1(217.01,95.23) ; C229.2 136.22,119.41 136.09,119.53 v1(136.1,119.54) ; R413.2 v1(231.99,31.48) ; v1(144.1,166.36) C8.1 ; R11.2 102.93,159.13 102.94,159.13 v1(102.82,159.25) ; R412.1 v1(229.32,31.86) ; v1(137.73,120.56) 138.33,120.56 C216.2 ; C427.2 v1(241.89,56.5) ; C503.2 C502.2 228.43,37.07 227.54,36.18 v1(226.65,36.18) ; C406.2 62.05,63.86 v1(62.82,64.64) ; v1(124.58,82.27) 124.55,82.3 C315.2 ; R142.2 v1(88.3,119.11) ; v1(66.51,107.58) 66.35,107.43 R191.2 ; R216.2 42.88,102.08 v1(42.88,101.71) ; C5.1 v1(60.41,171.05) ; C351.2 133.31,76.34 133.89,76.92 133.89,77.5 133.44,77.95 v1(133.28,77.95) ; C275.1 v1(41.61,101.71) ; C402.2 v1(159.85,63.86) ; U19.2 v1(240.24,112.79) ; v1(209.64,78.33) C334.1 ; C397.2 136.47,64.5 v1(136.52,64.45) ; v1(78.6,52.43) 78.6,53.27 C451.2 C452.2 C453.2 ; C711.2 127.49,65.58 C716.2 ; C513.2 v1(232.24,28.05) ; 147.66,41.39 148.55,40.5 v2(148.55,40.07) ; C378.2 222.07,69.7 v1(221.57,69.2) ; PR63.2 199.05,75.57 v1(199.7,75.57) ; v1(243.93,53.07) 243.93,52.44 R381.1 ; PQ23.1 v1(179.16,52.41) ; Q5.1 v1(14.46,146.52) ; C4.1 v1(59.27,171.05) ; C34.1 112.73,160.63 v1(112.73,160.13) ; v1(61.81,160.51) 61.55,160.26 61.55,159.56 R9.1 ; R86.1 v1(149.69,136) ; R347.2 v1(159.85,60.56) ; C426.1 v1(240.62,57.26) ; v1(225.51,70.19) U25.9 v1(225.51,67.93) ; R272.1 95.84,91.3 96.61,90.53 100.67,90.53 103.6,93.46 C299.2 105.5,98.64 v1(106.89,100.03) ; v1(128.51,77.2) 127.85,76.54 C349.1 ; SW1.5 v1(164.55,45.16) ; R135.2 v1(88.38,120.38) ; C475.1 v1(86.83,50.78) ; D21.2 v1(228.18,27.03) ; v1(33.98,62.1) 33.98,62.9 PQ20.1 ; C286.2 52.34,100.5 v1(52.34,99.6) ; v1(125.92,154.57) 125.76,154.73 125.76,155.25 C51.2 ; C225.1 138.13,119.49 137.72,119.08 v1(137.7,119.08) ; C781.1 v1(232.88,15.22) ; PR32.1 20.41,117.95 20.15,118.21 v1(20.15,118.22) ; C61.2 106.13,150.86 v1(105.75,150.48) ; SW1.6 v1(162.05,40.16) ; D13.2 v1(233.27,69.19) ; Q1.1 v1(78.32,154.42) ; PC79.1 31.91,51.16 v1(31.2,51.16) ; v1(218.27,95.23) 218.27,94.98 218.65,94.6 C298.1 ; C238.2 135.97,117.31 135.62,116.96 v1(135.62,116.71) ; v1(33.92,52.99) 34.07,52.99 34.58,52.48 PC77.2 36.15,52.48 v1(36.66,51.98) ; v1(7.83,119.74) 7.71,119.63 C226.1 ; PC70.1 v1(210.78,59.93) ; C209.2 v1(8.09,123.05) ; C509.2 v1(230.34,31.86) ; R69.1 v1(24.08,143.36) ; v1(114.99,104.05) 114.99,103.39 115.5,102.88 C271.2 ; v1(226.53,62.82) 226.53,63.05 226.01,63.57 C400.2 ; PC12.1 v1(23.58,141.85) ; C102.1 26.89,138.03 v1(27.52,138.03) ; PC78.1 v2(47.81,53.3) ; PR68.1 v1(199.73,74.28) ; C483.2 235.03,48.13 v1(234.53,48.62) ; C301.2 223.91,92.25 v1(223.91,91.68) ; HOLE14.4 HOLE14.1 HOLE14.3 ; R287.2 v1(224.49,80.88) ; v1(10.75,142.73) 10.75,142.07 PQ1.1 ; D22.2 v1(232.24,27.03) ; C365.2 65.75,72.24 v1(66.13,71.87) ; C267.1 v1(36.28,104.5) ; C318.1 120.99,82.53 121.01,82.51 121.01,82.03 120.5,81.51 v1(120.38,81.51) ; v1(156.88,104.76) 156.88,105.45 C265.1 C264.1 ; C58.1 v1(91.02,152.38) ; C477.2 v1(231.33,49.87) ; v1(141.1,43.42) C493.2 ; v1(61.26,68.96) PQ18.1 ; C399.2 v1(159.85,64.88) ; C28.1 v1(104.86,161.65) ; C482.2 v1(233.77,49.77) ; C295.1 v1(214.08,94.47) ; R383.2 v1(235.42,50.91) ; C1.1 v1(33.49,171.05) ; U33.2 v1(241.51,54.06) ; Q6.1 v1(17.99,146.57) ; C33.1 v1(109.43,160.13) ; PQ6.1 v1(29.93,111.08) ; Q4.1 v1(20.91,147.03) ; C374.1 v1(65.87,69.48) ; Q29.1 v1(130.79,54.97)
  TOP w0.762: v2(180.17,62.21) 179.54,62.21 178.7,61.38 PC66.2 ; PC76.2 205.29,53.3 v2(204.76,52.77) ; PC51.2 179.74,69.86 v2(179.46,70.14)
  IN1 w0.508: HOLE13.7 HOLE13.1 ; HOLE13.1 HOLE13.8 ; HOLE13.1 HOLE13.9 ; HOLE5.6 HOLE5.1 ; HOLE5.1 HOLE5.5 ; HOLE5.1 HOLE5.7 ; HOLE9.1 HOLE9.2 ; HOLE7.1 HOLE7.2
  IN2 w0.508: HOLE13.1 HOLE13.8 ; HOLE13.1 HOLE13.7 ; HOLE13.1 HOLE13.9 ; HOLE5.1 HOLE5.5 ; HOLE5.1 HOLE5.6 ; HOLE5.1 HOLE5.7 ; HOLE7.1 HOLE7.2 ; HOLE9.1 HOLE9.2
  IN3 w0.508: HOLE9.1 HOLE9.2 ; HOLE5.1 HOLE5.5 ; HOLE5.1 HOLE5.7 ; HOLE5.1 HOLE5.6 ; HOLE13.1 HOLE13.8 ; HOLE13.1 HOLE13.9 ; HOLE13.1 HOLE13.7
  BOTTOM w0.076: 139.39,124.82 U45.J10
  BOTTOM w0.127: U45.AV39 121.65,108.9 122.03,109.27 122.03,109.76 ; 115.88,109.79 115.88,109.67 115.72,109.51 115.72,109.27 115.35,108.9 U45.AV49 ; 118.88,109.79 118.87,109.77 118.87,109.24 118.5,108.88 U45.AV43 ; U45.AV36 123.23,108.9 123.59,109.27 123.59,109.67 123.71,109.79 ; v1(142.99,128.38) 143.11,128.26 143.11,127.97 143.37,127.72 143.89,127.72 U45.D2 ; U45.AR11 138.77,110.54 138.77,110.75 139.02,111.01 139.02,111.2 U45.AP10 139.02,111.49 139.02,111.71 138.86,111.87 138.86,112.12 138.95,112.21 138.95,112.43 138.86,112.52 138.86,112.77 139.17,113.08 U45.AL10 ; 107.02,127.87 107.02,127.67 107.16,127.52 107.16,127.28 107.19,127.25 107.19,127.02 v1(107.2,127.01) ; 117.28,109.85 117.28,109.54 117.29,109.53 117.29,109.27 116.93,108.9 U45.AV46 ; 120.48,109.74 120.44,109.7 120.44,109.27 120.08,108.9 U45.AV41 ; U45.D62 106.85,128.04
  BOTTOM w0.14: U45.L7 140.89,123.82 140.06,124.65 139.57,124.65 139.39,124.82 ; U49.2 231.35,65.26 v1(231.61,65.52) ; C767.2 147.9,50.78 v1(148.04,50.91)
  BOTTOM w0.152: v1(126.65,106.85) 126.72,106.92 U45.AY30 ; U45.AY57 110.05,107.76 110.05,106.86 v1(109.99,106.8) ; v1(130.46,106.84) 130.51,106.89 U45.AY24 U45.AW24 ; v1(136.11,106.61) 135.8,106.93 135.8,107.61 U45.AY16 ; U45.AY26 129.15,107.76 129.15,106.72 v1(128.96,106.53) ; v1(112.43,106.84) 112.46,106.84 112.49,106.88 U45.AY53 ; U45.AY18 134.29,106.89 v1(134.32,106.85) ; v1(105.05,115.41) 105.11,115.47 U45.AG63 U45.AG62 U45.AG61 ; U45.AY22 131.86,106.39 v1(131.98,106.27)
  BOTTOM w0.165: v1(43.33,141.94) 43,141.61 U43.P26
  BOTTOM w0.178: U45.AU51 U45.AV51 U45.AW51 U45.AY51 113.84,106.37 v1(114.05,106.16) ; U45.AU51 113.33,109.72 113.24,109.81 113.09,109.81 113.01,109.72 U45.AU53 112.08,109.72 112.07,109.74 111.78,109.74 111.76,109.72 U45.AU55 ; U45.AU51 114.01,109.72 v1(114.55,110.26) ; U45.AK23 130.98,114.12 130.98,114.73 130.9,114.81 U45.AH24 131.44,114.79 U45.AJ23 131.85,114.38 v1(132.33,114.38) 132.33,114.82 U45.AH22 ; U45.AW24 130.59,108.5 130.59,108.98 130.51,109.06 U45.AV24 U45.AU24 ; v1(124.66,110.3) 124.92,110.56 U45.AR33 ; v1(124.66,110.3) 125.21,109.74 U45.AU33 ; v1(124.66,110.3) 124.39,110.03 U45.AT35 123.96,109.85 123.89,109.79 123.25,109.79 123.18,109.85 U45.AT37 122.74,109.93 122.2,109.93 122.03,109.76 121.64,109.76 121.55,109.85 U45.AT40 ; v1(115.53,110.86) 115.88,111.21 U45.AP48 ; v1(120.3,111.53) 119.98,111.86 U45.AN42 119.66,111.86 v1(119.39,111.58) 119.11,111.86 U45.AN43 U45.AN45 ; v1(105.68,116.91) 106.18,116.91 U45.AD63 ; U45.AU24 129.99,109.72 129.97,109.74 129.69,109.74 129.67,109.72 U45.AU26 128.75,109.72 128.73,109.74 128.44,109.74 128.43,109.72 U45.AU28 ; U45.AU24 130.98,109.72 131.02,109.76 131.3,109.76 131.34,109.72 U45.AU22 132.27,109.72 132.28,109.74 132.57,109.74 132.59,109.72 U45.AU20 ; U45.AP52 113.24,111.08 113.18,111.02 113.18,110.75 113.24,110.69 U45.AR52 ; U45.AW35 124.05,108.1 v1(124.4,108.45) 124.7,108.75 U45.AV34 ; U45.AW33 125.42,108.47 125.42,108.95 125.37,109 125.37,109.02 U45.AV33 ; U45.AW33 U45.AY33 ; U45.AW33 125.13,108.42 U45.AV34 ; v1(108.45,119.52) 108.8,119.17 U45.Y59 ; U45.AN49 115.33,111.6 115.71,111.6 U45.AN48 115.98,111.85 116.22,111.85 v1(116.53,112.16) ; v1(112.72,113.67) 112.86,113.81 U45.AK52 113.35,113.92 U45.AJ52 ; U45.AN31 126.33,112.18 U45.AN32 125.67,111.53 v1(125.61,111.53) ; U45.AW42 119.3,108.1 v1(119.65,108.45) 119.95,108.75 U45.AV41 ; v1(122.75,112.99) 122.92,113.16 U45.AL36 ; v1(105.4,118.88) 105.67,119.15 U45.Y63 ; U45.AV34 125.13,109.07 U45.AV33 ; U45.AU59 U45.AV59 U45.AW59 ; U45.AU59 109.23,109.72 109.24,109.74 109.53,109.74 109.55,109.72 U45.AU57 110.47,109.72 110.49,109.74 110.77,109.74 110.79,109.72 U45.AU55 ; U45.AU59 108.82,109.75 108.52,110.05 108.52,110.43 v1(108.39,110.56) ; v1(128.18,130.69) 128.29,130.58 U45.A28 ; U45.AL60 U45.AL61 107.79,112.87 v1(107.31,112.87) ; U45.AL60 108.47,113.39 108.49,113.41 108.49,113.69 108.47,113.71 U45.AJ60 108.47,114.38 108.72,114.63 108.54,114.8 108.54,115.4 U45.AG60 U45.AG61 ; U45.AL60 108.47,112.42 108.49,112.4 108.49,112.12 108.47,112.1 U45.AN60 108.47,111.17 108.49,111.16 108.49,110.67 v1(108.39,110.56) ; U45.AG21 132.87,114.52 v1(132.99,114.41) ; U45.AR49 114.85,110.56 v1(114.55,110.26) ; U45.AV39 121.55,108.75 v1(121.25,108.45) 120.9,108.1 U45.AW40 ; U45.AW47 116.18,108.1 v1(116.53,108.45) 116.83,108.75 U45.AV46 ; U45.P59 108.8,122.22 v1(108.47,122.54) ; v1(114.55,110.26) 114.91,109.89 U45.AT49 115.33,109.83 115.37,109.79 115.88,109.79 115.94,109.85 U45.AT46 U45.AT43 118.16,109.79 119.52,109.79 119.59,109.85 U45.AT42 120.06,109.85 120.18,109.74 120.48,109.74 120.51,109.76 121.15,109.76 U45.AT40 ; U45.AV33 125.42,109.72 U45.AU33 ; U45.AV43 118.4,108.75 v1(118.1,108.45) 117.75,108.1 U45.AW44 ; v1(139.99,145.59) 140.33,145.93 PU7.3 ; v1(108.39,110.56) 108.26,110.44 U45.AT61 107.64,110.26 107.13,110.26 U45.AT62 106.92,110.38 106.77,110.23 U45.AT63 ; U45.AU20 U45.AV20 133.11,109.04 v1(133.11,108.56) ; U45.AU20 133.56,109.72 133.58,109.74 133.86,109.74 133.88,109.72 U45.AU18 134.8,109.72 134.96,109.88 135.12,109.72 U45.AU16 U45.AV16 U45.AW16 135.6,108.38 135.67,108.31 135.67,107.88 135.6,107.81 135.6,107.81 U45.AY16 ; U45.AL52 113.35,113.16 v1(113.67,112.83) 113.57,112.83 U45.AM52 ; U45.AV49 115.25,108.75 v1(114.95,108.45) 114.76,108.25 114.68,108.25 U45.AW50 ; U45.AU33 126.19,109.74 126.21,109.72 U45.AU30 127.13,109.72 127.15,109.74 127.44,109.74 127.45,109.72 U45.AU28 ; U45.AW37 122.48,108.1 v1(122.83,108.45) 123.13,108.75 U45.AV36 ; U45.AT40 121.24,110.84 U45.AR39 U45.AP39 U45.AN39 121.28,112.7 v1(121.15,112.83) 121.15,113.35 U45.AL39 121.28,113.62 v1(121.8,114.13) ; v1(104.6,111.51) 104.78,111.69 U45.AN63 ; v1(142.41,109.19) 142.51,109.1 142.51,108.45 U45.AW4 ; U45.AU55 U45.AV55 ; U45.AJ63 105.92,114.12 105.69,113.89 v1(105.34,113.89) ; U45.AB7 140.89,118.35 v1(141.04,118.5) ; U45.AU28 U45.AV28 127.94,109.06 127.97,109.03 v1(127.97,108.56) ; U45.AL33 124.92,113.16 v1(124.66,112.9)
  BOTTOM w0.203: U43.B8 52.74,125.8 52.29,126.25 51.71,126.25 v1(51.7,126.25) ; 120.96,111.86 U45.AN40 120.63,111.86 v1(120.3,111.53) ; 120.96,111.86 U45.AP39 ; 120.96,111.86 U45.AN39 ; U45.K1 145.31,124.35 v1(145.45,124.49) ; U45.T1 145.33,121.36 v1(145.36,121.33) ; U45.U61 107.5,120.72 v1(107.2,121.02) ; U45.F58 109.45,127.34 108.92,127.86 U45.D59 ; U45.AN7 141.42,111.67 v1(141.48,111.67) ; U45.AW4 142.9,108.06 U45.AY4 ; U43.U26 40.52,140.84 40.37,140.99 40.37,141.85 40.59,142.07 v1(40.59,142.28) ; v1(136.06,109.97) 136.28,109.97 U45.AR15 ; v1(136.06,109.97) 135.6,110.43 U45.AR17 ; v1(136.06,109.97) 135.81,109.72 U45.AU16 ; U45.AN49 114.83,111.62 114.3,111.62 U45.AN51 113.99,111.86 113.86,111.73 113.48,111.73 113.35,111.86 U45.AN52 ; U45.AP57 110.24,111.21 v1(109.92,110.88) ; U45.AD3 143.52,116.78 v1(143.82,116.48) ; v1(116.53,112.16) 116.83,111.86 U45.AN46 117.22,111.86 117.29,111.78 117.67,111.78 117.75,111.86 U45.AN45 ; v1(108.68,106.89) 108.74,106.94 U45.AY59 ; U45.AN52 113.15,111.86 v1(112.83,112.18) ; U45.AN52 U45.AP52 ; U45.W22 132.22,119.92 132.91,120.62 U45.U20 U45.W20 ; v1(121.4,64.3) 120.81,63.71 120.15,63.71 U31.J8 ; v1(121.15,112.83) 120.82,113.16 U45.AL40 ; U45.AM1 144.85,112.39 145.35,112.39 v1(145.41,112.45) ; v1(113.67,112.83) 114,113.16 U45.AL51 ; v1(143.82,122.48) 143.52,122.78 U45.N3 ; U45.AP3 143.52,110.76 v1(143.8,110.49) ; U45.L61 107.5,123.72 v1(107.2,124.02) ; v1(138.57,106.46) 138.45,106.58 U45.AY11 ; v1(143.83,119.48) 143.82,119.48 143.82,119.6 U45.V3 ; U45.AC61 107.5,117.72 v1(107.2,118.02) ; v1(135.11,127.93) 135.55,127.48 U45.E17 ; U45.AL54 112.15,113.16 v1(111.82,112.83) ; v1(109.92,112.83) 110.24,113.16 U45.AL57 ; U45.AT43 118.09,109.89 v1(118.44,110.23) 118.76,110.56 U45.AR43 ; v1(142.37,116.59) 142.19,116.42 U45.AE5 ; U45.AN48 U45.AP48 ; U45.J63 105.74,125.14 v1(105.62,125.26) ; U45.AP38 122.12,111.21 v1(121.8,110.88) U45.AR39 ; U45.AV14 136.67,108.42 v1(136.58,108.42) ; U45.AU1 145.02,109.42 v1(146.03,108.4) ; U45.G5 142.45,125.93 142.45,125.81 142.77,125.49 v1(143.19,125.49) ; U45.AP54 112.15,111.21 v1(111.82,110.88) ; v1(143.82,113.49) 143.52,113.79 U45.AK3 ; U45.AW60 108.5,108.1 U45.AW59 ; U45.M22 131.26,123.06 v1(131.17,122.97) ; v1(107.2,127.01) 107.2,126.9 U45.F61 ; U12.T9 47.25,158.62 47.25,157.79 U12.P9 ; U45.AG1 145.28,115.36 v1(145.41,115.49) ; v1(141.69,106.56) 141.71,106.56 141.45,106.82 U45.AY6 ; U43.B11 52.67,128.28 52.26,128.69 v1(51.7,128.69) ; U45.AL46 117.3,112.88 v1(117.45,112.88) 117.64,112.88 117.92,113.16 U45.AL45
  BOTTOM w0.229: CN7.29 58.05,105.42 58.12,105.49 v1(58.12,105.77) ; U50.D8 70.15,66.93 70.85,66.93 v1(71.08,66.71) ; v1(89.09,63.61) 88.98,63.72 88.16,63.72 U29.J8 ; U31.J2 114.84,63.33 114.44,62.93 114,62.93 113.73,63.2 v1(113.73,63.8) ; U53.D8 115.36,66.93 116.07,66.93 v1(116.26,66.74) ; U45.L20 133.6,123.91 133,123.91 132.23,124.68 U45.J22 ; CN7.24 60.55,105.54 v1(60.66,105.66) ; v1(131.2,122.36) 131.32,122.24 U45.P22 ; U52.D8 102.15,66.93 102.86,66.93 v1(103.06,66.74) ; CN7.12 66.55,105.31 67.17,105.93 v1(67.17,106.03) 67.29,106.03 68.05,105.27 CN7.9 ; v1(69.15,57.21) 69.07,57.29 69.07,57.61 U28.T1 ; CN7.15 65.05,105.27 64.75,105.57 v1(64.51,105.57) ; U51.D8 83.36,66.93 84.06,66.93 v1(84.26,66.74)
  BOTTOM w0.254: JDIM1.43 108.98,82.84 108.95,82.81 108.95,82.05 109.45,81.55 v1(109.45,81.49) ; v1(115.24,77.92) 115.44,77.92 115.88,77.48 JDIM1.66 ; U45.D42 119.76,127.8 U45.D41 120.55,128.59 v1(120.97,128.59) ; U45.D42 119.28,127.8 U45.D43 118.94,128.12 v1(118.47,128.59) ; U45.D42 U45.F42 119.52,126.37 v1(119.51,126.37) ; v1(122.02,126.37) 122.02,126.37 U45.F38 U45.D38 ; PU10.5 132.26,46.35 PU10.22 ; v1(98.65,80.74) 98.87,80.74 99.38,81.25 JDIM1.11 ; U13.P1 69.1,138.35 v1(68.69,137.94) ; v1(142.45,111.18) 142.41,111.18 U45.AR5 ; U45.C11 138.47,128.67 U45.D12 138.09,127.98 v1(137.89,127.78) ; U12.P1 53.27,157.62 53.6,157.95 53.99,157.95 54.49,157.45 v1(54.49,157.45) ; U45.A32 125.79,129.66 125.66,129.53 125.66,129.22 U45.B32 125.79,128.79 v1(125.99,128.59) ; v1(103.88,77.95) 104.48,77.35 JDIM1.28 ; v1(125.59,114.13) 125.7,114.25 U45.AH32 ; v1(105.65,122.32) 105.83,122.14 U45.P63 U45.P62 ; JDIM1.63 114.98,82.11 v1(114.38,81.51) ; v1(137.04,85.38) 136.79,85.38 136.58,85.17 JDIM1.127 ; U45.AJ50 114.32,114.46 U45.AH51 113.67,114.46 U45.AJ52 ; U45.G5 141.91,126.47 v1(141.83,126.47) 141.61,126.47 141.3,126.16 U45.G6 140.95,126.48 140.67,126.48 140.35,126.16 U45.G8 139.99,126.48 v1(139.92,126.48) ; v1(133.63,110.88) 133.66,110.88 133.82,111.05 133.83,111.05 133.99,111.21 U45.AP20 ; v1(139.28,74.05) 139.28,74.08 139.28,74.08 JDIM1.136 ; U45.AM31 U45.AL31 126.56,113.66 127.36,114.46 U45.AJ29 ; U45.AM31 v1(127.07,112.83) 127.12,112.83 127.45,113.16 U45.AL29 ; U45.AM31 U45.AN31 U45.AP31 U45.AR31 126.56,109.88 U45.AU30 ; v1(95.97,77.45) 96.36,77.45 96.68,77.13 JDIM1.2 ; U45.F58 109.45,126.5 v1(109.34,126.4) U45.H57 ; JDIM1.153 144.38,81.9 143.96,81.48 v1(143.69,81.48) ; v1(120.56,130.24) 120.56,129.96 U45.A40 U45.B40 120.97,128.9 v1(120.97,128.59) ; v1(98.65,79.25) 98.28,79.25 96.98,80.55 JDIM1.3 ; U45.D46 U45.F46 117.01,126.37 v1(117.01,126.37) ; U45.D46 116.68,128.12 U45.D47 ; U45.D46 117.25,127.8 U45.D45 118.02,128.57 118.45,128.57 v1(118.47,128.59) ; U45.V7 140.89,120.15 v1(141.14,120.4) ; U45.H13 137.12,125.84 v1(137.05,125.84) ; JDIM1.14 100.28,77.7 v1(100.54,77.96) ; v1(139.3,132.32) 139.06,132.08 139.06,131.04 138.59,130.57 138.59,130.56 138.46,130.43 U45.A11 ; v1(137.89,127.78) 138.21,127.46 U45.E11 ; v1(137.89,127.78) 137.81,127.78 U45.D14 136.9,128.7 U45.C14 136.91,128.89 136.91,129.73 136.79,129.85 U45.A14 136.79,130.46 v1(136.9,130.57) ; v1(156.98,85.4) JDIM1.195 ; U45.AA58 v1(110.12,118.74) ; v1(136.53,116.66) 136.48,116.66 137.14,116 U45.AF14 ; U45.D34 124.86,128.12 U45.D33 125.54,128.57 125.97,128.57 v1(125.99,128.59) ; U45.D34 124.29,127.8 U45.D35 123.95,128.12 v1(123.48,128.59) ; U45.D34 U45.F34 124.53,126.37 v1(124.53,126.37) ; v1(144.98,85.3) JDIM1.155 ; v1(131.7,110.87) 131.78,110.87 U45.AP22 ; v1(131.7,110.87) 131.53,110.7 131.38,110.7 131.3,110.62 U45.AR23 131.28,110.56 131.02,110.3 131.02,109.76 ; v1(131.7,110.87) 131.63,110.87 U45.AP23 131.15,111.35 131.15,111.71 U45.AN23 131.12,112.03 131.12,112.34 U45.AM23 131.42,112.63 131.53,112.63 v1(131.73,112.83) ; U45.K12 137.9,124.37 U45.L13 137.39,123.86 137.39,123.57 137.32,123.5 137.32,122.3 137.78,121.84 v1(137.78,121.55) 137.8,121.57 138.77,121.57 139.02,121.83 U45.R10 U45.N10 ; v1(118.47,128.59) 118.26,128.8 U45.B44 118.1,129.26 118.1,129.58 U45.A44 ; JDIM1.61 v1(114.38,85.4) 112.91,85.4 112.58,85.07 JDIM1.55 ; v1(105.42,74.15) 105.68,74.41 JDIM1.32 ; U45.AJ29 v1(127.65,115.2) 127.41,115.2 U45.AH30 ; U45.AJ29 127.98,114.46 U45.AH28 128.63,114.46 U45.AJ27 129.16,114.25 130.05,114.25 U45.AJ25 130.58,114.79 U45.AH24 ; v1(60.66,105.66) 61.54,105.66 62.05,105.15 CN7.21 ; v1(125.99,128.59) 126.46,128.12 U45.D31 126.8,127.8 U45.D30 ; U45.AD21 133.14,116.99 v1(132.76,117.36) 132.76,117.44 132.22,117.98 U45.AB22 ; U45.P22 U45.M22 ; U45.P22 132.73,122.24 U45.N21 ; U45.P22 U45.R22 ; JDIM1.150 143.48,76.82 143.37,76.93 143.37,77.6 143.62,77.86 v1(143.62,77.88) ; U45.AH20 133.51,114.6 133.81,114.29 v1(133.89,114.29) 133.99,114.29 U45.AH19 ; U45.D26 U45.F26 129.55,126.3 v1(129.8,126.04) ; U45.D26 129.22,128.12 U45.D27 U45.C27 128.68,128.77 v1(128.5,128.59) 128.07,128.59 U45.D29 127.36,128.12 U45.D30 ; U45.D26 129.79,127.8 U45.D25 U45.C25 129.87,128.77 U45.B26 129.63,129.18 129.63,130.62 v1(129.68,130.67) ; U45.V58 v1(109.99,120.05) ; v1(139.88,73.93) 139.88,74.01 JDIM1.138 ; v1(151.85,77.15) 151.88,77.12 JDIM1.178 ; v1(136.04,113.12) 135.92,113.01 135.77,113.01 U45.AM17 U45.AN17 U45.AP17 U45.AR17 ; v1(136.04,113.12) 136.56,113.65 136.56,113.78 U45.AJ14 137.08,113.61 137.08,113.47 U45.AL13 137.55,113.6 U45.AJ13 ; v1(136.04,113.12) 135.66,113.49 U45.AL17 135.45,113.64 v1(135.45,114.13) ; JDIM1.25 103.58,81.29 104.34,80.53 v1(104.51,80.53) ; U45.G22 132.59,126.68 U45.D21 132.2,127.65 v1(132.08,127.77) ; JDIM1.184 153.68,76.98 153.67,76.99 153.67,77.73 153.91,77.96 v1(154.01,77.96) ; JDIM1.48 110.48,74.22 v1(110.49,74.21) ; JDIM1.172 150.08,74.29 149.82,74.02 149.06,74.02 v1(148.93,74.15) 148.88,74.2 JDIM1.168 ; v1(146.9,77.99) 147.42,77.47 147.42,77.03 147.08,76.69 JDIM1.162 ; v1(131.73,112.83) 131.57,112.99 131.47,112.99 U45.AL23 131.21,113.25 131.21,113.72 U45.AK23 ; v1(131.73,112.83) 131.77,112.83 132.1,113.16 U45.AL22 ; v1(120.97,128.59) 121.44,128.12 U45.D39 121.79,127.8 U45.D38 ; JDIM1.13 99.98,82.42 v1(99.96,82.4) ; v1(136.88,77.2) JDIM1.128 ; v1(110.24,81.52) 110.36,81.52 110.83,81.99 110.83,82.51 110.78,82.56 JDIM1.49 ; U45.AH16 135.81,114.6 135.45,114.24 v1(135.45,114.13) ; v1(140.18,85.24) JDIM1.139 140.18,81.92 v1(139.97,81.71) ; v1(137.73,120.56) 137.73,120.56 137.83,120.45 139.74,120.45 U45.U9 ; U45.AF11 138.44,116.11 138.24,116.11 137.83,116.52 137.83,116.54 v1(137.85,116.57) ; U45.AF11 138.77,115.69 U45.AG11 137.95,115.69 U45.AF12 ; U45.AF11 139.02,115.79 U45.AE10 ; U45.AL10 138.87,113.3 v1(138.69,113.47) ; JDIM1.31 105.38,82.52 v1(105.5,82.41) ; U45.AA1 145.19,118.36 v1(145.4,118.14) ; U45.D37 122.26,128.45 U45.C38 121.79,128.45 U45.C39 ; U45.D37 122.26,127.8 U45.D38 ; U45.D37 123.04,128.57 123.46,128.57 v1(123.48,128.59) ; v1(138.52,117.87) 139.19,117.87 U45.AB10 ; JDIM1.9 98.78,82.4 v1(98.65,82.27) ; JDIM1.161 v1(146.78,85.4) ; v1(128.98,110.88) 129.03,110.88 129.36,111.21 U45.AP26 ; v1(108.47,125.52) 108.8,125.19 U45.J59 ; CN7.18 63.55,105.49 v1(63.65,105.58) ; v1(155.18,85.4) JDIM1.189 ; v1(128.98,112.83) 129.3,113.16 U45.AL26 ; U45.D30 U45.F30 127.04,126.37 v1(127.04,126.37) ; JDIM1.156 145.28,76.9 145.33,76.95 145.33,77.61 145.08,77.86 v1(145.08,77.88) ; v1(110.15,116.27) 109.57,116.27 U45.AE58 ; v1(103.88,74.2) JDIM1.26 ; U45.D62 106.25,128.04 U45.D63 v1(105.62,128.1) ; v1(130.79,130.67) 130.8,130.66 U45.A24 130.8,129.69 130.74,129.64 130.74,129.16 U45.B24 130.8,128.94 U45.D23 ; PU9.25 PU9.21 ; JDIM1.71 117.38,85.61 v1(117.36,85.63) ; JDIM1.190 155.48,77.38 v1(154.97,77.89) ; U45.L58 v1(110.15,123.95) ; v1(114.5,126.37) 114.5,126.37 U45.F50 U45.D50 114.18,128.12 U45.D51 113.75,128.12 113.27,128.61 v1(113.07,128.61) ; U45.AH17 135.11,114.47 v1(135.45,114.13) ; U54.13 214.57,56.36 v1(214.33,56.12) 214.36,56.12 214.62,55.86 U54.12 ; U45.AF17 U45.AF18 ; U45.AF17 U45.AF15 ; U45.AF17 135.51,115.99 135.62,116.1 v1(135.62,116.71) ; v1(123.48,128.59) 123.28,128.79 U45.B36 123.28,129.24 123.26,129.32 123.26,129.59 123.28,129.64 U45.A36 ; v1(101.78,82.27) JDIM1.19 ; v1(68.69,137.32) 68.56,137.32 67.53,138.35 U13.M1 ; U45.H17 135.5,125.5 135.18,125.83 134.93,125.83 U45.G18 134.38,126.16 v1(134.07,125.84) 134.07,126.39 U45.F20 ; U45.A48 115.63,129.62 115.63,129.23 U45.B48 115.76,128.74 v1(115.63,128.61) 115.14,128.12 U45.D49 ; JDIM1.173 150.38,81.91 v1(149.97,81.5) ; v1(133.56,112.77) 133.63,112.77 133.9,113.04 U45.AL20 ; v1(139.1,73.47) 138.68,73.89 JDIM1.134 ; JDIM1.170 149.48,77.35 v1(150.08,77.95) ; v1(98.53,77.05) 98.48,77 JDIM1.8 ; JDIM1.187 154.58,81.83 154.25,81.51 v1(153.98,81.51) ; U45.D53 112.59,128.12 v1(113.07,128.61) ; v1(214.33,54.85) 214.34,54.86 U54.10 ; JDIM1.65 115.58,81.16 116.76,79.98 v1(117,79.98) ; U45.AG23 131.58,115.21 129.64,115.21 v1(129.4,115.45) ; JDIM1.46 109.88,77.35 v1(109.28,77.95) ; U45.J10 138.98,125.24 v1(138.88,125.24) ; v1(138.85,81.61) 138.26,82.19 138.26,82.53 138.38,82.65 JDIM1.133 138.38,85.55 137.97,85.96 137.34,85.96 v1(137.32,85.94) ; v1(141.77,74.15) 141.68,74.24 JDIM1.144 ; U45.AN35 124.06,111.86 123.74,111.53 v1(123.7,111.53) 123.57,111.53 U45.AN36 122.92,111.86 v1(122.75,111.68) ; 108.72,114.63 108.88,114.46 U45.AJ58 109.75,114.16 v1(109.94,114.16) 110.1,114.31 U45.AH57 110.42,114.79 U45.AJ56 111.07,114.46 U45.AH55 111.72,114.46 U45.AJ54 112.37,114.46 U45.AH53 112.7,113.69 v1(112.72,113.67) ; v1(141.98,85.4) JDIM1.145 ; JDIM1.38 107.48,76.97 v1(107.59,77.09) ; JDIM1.167 148.58,82.56 148.55,82.53 148.55,81.75 v1(148.72,81.58) ; JDIM1.196 157.28,77.52 156.99,77.81 v1(156.65,77.81) ; v1(135.11,127.93) 135.11,127.93 134.75,128.29 U45.D18 134.32,128.7 U45.C18 134.33,128.89 134.33,129.96 U45.A18 134.29,130.15 134.29,130.56 v1(134.37,130.64) ; JDIM1.60 114.08,74.35 113.88,74.15 112.34,74.15 v1(112.3,74.19) 112.28,74.21 JDIM1.54 ; JDIM1.37 107.18,82.6 v1(107.52,82.27) ; U45.B28 U45.A28 ; 106.85,128.04 107.02,127.87 ; U45.T58 v1(110.02,121.35) ; JDIM1.179 152.18,84.9 152.69,85.4 v1(153.98,85.4) 153.98,84.88 JDIM1.185 ; U45.V10 U45.Y10 ; v1(111.99,126.37) 111.99,126.37 U45.F54 U45.D54 ; R660.2 144.74,101.61 144.13,101 v1(144.15,101) ; U54.5 v1(218.76,54.36) ; U45.AU53 112.49,109.99 113.06,110.56 U45.AR52 ; U45.AR15 137.01,110.05 U45.AT13 137.56,110.05 v1(138.21,110.7) 138.28,110.7 U45.AR11 ; U54.16 217.07,57.29 v1(216.8,57.57) 216.57,57.34 U54.15 ; U45.AP29 127.43,111.21 127.1,110.88 v1(127.06,110.88) ; U45.D59 108.42,128.63 v1(108.42,128.83) 108.42,129.14 108.2,129.36 108.2,129.38 U45.B60 ; JDIM1.20 v1(102.08,77.19) ; v1(45.7,156.71) 45.7,156.55 46.06,156.19 46.48,156.19 U12.M9 ; v1(136.23,123.05) 136.36,123.17 136.36,123.78 U45.L15 U45.L17 ; v1(7.47,116.93) CN6.9 ; JDIM1.151 v1(143.78,85.4) ; v1(113.07,128.61) 113.25,128.78 U45.B52 113.12,129.23 113.12,129.62 U45.A52 ; JDIM1.44 v1(109.28,74.21) ; v1(133.46,129.57) 133.36,129.48 133.02,129.48 U45.B20 132.97,129.38 133.31,129.04 U45.C20 133.34,128.85 133.34,127.96 133.23,127.85 v1(133.26,127.85)
  BOTTOM w0.279: v1(7.45,115.28) 7.6,115.43 CN6.6 ; v1(226.4,91.3) 226.49,91.21 CN12.75 ; CN6.5 7.83,114.93 7.55,114.65 v1(7.45,114.65) ; v1(54.85,61.58) 55.24,61.97 PU9.14 PU9.25 ; U42.3 97.72,137.02 v1(97.9,137.19)
  BOTTOM w0.3: U43.AC26 35.42,140.79 35.42,142.13 v1(35.47,142.18)
  BOTTOM w0.305: U45.AB20 133.64,118.22 134.2,118.77 v1(134.2,118.97) ; U11.B9 34.92,147.8 v1(34.53,147.41) ; U39.E1 46.87,150.2 v1(47.26,149.82) 46.87,149.43 U39.D1 ; U50.E7 70.53,66.53 v1(70.14,66.14) U28.E2 ; U45.R8 U45.R10 ; v1(35.39,150.61) 35.8,150.2 U11.E8 ; U53.F9 113.64,65.2 v1(113.64,65.03) 113.75,64.93 U31.G1 ; CN14.10 147.78,59.55 v1(147.53,59.3) 147.03,59.3 146.78,59.55 CN14.12 ; v1(40.1,137.82) 40.52,138.24 U43.U23 ; CN12.69 226.84,89.71 226.58,89.44 v1(226.4,89.44) ; U43.Y26 38.04,140.65 v1(38.43,140.26) ; U51.B3 v1(87.34,68.55) ; U39.B3 48.47,147.76 v1(48.82,147.4) ; U13.G9 63.53,144.73 v1(63.93,144.33) ; U52.G8 101.38,65.31 v1(101.38,65.31) ; U29.B1 81.09,68.93 81.01,69 v1(80.88,69) ; U51.G8 82.58,65.31 v1(82.58,65.34) ; U11.T1 41.4,159.31 v1(41.03,159.68) ; v1(89.37,68.46) 89.04,68.46 U29.B9 ; U29.E2 82.98,66.53 v1(83.36,66.15) 83.74,66.53 U51.E7 ; v1(64.74,127.68) 65.13,127.29 U16.J2 65.16,127.28 v1(65.54,127.66) ; v1(52.5,132.84) 52.9,133.24 U43.B17 ; U43.E22 50.42,137.36 v1(49.97,137.81) ; CN12.1 v1(226.48,72.71) ; U53.B3 v1(119.35,68.55) ; U11.G9 v1(34.38,151.8) ; U16.J8 65.15,132.08 v1(65.56,131.68) ; v1(88.38,57.22) 88.56,57.41 U29.T9 ; U51.D1 88.56,67.29 v1(88.19,66.91) 87.81,66.53 U29.E8 ; U38.E1 v1(35.38,149.82) 35,149.44 U38.D1 ; U50.D3 73.76,67.3 v1(74.13,66.92) ; U43.E17 50.47,133.24 v1(50.04,132.81) ; v1(69.13,125.88) U16.P1 ; v1(52.09,153.81) 52.47,153.43 U12.J2 ; U29.M9 v1(89.06,60.43) ; v1(106.98,66.11) 107.36,66.49 U52.E1 ; U53.A9 113.68,70.21 v1(113.12,70.21) ; U11.J2 40.6,153.42 v1(40.21,153.81) ; v1(35.92,135.3) U43.AB20 ; U52.D1 107.36,67.29 v1(106.98,66.91) 106.6,66.53 U30.E8 ; v1(108.17,68.46) 107.83,68.46 U30.B9 ; v1(226.53,86.85) 226.67,86.71 CN12.57 ; U13.E8 61.93,143.95 v1(61.51,144.37) 61.9,144.75 U41.E1 ; U43.AB17 v1(35.92,133.66) ; U28.B1 v1(67.77,68.93) ; U12.G1 53.24,151.8 v1(52.84,151.4) ; U30.J8 106.15,63.74 v1(106.13,63.74) ; U43.B14 52.9,130.7 v1(53.27,130.33) ; v1(106.14,66.92) 105.76,67.3 U52.D3 ; U43.P23 43,138.23 v1(42.62,137.85) ; v1(53.29,135.28) 52.9,135.67 U43.B20 ; U31.G9 v1(120.19,65.31) ; v1(53.81,138.25) 53.71,138.34 53.03,138.34 U43.B23 ; U29.P1 v1(82.56,58.93) ; v1(88.19,66.11) 88.56,66.49 U51.E1 ; U16.T9 70.73,132.88 71.16,132.88 71.31,132.73 v1(71.41,132.73) ; v1(226.4,81.26) 226.4,81.14 226.83,80.71 CN12.33 ; v1(67.53,125.95) U16.M1 ; U29.M1 v1(81.76,60.53) ; v1(46.25,151.86) 46.3,151.8 U12.G9 ; U30.P9 107.36,59.34 106.97,59.73 v1(106.97,59.76) ; v1(226.4,84.82) 226.79,85.21 CN12.51 ; v1(70.39,137.86) 70.73,138.2 U13.T1 ; U43.AB14 v1(35.92,131.18) ; U45.AV8 139.68,108.44 v1(139.58,108.44) ; v1(74.97,63.74) U28.J8 ; v1(50.88,140.29) 50.88,140.29 U43.E25 ; U53.D3 118.97,67.3 v1(119.35,66.92) ; U12.E8 47.67,150.18 47.99,149.86 48,149.86 v1(48.05,149.81) ; v1(70.14,63.74) 70.14,63.71 U28.J2 ; U28.M9 v1(75.74,60.54) ; v1(48.05,153.78) U12.J8 ; U53.E7 115.74,66.53 v1(115.36,66.14) U31.E2 ; CN12.45 228.65,83.71 228.81,83.55 v1(229.17,83.55) ; v1(35.42,152.98) 35.8,153.36 U11.J8 ; U30.G1 100.51,64.93 v1(100.36,65.08) 100.36,65.21 100.88,65.73 U52.F9 ; U43.H25 48.37,140.27 v1(48.4,140.27) ; U52.A9 100.33,70.36 v1(100.14,70.36) ; U53.G8 v1(114.59,65.31) ; U31.P9 120.17,59.73 v1(120.17,59.75) ; U50.E1 75.36,66.49 v1(74.98,66.11) ; v1(137.7,119.08) 139.24,119.08 U45.Y10 ; U52.E7 102.53,66.53 v1(102.15,66.14) U30.E2 ; v1(54.29,141.12) 54.16,141.12 U43.A26 U43.B27 ; U13.P9 69.13,145.41 v1(69.35,145.63) ; U29.P9 88.56,59.34 v1(88.17,59.73) ; v1(71.3,145.21) 70.84,144.75 U13.T9 ; CN14.8 148.78,59.67 148.52,59.42 v1(148.52,59.29) ; U43.L23 45.48,138.25 v1(45.07,137.84) ; U31.E8 119.81,66.53 v1(120.19,66.91) 120.57,67.29 U53.D1 ; U12.B9 v1(46.33,147.8) ; v1(59.5,145.4) 59.5,144.78 U13.B9 ; U43.E11 v1(50.08,128.7) ; U31.P1 114.17,59.33 v1(114.57,58.93) ; U44.G8 63.53,127.27 v1(63.15,126.89) 62.75,126.48 U44.F9 ; v1(121.11,60.33) 121.11,60.39 U31.M9 ; U31.M1 v1(113.77,60.53) ; U43.E14 v1(50.9,130.36) ; v1(78.6,52.43) 78.6,51.85 77.45,50.7 CN17.3 ; U47.3 157.31,97.89 157.06,97.63 156.69,97.27 v1(156.17,97.27) ; v1(107.76,60.53) U30.M9 ; U11.M1 41.97,156.37 v1(41.97,157.01) ; v1(102.17,63.76) 101.76,63.35 U30.J2 ; v1(65.53,139.51) 65.18,139.15 U13.J2 ; U45.G3 143.52,125.82 v1(143.19,125.49) ; v1(75.78,57.3) U28.T9 ; v1(112.98,58.91) U31.T1 ; v1(52.46,119.14) 52.9,119.58 U43.B1 ; CN12.18 v1(221.43,76.96) ; U16.M9 67.53,133.34 v1(67.29,133.76) ; U50.A9 68.6,70.09 v1(68.11,70.09) ; U13.M9 67.53,145.26 67.38,145.41 v1(67.41,145.41) ; U16.E2 61.93,127.28 v1(61.52,126.86) 61.13,127.24 U44.D8 ; U39.A9 53.43,147.16 53.43,147.65 U12.B1 ; U28.G1 68.52,64.93 v1(68.41,65.03) 68.41,65.26 68.88,65.73 U50.F9 ; v1(37.28,147.79) 36.61,147.79 U38.B3 ; v1(99.73,58.61) 100.61,57.73 U30.T1 ; 75.52,51.37 75.95,50.94 CN17.6 ; v1(68.44,59.54) 68.75,59.54 U28.P1 ; CN12.39 v1(226.46,82.21) ; U41.D1 61.13,144.78 60.59,145.32 v1(60.13,145.32) ; v1(34.43,157.4) U11.P9 ; U30.T9 107.37,57.73 v1(107.79,57.3) ; U31.T9 120.74,57.56 v1(120.74,57.2) ; U53.E1 120.57,66.49 v1(120.19,66.11) ; U29.G9 v1(88.19,65.31) ; U43.H23 47.97,138.26 v1(48.36,138.65) ; U50.D1 75.36,67.29 v1(74.98,66.91) 74.6,66.53 U28.E8 ; v1(63.53,125.91) U16.G1 ; U31.B1 113.96,69.13 v1(113.01,69.13) ; v1(68.54,60.52) U28.M1 ; C549.2 82.91,159.37 v1(82.79,159.5) ; U39.D8 52.47,149.42 v1(52.87,149.82) 52.48,150.2 U12.E2 ; v1(104.61,70.21) 104.61,70.08 U52.B3 ; U11.T9 34.44,159 v1(34.4,159.05) ; v1(99.68,69) 99.81,69 99.88,68.93 U30.B1 ; U31.B9 v1(121.04,68.46) ; U43.E20 50.5,135.72 v1(50.93,136.15) ; v1(147.15,96.26) 146.63,96.26 146.06,96.83 R688.2 ; v1(83.37,63.74) U29.J2 ; v1(118.17,74.15) 117.68,74.64 JDIM1.72 ; U51.D3 86.96,67.3 v1(87.34,66.92) ; U30.P1 v1(101.36,58.93) ; CN14.14 v1(145.78,59.32) ; U11.M9 34.47,155.8 v1(34.38,155.9) ; v1(226.53,88.21) CN12.63 ; v1(68.74,133.26) 68.74,133.27 U16.P9 ; U50.G8 v1(69.35,65.33) ; U12.T9 46.87,160.25 46.86,160.26 46.85,160.26 v1(46.85,160.28) ; v1(81.42,70.41) 82.11,69.73 U51.A9 ; v1(53.8,155.62) 53.45,155.62 U12.M1 ; v1(100.44,60.69) 100.72,60.69 U30.M1 ; U51.F9 82.09,65.73 81.59,65.24 v1(81.59,64.93) U29.G1 ; U50.B3 v1(74.13,68.55) ; CN12.7 v1(228.92,74.21) ; U28.G9 v1(74.98,65.31) ; U13.B1 59.27,138.09 ; v1(75.9,59.52) 75.72,59.34 75.36,59.34 U28.P9 ; U28.B9 v1(75.83,68.46) ; v1(41,157.8) U11.P1 ; U30.G9 v1(106.98,65.31) ; U29.T1 v1(82.16,57.18)
  BOTTOM w0.356: v1(136.15,101.29) 136.15,101.3 136.15,101.3 136.15,101.3 136.7,101.3 137.11,101.71 R664.1 137.37,102.23 R654.1 ; v1(60.03,60.05) 60.03,60.69 60.44,61.1 PC130.1
  BOTTOM w0.381: 46.49,134.26 v1(46.49,134.2) ; 46.49,134.26 46.99,133.76 U43.K17 ; 46.49,134.26 46.49,134.27 U43.L18 ; v1(58.68,129.56) 58.68,130.06 59.53,130.91 U44.B3 ; U45.L18 134.6,123.61 134.27,123.28 134.27,123.24 ; C563.1 R466.2 56.58,155.62 v1(53.8,155.62) ; 45,129.76 44,130.76 U43.N14 U43.P15 42.48,132.29 v1(42.48,132.29) 42.47,132.29 U43.R16 42,132.76 41,133.76 U43.T17 41,133.76 v1(40.5,134.26) 40,134.76 U43.U18 ; 45,129.76 v1(45.5,129.26) 46,128.76 U43.L12 U43.K11 47.16,127.76 v1(47.81,128.41) ; 45,129.76 U43.M13 ; U43.AD21 U43.AD22 ; U43.AD22 34.7,137.36 34.3,137.76 v1(34.3,137.78) ; U43.AD22 34.8,137.26 35.4,137.26 U43.AC22 ; U43.U2 40.54,120.86 v1(40.93,121.25) ; U39.G8 52.47,151.77 v1(52.84,151.4) 53.24,151 U39.F9 ; R444.1 v1(62.37,162.4) R436.1 ; v1(35.93,128.69) U43.AB11 ; PC119.1 54.48,73.94 v2(54.73,74.19) 55.54,73.39 PR176.1 ; PR215.2 135.34,50.01 135.67,50.34 v1(136.01,50.34) 136.29,50.34 136.54,50.1 PC143.2 ; U43.AB24 36.36,139.06 v1(35.95,138.65) ; PC130.1 60.22,61.44 PR203.1 ; v1(38.62,132.3) 38.62,132.14 U43.V15 U43.U14 U43.T13 41,129.76 v1(41.5,129.26) 42,128.76 U43.R12 U43.P11 U43.N10 ; U43.H5 v1(48.38,123.68) ; v2(10.5,140.8) 9.57,139.87 PC100.1 ; PR165.1 199.6,76.62 v1(199.68,76.54) ; v1(61.54,131.68) 61.93,132.08 U16.E8 ; U43.Y5 38.02,123.26 v1(37.62,122.86) ; U43.P5 43.02,123.26 v1(43.42,122.86) ; v1(52.88,148.19) 53.26,147.8 U12.B1 ; U13.J8 v1(64.74,143.56) ; U43.AE20 33.9,135.7 v1(34.3,135.3) 34.7,134.9 U43.AD19 ; v1(59.29,159.19) 59.07,158.97 R456.1 ; R680.2 151.22,99.29 v1(151.76,98.75) ; v1(47.84,131.13) 47.63,131.13 U43.K15 46.92,131.76 v1(46.37,132.31) 46,132.69 U43.L16 46,132.76 45.5,133.26 U43.M17 45,133.76 44.56,134.2 ; v1(60.41,163.31) 60.28,163.18 R442.1 ; U43.R10 42.17,126.59 42.17,126.28 41.97,126.08 v1(41.92,126.08) ; U43.AC2 35.55,120.84 v1(35.95,120.44) ; U43.L10 46,126.76 45,127.76 U43.M11 45,127.81 44.55,128.26 44.55,128.26 44.05,128.76 U43.N12 43.93,128.76 v1(43.44,129.25) 43,129.7 U43.P13 U43.R14 41.47,131.29 v1(41.32,131.29) 41.32,131.44 U43.T15 41,131.76 v1(40.5,132.26) 40.5,132.26 U43.U16 40,132.76 39.5,133.26 39.5,133.26 U43.V17 38.62,134.14 v1(38.62,134.2) ; PR168.2 56.32,75.55 57.03,74.84 57.67,74.84 57.83,75.01 PR169.1 ; C79.1 74.56,147.79 v1(75.07,148.3) ; R668.2 65.64,99.95 v1(65.64,99.81) ; U43.L25 45.44,139.86 v1(45.07,139.49) ; U43.AE17 34.3,133.64 v1(34.3,133.7) 34.68,134.08 U43.AD18 ; C587.1 69.19,145.8 v1(69.35,145.63) ; PC132.1 60.44,59.56 60.03,59.98 v1(60.03,60.05) ; C675.2 51.28,100.3 50.5,101.08 PC104.2 ; R498.2 74.3,137.37 v1(75.19,138.27) ; U16.B9 59.53,133.1 v1(59.12,133.52) ; U41.B3 59.53,142.42 58.93,141.82 v1(58.93,141.09) ; U16.B1 59.53,126.34 v1(59.09,125.9) 58.73,126.26 U44.A9 ; v1(32.67,138.62) 32.8,138.5 32.81,138.5 U43.AF23 ; v1(126.03,69.78) 125.98,69.83 C704.2 ; U43.AA7 37.01,124.77 36.53,124.77 U43.AB7 v1(35.92,125.38) U43.AC8 ; U43.AE11 U43.AF11 v1(32.55,128.28) ; v1(45.06,122.86) 45.08,122.86 U43.L5 ; U43.A2 53.7,120.49 53.55,120.34 v1(53.53,120.34) ; v1(42.61,121.25) U43.P2 ; 134.27,123.24 v1(134.27,123.07) ; 134.27,123.24 U45.L20 ; U12.T1 v1(53.86,159) ; v1(47.5,120.45) 47.5,120.44 47.54,120.44 U43.H2 ; U43.AD15 v1(34.3,132) 34.7,132.39 U43.AD16 ; v1(147,101.2) 147,101.42 147.28,101.7 R662.1 R663.2 ; v1(134.64,50.34) 134.44,50.34 134.18,50.08 PC142.1 ; U43.AC5 35.55,123.29 v1(35.97,122.86) ; U43.AG2 32.3,120.27 v1(32.27,120.23) 32.44,120.06 U43.AF1 ; v1(52.5,123.74) 52.9,123.34 U43.B5 ; v1(41.31,127.3) 41.31,127.45 U43.T11 41,127.76 40.5,128.26 40.5,128.26 U43.U12 40,128.76 v1(39.5,129.26) 39,129.76 U43.V13 38.48,129.76 38.36,129.64 v1(38.36,129.63) ; v1(47.84,129.26) 47.5,129.26 U43.K13 U43.L14 46,130.76 45,131.76 U43.M15 45,131.76 v1(44.5,132.26) 44,132.76 U43.N16 U43.P17 43,133.76 42.43,134.33 ; C659.1 158.46,118.75 158.28,118.93 158.28,119.05 v1(157.92,119.41) 157.27,119.41 C657.1 ; PR213.2 131.74,50.11 132,50.37 v1(132.1,50.37) ; 42.43,134.33 v1(42.43,134.33) ; 42.43,134.33 42,134.76 U43.R18 ; U44.E1 61.93,132.96 v1(61.48,133.42) 61.13,133.07 U44.D1 ; U43.Y23 38.02,138.26 37.63,138.66 v1(37.63,138.65) ; U41.A9 58.73,138.11 v1(58.97,137.87) 59.05,137.87 59.27,138.09 ; v1(37.64,120.46) U43.Y2 ; U43.E2 50.29,120.7 50.29,119.39 v1(50.51,119.17) ; U43.E8 50.48,125.8 v1(50.07,125.39) ; U45.W20 134.08,119.8 134.43,120.15 135.77,120.15 136.1,119.82 v1(136.1,119.54) ; v1(141.44,98.92) 141.44,99.67 C678.1 ; R493.1 v1(26.5,143.49) ; v1(38.24,127.85) 38.91,127.85 U43.V11 39.5,127.26 v1(39.5,127.26) 40,126.76 U43.U10 ; U43.N18 44.56,134.2 ; 44.56,134.2 v1(44.59,134.2) ; v1(58.81,159.6) 59.01,159.81 59.01,160.39 C546.2 ; U43.AF8 32.7,126.2 v1(32.7,126.23) ; U43.L2 45.46,120.86 v1(45.06,121.26) ; C664.1 C665.1 153.22,102.47 v1(153.5,102.75) ; U43.E5 50.51,123.31 v1(50.91,123.71) ; U16.T1 v1(70.73,125.81) ; U16.G9 63,133.41 v1(63,133.48) ; U43.AF20 v1(33.49,135.33) ; U43.AF17 v1(33.49,133.63) ; U43.AF5 32.63,123.31 v1(32.45,123.13) ; U43.U5 v1(40.94,123.68) ; U43.AG26 v1(31.9,141.06)
  BOTTOM w0.406: v1(164.55,45.16) 164.39,45.31 U56.25 ; v1(168.12,45.19) 168.24,45.31 U56.4 ; v1(168.1,40.63) 168.22,40.76 U56.11 ; U56.18 164.16,40.76 164.17,40.75 v1(164.3,40.75)
  BOTTOM w0.457: C636.2 140.93,133.26 v1(140.27,132.6) ; SW2.5 103.84,44.94 103.21,44.94 v1(102.85,45.3) ; C715.2 v1(126.06,65.38) ; C622.1 104.73,136.13 104.86,136.25 C621.1 ; v1(99.07,113.78) 99.07,114.33 99.15,114.41 PR155.2 ; R595.2 155.67,117.71 R588.2 ; v1(126.96,56.32) 126.96,56.26 126.55,55.85 C727.2 ; C703.2 63.7,70.21 v1(63.48,70.42) ; v1(83.04,52.92) 82.52,53.44 C738.2 ; v1(83.04,52.92) 83.46,53.34 C744.2 ; v1(83.04,52.92) 83.04,52.71 82.56,52.23 81.67,52.23 80.7,53.2 C759.2 80.48,53.33 80.48,53.58 79.89,54.16 R756.1 ; v1(149.69,118.14) 149.61,118.22 R592.2 ; v1(126.19,58.53) 125.43,59.28 C720.2 ; v1(82.74,156.8) 82.74,157.69 82.89,157.84 ; PQ35.1 96.73,107.07 v1(96.48,107.32) ; Q39.1 97.24,129.52 v1(96.86,129.9) ; R644.1 101.68,107.9 v1(101.84,108.06) 101.68,108.22 R640.1 ; R639.1 100.3,110.09 100.24,110.03 v1(100.24,109.61) ; C733.2 78.13,54.92 v1(78.19,54.97) ; v1(149.69,122.79) 149.56,122.67 R559.2 ; v1(85.35,53.25) 85.17,53.43 C745.2 ; v1(66.48,52.43) 66.48,52.84 65.87,53.45 C736.2 ; v1(126.07,68.31) 125.82,68.55 C708.2 ; v1(125.99,62.11) 125.77,62.33 C718.2 ; v1(151.34,150.73) 150.95,150.35 PR135.2 ; C712.2 125.42,67.03 v1(126.06,67.67) ; v1(126.21,57.61) 125.98,57.38 C723.2 ; v1(142.99,98.82) 142.98,98.82 142.98,99.7 C679.1 ; R541.2 R537.2 151.12,126.88 v1(151.77,126.88) ; PC103.1 93.84,110.12 94.22,110.5 v1(94.22,110.85) ; C734.2 93.5,53.52 v1(93.37,53.39) ; R642.2 157.18,107.54 157.07,107.43 R647.2 157.72,106.92 v1(157.92,106.71) ; v1(156.99,110.57) 156.63,110.21 R638.2 ; C747.2 87.48,53.22 v1(87.92,53.22) ; C748.2 91.31,53.33 91.98,53.33 v1(92,53.31) ; v1(62.32,59.14) 61.93,59.53 R745.1 ; C682.2 C683.1 151.6,96.86 v1(151.39,96.66) ; v1(149.69,116.06) 149.19,116.06 C660.1 ; v1(90.57,53.32) 90.48,53.41 C755.2 C754.2 ; v1(86.62,53.25) 86.44,53.43 C746.2 ; v1(83.39,161.39) D27.1
  BOTTOM w0.508: HOLE13.1 HOLE13.2 ; HOLE13.1 HOLE13.6 ; HOLE13.1 HOLE13.3 ; HOLE13.1 HOLE13.5 ; v1(136.2,135.77) 136.86,136.43 C618.1 136.86,137.77 v1(137.12,138.03) ; v1(120.4,136.25) 120.4,135.85 120.1,135.54 R504.1 ; C690.1 218.65,94.47 218.91,94.73 v1(218.91,95.49) ; CN19.3 v1(226.69,48.53) ; C705.1 62.39,69.07 v1(62.29,68.97) ; v1(154.67,157.16) 154.47,156.96 C566.1 ; C701.1 216.84,71.59 v1(216.37,71.59) ; C742.2 R757.1 112.61,52.56 112.48,52.43 C765.2 112.79,51.81 v1(113.3,51.29) ; v1(186.93,86.83) 186.37,86.27 CN10.3 ; CN19.6 227.34,41.03 v1(226.69,40.38) ; R632.2 v1(55.08,111.62) ; PC148.2 148.91,40.77 149.31,40.37 v2(149.31,40.07) ; PC131.1 55.58,60.44 55.57,60.69 55.57,60.85 v1(54.85,61.58) ; R773.1 122.74,44.56 123.1,44.21 v1(123.1,44.05) ; C770.2 C775.1 173.19,45.07 v1(173.31,45.2) ; C763.2 219.26,52.22 v1(219.26,52.69) ; C544.2 107.03,160.88 v1(106.77,161.15) ; D29.2 233.89,93.07 234.53,93.71 v1(234.65,93.71) ; Y4.4 v1(63.52,119.45) ; C777.2 v1(225.13,42.65) ; C663.2 46.97,106.26 47.58,105.65 v1(47.58,105.57) ; v1(121.01,135.87) 121.01,135.35 R505.1 ; R604.1 v1(42.25,113.9) ; v1(153.22,128.23) 153.22,127.71 R535.1 ; v1(216.37,95.23) 216.37,94.73 216.62,94.47 C688.1 ; v1(104.89,47.51) 104.94,47.56 106.04,47.56 D35.2 C769.2 ; U46.2 v1(44.41,105.55) ; CN4.5 19.13,160.76 v1(18.63,160.26) ; v1(94.09,59.55) 94.09,57.98 93.5,57.39 C728.2 C734.2 ; R588.2 155.89,118.47 156.14,118.22 v1(156.42,118.22) ; v1(55.08,113.78) R612.2 R611.2 ; C585.2 111.21,148.47 v1(111.21,149.21) ; v1(96.96,150.17) 97.27,150.48 R484.1 ; C757.2 v1(219.29,53.32) ; C523.1 11.4,166.49 v2(13.04,168.13) ; PR128.1 153.06,155.8 153.48,155.38 v1(153.48,154.39) ; CN18.8 83.52,46.81 v1(83.52,48.12) ; R602.1 97.75,115.93 v1(97.37,116.32) ; v1(55.71,99.65) R672.2 C674.2 ; R720.2 153.36,65.25 153.63,64.98 v1(154.26,64.98) ; v1(14.93,157.23) 15.15,157.46 CN4.3 ; v1(102.83,159.88) 103.34,159.88 103.71,159.5 C551.1 ; C677.1 156.42,100.57 v1(156.83,100.97) ; Y2.4 103.48,145.44 v1(104.02,144.89) ; PC98.2 129.94,141.16 130.5,141.16 130.84,141.5 v1(130.84,141.97) ; v2(124.16,158.86) 125.16,157.87 C572.2 127.36,157.87 v2(128.36,158.86) ; v1(44.79,108.19) 44.41,107.81 U46.5 ; v1(89.49,70.85) 89.06,71.29 C698.2 ; v1(96.02,53.5) C735.2 96.02,54.54 95.83,54.73 R752.1 95.83,60.11 v1(95.91,60.18) ; C719.2 C718.2 ; v1(52.34,99.6) 52.34,100.04 C676.1 ; R640.1 101.05,108.7 100.54,108.19 R645.2 ; R607.2 v1(48.22,113.78) ; v1(184.32,86.88) 183.07,88.12 CN10.5 ; v1(230.59,71.87) 230.89,71.87 C706.2 230.92,69.45 v1(230.72,69.45) ; R491.2 144.04,149.26 v1(144.61,149.26) ; C661.1 v1(154.9,114.79) ; R547.2 153.34,124.31 v1(153.43,124.22) 153.41,124.19 153.41,123.2 R556.1 ; PC140.1 v1(191.09,51.04) ; C570.1 v1(96.88,154.92) ; v1(47.2,111.62) 47.2,112.12 R626.2 ; PU8.4 94.7,115.3 94.29,114.89 v1(94.29,114.08) ; v1(99.78,146.8) C593.1 ; R462.1 57.79,156.9 v1(58.38,156.32) ; C760.1 72.91,52.56 71.89,53.58 71.18,53.58 C737.1 ; v1(161.5,106.28) 162.26,106.28 162.52,106.03 PQ33.1 ; C717.2 224.91,62.82 v1(225.89,62.82) ; C724.2 v1(221.57,56.5) ; v1(59.78,57.13) 60.15,56.76 C725.2 ; v1(44.66,114.79) 44.66,115.42 R603.2 ; R631.2 v1(53.93,111.62) ; v1(147.86,40.07) 147.49,40.44 PC149.2 ; C713.2 C709.2 64.08,68 v1(64.45,68.36) ; CN18.6 v1(85.35,48.12) ; v1(224.11,44.76) 224.49,45.15 C771.1 ; 89.37,102.47 89.37,103.18 v1(89.73,103.54) ; R768.1 122.52,47.43 v1(122.39,47.56) 122.52,47.69 R763.1 ; v1(129.63,137.91) 130.43,138.71 Y3.4 ; HOLE5.1 HOLE5.9 ; HOLE5.1 HOLE5.3 ; HOLE5.1 HOLE5.2 ; C561.1 107.65,158.73 v1(108.92,158.73) ; C36.2 111.63,160.92 v1(111.95,160.92) ; PR168.2 56.02,75.54 55.11,75.54 v2(54.78,75.87) ; C635.2 R511.1 137.88,134.65 138.11,134.88 v1(138.11,135.11) ; C31.2 111.85,161.65 v1(111.97,161.53) ; C611.1 28,137.55 v1(27.52,138.03) ; C726.2 64.99,56.12 65.12,56.24 v1(65.49,56.24) ; C630.2 v1(128.86,135.09) ; R532.2 101.93,128.27 v1(101.71,128.05) ; CN18.5 86.35,48.28 v1(86.19,48.12) ; R476.1 v1(113.12,152.64) ; C565.1 v1(98,157.08) ; v1(226.4,91.3) 226.4,91.75 CN12.77 ; v1(151.98,150.73) 151.98,151.67 151.81,151.84 PC87.2 PC88.2 ; U48.2 v1(232.62,81.19) ; PC124.1 61.03,65.98 v1(61.05,66) ; C768.2 109.56,48.62 109.1,48.17 109.1,46.14 v1(109.15,46.08) R770.1 ; v1(223.58,64.29) 224.05,64.75 R792.2 ; C584.1 84.9,148.7 v1(85.15,148.45) ; R457.1 61.22,159.93 v1(61.81,160.51) ; C619.1 142.08,137.6 141.83,137.84 v1(141.83,137.97) ; R625.2 v1(45.93,111.62) ; PR210.1 196.43,57.39 v1(196.43,57.72) ; C693.2 232.89,76.31 233.26,76.68 v1(233.26,76.95) ; C9.1 147.37,165.59 146.86,165.08 v1(146.77,165.08) ; v1(88.73,50.78) 88.73,51.55 C761.2 ; R628.2 v1(49.36,111.62) ; C702.2 C700.2 63.66,72.9 v1(63.29,72.9) ; PC147.1 146.22,40.36 v2(146.52,40.07) ; v1(157.44,100.95) 157.82,100.57 R674.1 ; D31.2 234.41,74.29 v1(234.53,74.41) ; R613.2 R614.1 v1(57.36,113.78) ; C675.2 51.46,99.9 v1(51.72,99.63) ; PQ37.1 v1(102.04,100.64) ; C634.2 135.54,134.78 135.21,135.11 v1(134.91,135.11) ; C656.1 v1(58.76,121.88) ; v1(173.31,43.16) 173.19,43.04 R778.1 ; R623.1 v1(44.67,112.39) ; v1(224.09,44.15) 223.73,44.15 223.35,44.54 C774.1 ; R553.2 v1(24.46,123.29) ; PR194.1 v1(56.71,69.05) ; v1(16.34,115.73) 15.95,115.34 PC101.1 ; CN18.7 93.82,46.36 94.83,45.35 v1(94.83,44.96) ; PU8.6 90.76,116.57 91.38,115.95 91.38,115.39 91.53,115.25 v1(91.53,114.54) 91.14,114.54 90.38,115.3 PU8.5 ; CN12.76 225.64,71.61 v1(225.13,72.12) ; C662.2 46.59,108.2 v1(46.06,108.2) ; v1(102.82,159.25) 102.82,158.86 R459.1 ; C590.1 v1(85.2,147.56) ; C552.1 v1(153,159.11) ; v1(234.53,25.76) 234.9,26.14 C514.2 ; R516.2 v1(147.66,134.98) ; C721.1 v1(215.36,59.28) ; U55.4 v1(117.56,43.54) ; R589.2 v1(66.67,118.46) ; R633.1 55.84,111.86 v1(55.84,111.62) ; v1(108.8,145.91) 108.54,146.16 C588.2 ; C772.1 C776.2 v1(159.97,43.55) ; R503.1 118.07,136.51 v1(118.32,136.76) ; CN16.6 64.73,47.78 v1(64.73,46.29) ; v1(103.87,146.8) C594.1 ; v1(220.37,65.1) 219.73,65.1 C714.2 219.96,64.49 v1(220.37,64.49) ; C778.2 v1(159.97,42.77) ; C692.2 v1(234.52,87.88) ; v1(233.27,69.19) 233.41,69.33 C707.2 ; CN11.4 v1(34.7,85.25) ; v1(100.42,134.1) 101.19,134.1 101.45,134.35 R508.2 ; v1(62.35,46.69) 61.53,47.51 CN15.27 ; v1(129.63,136.31) 128.83,137.11 Y3.2 ; CN19.13 244.98,31.32 v1(245.96,32.29) ; 233.67,15.47 CN20.1 ; C766.1 82.25,51.29 v1(82.76,50.78) ; v1(34.88,77.58) 35.01,77.58 35.05,77.54 CN11.10 ; C567.2 v1(98,156.07) ; CN4.6 v1(21.57,155.16) ; v1(49.78,62.92) 50.24,62.46 PC129.2 ; R781.1 v1(173.31,41) ; v1(153.63,97.27) 153.49,97.4 R687.2 ; v1(102.83,135.54) 102.25,135.54 C623.1 ; v1(147.66,167.62) 147.4,167.36 C7.1 ; PR196.1 60.47,67.2 v1(61.15,67.88) ; PJ2.2 29.5,65.82 29.63,65.94 v1(29.65,65.94) ; R585.2 v1(70.93,119.47) ; CN11.11 35.09,76.74 v1(34.88,76.95) ; R759.1 v1(216.24,50.66) ; v1(85.56,114.79) 84.82,114.06 PC102.1 ; v1(59.01,117.84) 58.76,118.09 C658.1 ; v1(234.53,71.36) 234.41,71.48 D32.2 ; C773.1 v1(222.08,43.93) ; C524.1 v1(61.51,165.8) ; v1(60.2,116.74) Y4.2 ; C732.2 v1(67.97,54.97) ; CN10.6 188.67,87.3 v1(188.2,86.83) ; Q36.2 v1(112.38,157.21) ; v1(58.25,111.62) 57.62,112.24 R634.2 ; C689.1 v1(217.64,95.23) ; R590.2 v1(68.7,118.46) ; C568.1 v1(111.08,155.69) ; C779.2 v1(224.49,41.64) ; R567.2 v1(24.46,121.13) ; C564.1 v1(108.92,158.11) ; v1(130.13,135.09) C631.2 ; v1(218.4,59.42) 218.14,59.17 218.14,58.68 C722.2 ; C699.1 v1(216.37,72.88) ; v1(105.42,135.52) C621.1 ; C589.2 v1(96.73,147.81) ; Y2.2 v1(99.49,143.84)
  BOTTOM w0.762: PC113.1 168.49,80.88 v2(168.87,81.26) ; v2(180.17,62.21) 179.82,62.57 PC128.1 ; PC141.1 203.49,50.83 v2(203.29,51.04)
  vias: v1(3.59,119.95) v1(4.61,113.06) v1(4.81,120.51) v1(4.79,119.85) v1(4.81,119.19) v1(13.45,148.68) v1(24.98,133.59) v1(24.98,131.3) v1(24.98,128.69) v1(25.1,127.03) v1(25.1,125.03) v1(26.5,103.23) v1(26.5,102.22) v1(27.26,129.27) v1(27.26,127.24) v1(27.24,120.15) v1(28.2,103.34) v1(29.63,164.51) v1(29.73,163.41) v1(29.73,161.51) v1(29.73,160.75) v1(29.73,159.86) v1(29.73,159.1) v1(29.73,156.53) v1(29.73,155.29) v1(30.19,156.1) v1(30.31,125.51) v1(30.26,46.47) v1(30.34,164.53) v1(30.59,123.81) v1(30.67,51.55) v1(30.95,126.98) v1(31.07,129.65) v1(31.15,48.8) v1(31.71,129.65) v1(31.63,116.14) v1(31.91,76.11) v1(31.91,75.5) v1(31.91,74.89) v1(32.24,71.69) v1(32.72,48.57) v1(32.95,47.43) v1(33.71,44.15) v1(33.99,69.45) v1(34.27,164.94) v1(34.74,82.13) v1(34.74,81.49) v1(34.74,80.86) v1(34.91,164.94) v1(35.44,144.36) v1(35.54,164.94) v1(35.92,132.77) v1(36.18,164.94) v1(36.53,119.01) v1(36.53,117.97) v1(36.53,116.57) v1(36.81,164.94) v1(37.17,119.01) v1(37.17,117.97) v1(37.17,116.57) v1(37.45,164.94) v1(37.47,151.8) v1(37.53,150.77) v1(37.52,95.54) v1(37.63,96.94) v1(37.7,152.37) v1(38.08,164.94) v1(38.11,135.22) v1(38.19,89.52) v1(38.19,88.88) v1(39.2,96) v1(40.62,100.01) v1(41.02,149.78) v1(41.04,147.4) v1(41.81,151.41) v1(41.87,119.11) v1(41.87,117.84) v1(41.87,116.8) v1(42.2,143.44) v1(43.14,113.9) v1(43.52,116.34) v1(44.56,152.24) v1(45.43,125.62) v1(45.81,72.63) v1(45.93,44.05) v1(46.06,125.64) v1(46.52,78.04) v1(47.2,44.05) v1(47.84,118.98) v1(48.09,117.31) v1(48.35,44.05) v1(48.47,119.62) v1(48.47,118.98) v1(48.73,117.31) v1(49.54,44.05) v1(50.02,153.23) v1(50.5,44.05) v1(50.56,150.64) v1(50.96,152.09) v1(51.27,44.05) v1(51.9,166.15) v1(52.66,166.1) v1(52.87,86.01) v1(53.43,165.85) v1(53.43,44.18) v1(53.53,108.57) v1(53.65,110.47) v1(54.19,165.59) v1(54.16,108.57) v1(54.29,110.47) v1(54.8,108.57) v1(54.92,110.47) v1(54.95,165.34) v1(55.08,44.21) v1(55.53,127.55) v1(55.58,110.47) v1(55.71,165.08) v1(55.94,128.9) v1(56.22,44.31) v1(56.47,164.7) v1(57.24,165.08) v1(57.36,44.21) v1(57.52,131.72) v1(57.44,127.12) v1(57.87,165.08) v1(58.25,79.44) v1(58.51,165.85) v1(58.51,44.21) v1(58.96,78.22) v1(60.28,130.22) v1(60.69,140.96) v1(60.79,79.26) v1(60.84,121.5) v1(61.27,75.02) v1(61.48,121.5) v1(62.09,140.78) v1(62.11,121.5) v1(62.21,142.51) v1(62.21,128.84) v1(62.44,153.53) v1(63.28,130.34) v1(63.43,170.9) v1(63.43,129.15) v1(63.59,101.84) v1(63.64,121.5) v1(64.07,141.98) v1(64.17,136.46) v1(64.27,121.5) v1(64.25,52.94) v1(64.6,94.09) v1(65.01,169.12) v1(65.62,101.84) v1(65.92,150.84) v1(65.87,52.43) v1(66.56,150.84) v1(66.56,121.5) v1(66.68,156.81) v1(67.7,121.5) v1(67.83,150.84) v1(68,80.93) v1(68.56,168.21) v1(68.87,165.49) v1(68.84,121.5) v1(69.68,74.41) v1(70.11,121.5) v1(71.08,153.4) v1(71.26,108.29) v1(71.38,121.5) v1(71.59,152.89) v1(71.97,160.13) v1(72.22,152.38) v1(72.2,109.76) v1(72.48,69.48) v1(72.45,65.11) v1(72.6,153.02) v1(72.65,121.5) v1(72.78,151.73) v1(72.96,129.76) v1(73.01,98.49) v1(72.98,67.8) v1(73.03,97.27) v1(73.29,152.49) v1(73.41,73.97) v1(73.49,153.53) v1(73.49,150.89) v1(73.54,151.73) v1(73.77,52.28) v1(74,152.51) v1(74.3,151.73) v1(74.38,52.31) v1(74.51,159.62) v1(74.51,156.83) v1(74.56,95.21) v1(74.63,152.43) v1(74.68,97.37) v1(74.94,150.97) v1(74.94,129.89) v1(74.99,52.31) v1(75.07,151.73) v1(75.19,133.77) v1(75.65,124.7) v1(75.65,123.81) v1(75.65,123.05) v1(75.65,95.23) v1(75.78,151.75) v1(75.78,74.15) v1(76.18,74.66) v1(76.41,127.21) v1(76.41,52.21) v1(76.44,125.74) v1(76.67,75.04) v1(77.07,159.62) v1(77.07,156.83) v1(77.3,151.11) v1(77.3,137) v1(77.35,133.06) v1(77.48,140.05) v1(77.48,138.9) v1(77.48,129.63) v1(77.48,128.49) v1(77.61,150.33) v1(77.61,146.27) v1(77.61,145.13) v1(77.61,143.98) v1(77.73,132.17) v1(77.86,137.63) v1(77.99,133.06) v1(78.11,151.1) v1(78.11,147.54) v1(78.11,130.78) v1(78.19,73.39) v1(78.37,143.48) v1(78.37,142.59) v1(78.37,141.44) v1(78.62,73.82) v1(79.61,159.65) v1(79.76,156.83) v1(81.77,156.83) v1(82.51,107.73) v1(82.64,48.12) v1(83.37,104.5) v1(84.44,107.68) v1(84.44,107.04) v1(84.9,69.63) v1(85.61,65.29) v1(86.32,67.93) v1(92.48,59.56) v1(93.05,125.71) v1(93.05,124.32) v1(93.43,70.85) v1(93.37,65.01) v1(93.37,59.56) v1(93.63,84.02) v1(93.81,125.08) v1(93.84,81.52) v1(94.07,162.95) v1(94.32,158.48) v1(94.32,65.01) v1(94.37,159.39) v1(94.45,81.52) v1(94.57,125.71) v1(94.57,124.32) v1(94.57,70.85) v1(95.08,65.01) v1(95.21,70.47) v1(95.89,166.53) v1(95.84,65.01) v1(96.48,62.85) v1(96.92,60.18) v1(97.28,77.83) v1(98.26,51.55) v1(99.65,51.55) v1(100.72,80.77) v1(100.8,51.55) v1(100.85,111.24) v1(101.01,113.88) v1(101.3,38.16) v1(101.78,80.74) v1(101.81,51.55) v1(101.76,38.16) v1(102.08,78.72) v1(102.19,154.03) v1(102.19,152.26) v1(102.19,150.48) v1(102.32,41.39) v1(102.32,40.24) v1(102.4,115.38) v1(102.57,116.95) v1(102.7,111.24) v1(102.83,109.61) v1(102.96,51.55) v1(103.51,113.78) v1(103.56,69.07) v1(103.72,118.83) v1(103.84,51.55) v1(103.97,152.26) v1(104.13,109.61) v1(104.68,65.08) v1(104.99,67.8) v1(105.27,103.87) v1(105.24,41.39) v1(105.24,40.24) v1(105.68,77.95) v1(105.75,152.26) v1(106.23,102.3) v1(106.41,131.71) v1(106.49,135.01) v1(106.51,133.99) v1(106.84,105.32) v1(107.15,133.59) v1(107.15,51.55) v1(107.52,80.74) v1(107.55,103.67) v1(107.78,134.07) v1(108.04,51.55) v1(108.26,101.36) v1(108.27,78.72) v1(108.8,153.07) v1(108.92,51.55) v1(109.59,102.78) v1(109.94,51.55) v1(110.45,77.95) v1(110.55,128.63) v1(111.08,153.02) v1(111.08,151.14) v1(111.07,104.2) v1(112,38.31) v1(112.15,38.01) v1(112.28,77.95) v1(112.58,81.51) v1(112.58,79.98) v1(113.5,134.35) v1(113.5,132.95) v1(114.13,123.89) v1(114.38,79.98) v1(114.46,118.6) v1(114.46,117.97) v1(114.51,115.05) v1(114.51,77.83) v1(115.1,117.97) v1(115.41,114.23) v1(115.78,122.13) v1(116.16,117.97) v1(116.16,52.69) v1(116.29,141.23) v1(116.49,122.13) v1(116.53,114.23) v1(116.81,132.48) v1(117,81.51) v1(117.04,115.22) v1(117.18,117.97) v1(117.18,52.69) v1(117.51,142.4) v1(117.51,69.58) v1(117.56,102.88) v1(117.81,100.92) v1(117.91,77.95) v1(117.94,131.25) v1(117.94,117.97) v1(117.97,68.01) v1(117.94,52.69) v1(118.37,165.03) v1(118.53,122.13) v1(118.7,117.97) v1(119.37,114.2) v1(119.59,117.97) v1(119.64,107.12) v1(119.64,52.69) v1(120.23,117.97) v1(120.2,69.33) v1(120.4,132.5) v1(120.4,131.76) v1(120.36,114.23) v1(120.54,122.15) v1(120.68,79.48) v1(120.68,77.95) v1(121.15,115.02) v1(121.17,52.69) v1(121.32,163.66) v1(121.24,105.77) v1(121.27,87.82) v1(121.5,132.57) v1(121.62,161.27) v1(121.7,117.97) v1(121.88,52.69) v1(122.34,102.19) v1(122.34,101.58) v1(122.34,100.97) v1(122.51,88.02) v1(122.53,81.51) v1(122.58,122.15) v1(122.58,79.61) v1(122.64,138.67) v1(122.64,136.38) v1(122.89,132.32) v1(122.94,160.56) v1(123.66,135.87) v1(123.73,132.55) v1(123.75,115.02) v1(124.34,132.39) v1(124.47,152) v1(124.47,151.37) v1(124.61,122.15) v1(124.56,114.2) v1(124.58,80.74) v1(124.58,79.98) v1(124.85,138.21) v1(125.08,139.25) v1(125.38,139.79) v1(125.48,138.21) v1(125.71,139.25) v1(125.82,117.84) v1(126.32,137.8) v1(126.53,104.78) v1(126.53,102.88) v1(126.48,101) v1(126.45,79.91) v1(126.64,122.15) v1(126.68,117.89) v1(126.96,60.44) v1(127.47,57.79) v1(128.1,103.54) v1(128.36,81.52) v1(128.36,80.76) v1(128.36,79.99) v1(128.74,125.08) v1(128.99,68.44) v1(129.17,67.85) v1(130.01,79.87) v1(130.08,103.67) v1(130.08,101.74) v1(130.13,77.05) v1(130.46,152.42) v1(130.62,57.21) v1(130.99,150.85) v1(131.07,152.41) v1(131.1,135.09) v1(131.12,120.33) v1(131.12,119.72) v1(131.38,60.31) v1(131.68,152.41) v1(131.66,150.86) v1(131.71,58.02) v1(131.78,81.51) v1(131.78,80.74) v1(131.78,79.98) v1(132.12,103.49) v1(132.12,101.58) v1(132.29,150.86) v1(133.14,138.79) v1(133.41,80.02) v1(133.44,59.93) v1(133.77,138.79) v1(133.87,62.24) v1(134.07,67.75) v1(134.1,65.69) v1(134.17,104.28) v1(134.25,102.4) v1(134.25,100.54) v1(134.83,135.9) v1(135.16,62.49) v1(135.57,103.26) v1(135.57,100.73) v1(135.59,98.79) v1(135.67,102.4) v1(136.48,131.81) v1(136.62,81.48) v1(136.62,79.96) v1(137.83,78.72) v1(139.89,77.66) v1(140.27,78.88) v1(141.08,81.22) v1(141.55,128.82) v1(141.68,77.95) v1(142.09,81.47) v1(142.1,79.64) v1(142.53,78.72) v1(143.69,82.24) v1(143.65,80.74) v1(143.65,79.98) v1(145.17,81.58) v1(145.19,79.93) v1(145.37,144.13) v1(145.73,134.07) v1(146.78,81.51) v1(146.78,79.98) v1(148.93,79.36) v1(148.88,77.95) v1(149.06,167.88) v1(150.93,78.72) v1(151.85,167.88) v1(152.18,81.51) v1(152.18,79.98) v1(152.49,77.92) v1(153.98,79.98) v1(154.77,158.43) v1(154.77,103.23) v1(155.91,103.23) v1(156.73,80.1) v1(158.05,122.69) v1(163.08,90) v1(163.51,76.77) v1(163.51,76.16) v1(163.52,74.89) v1(163.53,84.18) v1(163.53,83.3) v1(163.53,82.41) v1(172.35,49.26) v1(173.62,38.67) v1(176.31,107.5) v1(176.62,49.72) v1(176.87,82.84) v1(183.47,98.56) v1(186.04,78.62) v1(187.92,38.46) v1(188.38,38.62) v1(190.03,60.66) v1(193.38,94.62) v1(194.24,94.19) v1(196.55,89.52) v1(201.94,64.35) v1(202.83,83.55) v1(204.81,83.55) v1(205.19,65.64) v1(214.08,87.61) v1(214.08,85.96) v1(214.08,84.31) v1(214.16,91.96) v1(215.4,89.65) v1(215.38,87.64) v1(215.6,84.31) v1(215.73,85.96) v1(216.39,91.88) v1(217.38,85.96) v1(217.38,84.31) v1(217.48,89.65) v1(223.73,70.09) v1(223.83,87.33) v1(224.8,94.6) v1(227.67,80.12) v1(227.92,68.31) v1(228.91,99.35) v1(228.91,75.8) v1(229.02,94.73) v1(229.57,85.71) v1(229.57,83.04) v1(230.21,86.98) v1(230.21,84.31) v1(230.46,81.75) v1(230.84,92.44) v1(230.84,90.48) v1(231.48,90.41) v1(232.88,20.81) v1(232.88,12.46) v1(233.46,99.17) v1(233.51,40.12) v1(233.51,38.34) v1(233.64,41.77) v1(234.53,89.26) v1(234.53,49.26) v1(235.01,41.41) v1(235.04,40.12) v1(235.04,38.34) v1(235.16,90.03) v1(236.1,63.15) v1(236.05,38.34) v1(236.19,3.53) v1(236.2,2.8) v1(236.43,148.14) v1(236.56,41.39) v1(236.56,40.12) v1(236.76,140.57) v1(237.3,62.62) v1(237.83,100.97) v1(241.92,123.83) v1(241.84,3.34) v1(242.5,2.93) v1(243.11,58.43) v1(243.26,61.19) v1(243.29,52.94) v1(243.72,117.28) v1(247.07,123.83) v2(0.82,128.2) v2(0.95,122.62) v2(0.95,120.96) v2(0.95,118.42) v2(0.95,115.88) v2(0.95,113.34) v2(0.95,110.8) v2(3.51,110.8) v2(5.42,138.03) v2(6.31,140.57) v2(6.94,142.99) v2(7.32,110.8) v2(7.45,145.78) v2(7.83,148.32) v2(8.06,168.08) v2(8.04,160.89) v2(8.04,158.35) v2(8.04,155.81) v2(8.04,153.27) v2(8.09,150.86) v2(8.19,126.86) v2(8.19,126.09) v2(8.21,123.81) v2(9.86,110.8) v2(11.49,148.83) v2(11.49,148.07) v2(11.49,147.3) v2(12.25,148.83) v2(12.25,148.07) v2(12.25,147.3) v2(12.4,110.8) v2(14.94,110.8) v2(17.48,110.8) v2(18.6,123.55) v2(19.14,122.54) v2(19.34,123.55) v2(19.9,122.54) v2(20.02,110.8) v2(20.05,123.55) v2(22.56,110.8) v2(22.72,168.11) v2(24.22,109.2) v2(24.22,107.17) v2(24.22,104.63) v2(24.22,102.09) v2(24.22,99.55) v2(24.34,44.94) v2(27.24,88.63) v2(27.24,86.09) v2(27.24,83.55) v2(27.24,81.01) v2(27.24,78.47) v2(27.24,75.93) v2(27.24,73.39) v2(27.24,70.85) v2(27.24,68.31) v2(27.24,65.77) v2(27.24,63.23) v2(27.24,60.69) v2(27.24,58.15) v2(27.24,55.61) v2(27.24,53.07) v2(27.24,50.53) v2(27.24,47.99) v2(27.24,45.45) v2(29.42,146.03) v2(29.42,145.14) v2(29.42,144.26) v2(29.55,135.72) v2(29.55,134.96) v2(29.93,73.14) v2(29.93,72.12) v2(29.93,71.1) v2(29.93,69.96) v2(30.18,136.13) v2(30.18,135.37) v2(30.18,134.6) v2(30.31,146.03) v2(30.31,145.14) v2(30.31,144.26) v2(30.82,172.96) v2(30.82,168.59) v2(31.27,73.14) v2(31.27,72.21) v2(31.27,71.21) v2(31.84,39.35) v2(32.85,41.26) v2(33.04,173.58) v2(34.88,41.79) v2(35.58,173.58) v2(37.42,41.79) v2(38.12,173.58) v2(39.2,98.15) v2(39.2,97.01) v2(39.84,98.66) v2(39.84,97.52) v2(39.84,96.55) v2(39.96,41.79) v2(40.66,173.58) v2(40.65,96.22) v2(42.5,41.79) v2(42.6,100.01) v2(43.2,173.58) v2(45.04,41.79) v2(45.74,173.58) v2(46.19,76.06) v2(46.95,76.06) v2(47.1,69.68) v2(47.1,68.94) v2(47.23,67.67) v2(47.58,41.79) v2(47.71,76.06) v2(47.81,69.68) v2(47.81,68.92) v2(47.84,93.46) v2(47.89,67.29) v2(48.28,173.58) v2(49.87,93.35) v2(50.12,41.79) v2(50.17,92.44) v2(50.82,173.58) v2(51.09,93.41) v2(51.44,92.49) v2(51.9,83.75) v2(51.88,82.38) v2(51.9,81.29) v2(51.93,80.32) v2(52.46,93.35) v2(52.69,92.52) v2(52.66,84.24) v2(52.66,41.79) v2(52.74,83.14) v2(52.89,80.83) v2(52.94,81.77) v2(53.16,74.27) v2(53.36,173.58) v2(53.4,83.78) v2(53.4,82.48) v2(53.68,93.38) v2(53.91,75.06) v2(54.01,92.49) v2(53.96,81.67) v2(53.98,80.93) v2(53.96,80.17) v2(54.9,93.35) v2(55.2,41.79) v2(55.25,92.44) v2(55.51,91.27) v2(55.46,90.18) v2(55.9,173.58) v2(56.47,78.65) v2(57.24,52.05) v2(57.74,41.79) v2(58.02,52.05) v2(58.44,173.58) v2(58.73,52.05) v2(59.45,78.99) v2(59.62,78.22) v2(59.91,91.85) v2(60.13,79.21) v2(60.28,78.5) v2(60.28,41.79) v2(60.54,93.28) v2(60.84,92.36) v2(60.98,173.58) v2(60.99,78.6) v2(61.05,76.18) v2(61.63,93.28) v2(61.55,76.69) v2(62.04,92.39) v2(62.57,93.79) v2(62.82,41.79) v2(63.59,173.59) v2(63.94,93.79) v2(64.7,91.53) v2(64.83,93.05) v2(65.21,92.19) v2(65.24,93.71) v2(65.24,90.76) v2(65.36,41.79) v2(66,173.59) v2(67.78,171.56) v2(67.9,41.79) v2(70.32,171.56) v2(70.44,41.79) v2(72.09,168.39) v2(72.09,166.35) v2(72.98,164.83) v2(72.98,41.79) v2(74.76,165.08) v2(75.52,41.79) v2(78.06,41.79) v2(80.6,41.79) v2(83.14,41.79) v2(85.68,41.79) v2(86.45,165.08) v2(88.22,41.79) v2(88.48,164.83) v2(89.37,168.39) v2(89.37,166.35) v2(90.76,41.79) v2(91.27,171.56) v2(93.3,41.79) v2(94.32,169.91) v2(96.73,169.91) v2(100.08,36.03) v2(100.92,166.73) v2(102.62,36.03) v2(105.16,36.03) v2(107.7,36.03) v2(110.24,36.03) v2(112.78,36.03) v2(115.32,36.03) v2(115.78,166.73) v2(115.86,37.91) v2(118.32,170.14) v2(118.4,37.91) v2(119.74,146.16) v2(120.51,145.45) v2(120.61,170.14) v2(121.01,146.19) v2(120.94,37.91) v2(121.09,144.89) v2(121.83,145.53) v2(122.01,146.41) v2(122.72,145.14) v2(122.77,146.8) v2(122.77,146.03) v2(122.74,144.43) v2(123.15,170.14) v2(123.28,150.86) v2(123.48,37.91) v2(124.04,150.86) v2(124.55,167.62) v2(125.43,173.08) v2(125.43,169.53) v2(125.43,165.21) v2(126.02,37.91) v2(126.32,161.22) v2(128.56,37.91) v2(131.1,37.91) v2(133.64,37.91) v2(136.18,37.91) v2(137.83,148.78) v2(137.78,147.33) v2(138.24,148.04) v2(138.72,37.91) v2(138.74,148.73) v2(138.79,147.33) v2(139.25,148.07) v2(139.68,148.78) v2(139.68,147.38) v2(140.17,148.12) v2(140.65,147.35) v2(141.26,37.91) v2(141.56,165.85) v2(141.69,173.08) v2(141.69,169.4) v2(142.12,144.76) v2(142.27,146.08) v2(142.45,167.62) v2(142.83,146.54) v2(142.83,144.76) v2(143.65,144.51) v2(143.8,37.91) v2(145.4,144.79) v2(145.73,36.03) v2(148.27,36.03) v2(150.81,36.03) v2(153.35,36.03) v2(155.89,36.03) v2(157.03,167.88) v2(157.03,165.34) v2(157.03,162.8) v2(157.03,160.26) v2(157.03,157.72) v2(157.03,155.18) v2(157.03,152.64) v2(157.03,150.1) v2(157.03,147.56) v2(157.24,145.31) v2(157.54,143.29) v2(158.05,140.95) v2(158.43,36.03) v2(158.67,138.77) v2(159.6,136.25) v2(160.51,134.22) v2(160.97,36.03) v2(161.4,132.32) v2(162.7,130.16) v2(163.51,36.03) v2(164.63,127.47) v2(166.05,36.03) v2(167.23,124.87) v2(168.59,36.03) v2(169.05,123.4) v2(169.88,64.55) v2(169.86,63.84) v2(170.6,64.58) v2(170.62,63.84) v2(171.13,36.03) v2(171.26,64.22) v2(171.33,121.4) v2(171.79,50.66) v2(173.19,119.36) v2(173.67,36.03) v2(174.46,117.74) v2(175.09,51.67) v2(175.09,50.91) v2(175.7,81.9) v2(175.7,81.16) v2(175.85,115.6) v2(175.85,51.67) v2(175.85,50.91) v2(176.46,81.87) v2(176.46,81.16) v2(176.62,51.67) v2(176.62,50.91) v2(177.02,113.45) v2(177.22,81.87) v2(177.22,81.14) v2(177.38,51.67) v2(177.38,50.91) v2(177.63,104.38) v2(177.63,103.62) v2(177.63,102.85) v2(177.89,81.52) v2(178.14,111.11) v2(179.1,104.35) v2(179.1,103.59) v2(179.49,108.82) v2(181.19,106.54) v2(181.57,103.62) v2(183.32,78.57) v2(183.32,77.83) v2(183.32,77.07) v2(183.6,101.46) v2(184.16,78.57) v2(184.16,77.83) v2(184.13,77.05) v2(184.34,50.76) v2(184.9,62.24) v2(185,78.57) v2(185,77.81) v2(185,77.05) v2(185.91,62.24) v2(186.27,58.91) v2(186.78,62.26) v2(186.9,59.57) v2(187.28,58.91) v2(187.79,62.32) v2(187.92,59.5) v2(188.43,58.91) v2(188.78,62.34) v2(189.06,66.53) v2(189.06,65.62) v2(189.06,64.78) v2(189.06,59.47) v2(189.57,58.89) v2(189.7,62.32) v2(189.82,36.03) v2(189.95,66.23) v2(189.95,65.21) v2(189.95,59.5) v2(190.59,62.32) v2(190.59,59.12) v2(190.71,65.74) v2(191.37,70.37) v2(192.49,36.03) v2(193.43,98.66) v2(194.27,76.77) v2(195.03,76.77) v2(195.03,36.03) v2(196.27,97.85) v2(197.57,36.03) v2(199.73,97.14) v2(200.11,36.03) v2(200.75,61.83) v2(200.87,59.67) v2(201,58.53) v2(201.13,61.2) v2(201.58,58.99) v2(201.74,61.76) v2(201.76,60.69) v2(202.14,96.73) v2(202.14,58.4) v2(202.52,59.8) v2(202.49,45.22) v2(202.65,36.03) v2(202.98,44.69) v2(203.46,45.22) v2(203.56,67.14) v2(203.56,66.4) v2(203.56,55.74) v2(203.56,54.59) v2(203.95,44.69) v2(204.42,45.22) v2(204.68,96.63) v2(205.19,36.03) v2(207.22,96.58) v2(207.73,36.03) v2(209.76,96.66) v2(210.27,36.03) v2(212.17,96.77) v2(212.81,36.03) v2(214.84,96.89) v2(215.35,36.03) v2(217.53,97.25) v2(217.89,36.03) v2(219.94,97.87) v2(220.43,36.03) v2(222.1,98.59) v2(223.1,34.91) v2(224.21,32.37) v2(224.21,29.57) v2(224.21,26.65) v2(224.49,99.65) v2(226.53,24.04) v2(226.7,100.89) v2(228.84,102.32) v2(229.32,23.89) v2(230.83,104.03) v2(231.2,21.83) v2(231.2,19.03) v2(231.2,16.49) v2(231.2,13.95) v2(231.2,11.41) v2(231.2,8.87) v2(231.2,6.33) v2(231.2,3.79) v2(232.11,0.85) v2(232.62,105.83) v2(234.16,107.77) v2(234.65,0.85) v2(235.64,109.89) v2(236.38,136.69) v2(236.51,153.45) v2(236.43,100.19) v2(236.85,112.18) v2(237.02,135.39) v2(237.07,67.04) v2(237.19,0.85) v2(237.45,85.45) v2(237.45,78.47) v2(237.58,134.1) v2(237.77,114.26) v2(238.46,153.4) v2(238.46,131.68) v2(238.52,116.6) v2(239.02,129.12) v2(239.13,119.22) v2(239.23,80.63) v2(239.4,126.84) v2(239.35,83.25) v2(239.48,152.89) v2(239.44,121.72) v2(239.53,124.49) v2(239.61,65.24) v2(239.73,0.85) v2(241.89,83.25) v2(242.02,130.24) v2(242.02,80.63) v2(242.27,0.85) v2(242.66,65.24) v2(242.78,130.24) v2(243.42,152.89) v2(243.8,137.4) v2(244.69,83.25) v2(244.69,80.63) v2(244.81,154.29) v2(245.14,65.24) v2(246.16,62.85) v2(246.16,59.42) v2(246.16,56.88) v2(246.16,54.34) v2(246.16,51.8) v2(246.16,49.26) v2(246.16,46.59) v2(246.16,44.05) v2(246.16,41.51) v2(246.16,38.97) v2(246.16,36.43) v2(246.16,33.89) v2(246.85,105.39) v2(247.56,116.06) v2(247.56,113.52) v2(247.56,110.98) v2(247.56,108.44) v2(247.99,154.29) v2(247.99,127.62) v2(249.39,106.92) v2(249.39,103.36) v2(249.39,100.82) v2(249.56,126.37) v2(249.56,123.83) v2(249.56,121.29) v2(249.56,118.75) v2(249.56,117.08) v3(186.14,61.07)
