# Allegro board DA0Z8CMB8D0-D-gina-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VMA_DM0: length 24.1
  TOP w0.127: U13.E7 61.73,142.95 61.73,141.33 v1(61.67,141.27)
  IN1 w0.14: v1(61.67,141.27) 61.67,141 61.28,140.61 60.95,140.61 60.87,140.53 60.51,140.53 59.98,141.06 59.7,141.06 59.3,140.66 58.75,140.66 58.59,140.81 58.38,140.81 58.23,140.66 57.41,140.66 57.19,140.88 57.19,142.06 57.04,142.21 56.78,142.21 56.69,142.12 56.69,140.17 56.82,140.05 57.16,140.05 57.29,139.92 57.29,139.59 56.57,138.87 56.04,138.87 55.91,138.74 55.91,138.46 56.04,138.34 56.52,138.34 56.65,138.21 56.65,137.76 55.29,136.41 53.96,136.41 53.74,136.19 52.58,136.19 v1(51.68,135.29)
  BOTTOM w0.127: U41.E7 61.77,139.79 61.6,139.79 61.53,139.86 61.53,141.13 v1(61.67,141.27) ; U43.D19 51.3,134.91 v1(51.68,135.29)
VMA_DM1: length 20.2
  TOP w0.127: v1(61.84,129.4) 61.84,131.19 U16.E7
  IN1 w0.102: 54.06,128.76 54.06,130.16 53.47,130.75 53.04,130.75 52.79,130.5 52.12,130.5 51.87,130.75 51.29,130.75 v1(50.89,131.14)
  IN1 w0.14: v1(61.84,129.4) 61.27,127.52 61.03,127.28 59.32,126.46 55.99,126.46 54.82,127.63 54.82,128 54.06,128.76
  BOTTOM w0.127: v1(61.84,129.4) 61.53,129.09 61.53,128.11 61.66,127.98 61.83,127.98 U44.E7 ; U43.D14 51.27,130.76 v1(50.89,131.14)
VMA_DM2: length 18.8
  TOP w0.127: U16.D3 61,128.08 60.84,128.24 60.84,129.51 v1(60.72,129.63)
  IN3 w0.102: v1(60.72,129.63) 60.72,130.01 60.84,130.14 61.68,130.14 61.81,130.27 61.81,130.72 61.68,130.85 54.42,130.85 54.24,131.03 54.24,132.13 v1(54.85,132.74)
  BOTTOM w0.102: U43.C17 52.1,133.53 52.2,133.63 53.13,133.63 53.35,133.42 53.91,133.42 54.59,132.74 v1(54.85,132.74)
  BOTTOM w0.127: v1(60.72,129.63) 60.72,130.87 U44.D3
VMA_DM3: length 20.7
  TOP w0.127: U13.D3 61.13,141.38 v1(60.97,141.54)
  IN3 w0.102: v1(60.97,141.54) 61.17,141.74 61.73,141.74 61.86,141.87 61.86,142.18 61.73,142.31 59.8,142.31 59.06,141.57 58.56,141.57 58.18,141.19 56.91,141.19 56.78,141.06 56.78,140.55 56.65,140.43 56.4,140.43 56.27,140.55 56.27,141.06 56.14,141.19 55.74,141.19 55.66,141.11 55.66,138.47 55.33,138.14 54.71,138.14 54.24,138.62 54.24,138.9 54.12,139.02 52.89,139.02 52.79,138.92 52.79,138.06 v1(52.5,137.77)
  BOTTOM w0.127: v1(52.5,137.77) 52.1,137.37 U43.C22 ; U41.D3 60.97,142.99 v1(60.97,141.54)
VMA_DM4: length 25.1
  TOP w0.111: v1(49.92,150.79) 49.11,149.98 48.69,149.98 U12.E7
  IN1 w0.102: 43.77,142.35 43.75,142.33 43.75,141.78 43.46,141.49 43.22,141.49 42.99,141.27 42.99,139.05 v1(43.39,138.64)
  IN1 w0.14: v1(49.92,150.79) 49.92,150.48 49.01,149.57 48.65,149.57 48.43,149.35 47.34,149.35 46.46,148.47 46.06,148.47 45.91,148.62 44.76,148.62 43.93,147.79 43.93,146.87 44.05,146.75 44.76,146.75 44.89,146.62 44.89,145.7 44.76,145.58 44.08,145.58 43.95,145.45 43.95,145.07 44.08,144.94 44.54,144.94 44.66,144.81 44.66,144.48 44.54,144.36 44.08,144.36 43.95,144.23 43.95,143.7 44.31,143.34 44.31,142.89 43.77,142.35
  BOTTOM w0.127: v1(43.39,138.64) 43.39,138.88 43.21,139.06 U43.P24 ; U39.E7 50.4,150.2 49.92,150.68 v1(49.92,150.79)
VMA_DM5: length 24.7
  TOP w0.111: v1(37.97,150.3) 37.87,150.2 U11.E7
  IN1 w0.14: v1(39.28,139.45) 38.89,139.06 38.68,139.06 38.57,139.17 38.57,139.74 38.71,139.88 39.01,139.88 39.11,139.98 39.11,140.2 38.53,140.78 38.26,140.78 38.03,140.55 37.7,140.55 37.47,140.78 36.23,140.78 36.13,140.88 36.13,141.15 36.23,141.25 36.97,141.25 37.07,141.35 37.07,141.56 36.53,142.1 36.28,142.1 35.7,141.51 35.5,141.51 34.58,142.43 34.58,142.71 34.86,142.99 34.86,143.49 34.58,143.77 34.58,144.13 35.26,144.81 35.47,144.81 37.71,147.06 37.71,148.06 37.47,148.29 37.47,148.62 37.71,148.86 37.71,150.04 v1(37.97,150.3)
  BOTTOM w0.127: U38.E7 39.8,150.2 38.07,150.2 v1(37.97,150.3) ; U43.W24 39.04,138.9 39.23,138.9 39.28,138.96 v1(39.28,139.45)
VMA_DM6: length 20
  TOP w0.102: v1(38.57,149.64) 38.74,149.82 38.95,149.82 39.02,149.74 39.02,149.26 39.15,149.13 39.67,149.13 39.8,149.26 U11.D3
  IN3 w0.102: v1(36.21,143.91) 36.21,143.57 36.3,143.48 36.62,143.48 36.74,143.6 36.74,144.36 36.61,144.49 35.88,144.49 35.77,144.59 35.77,144.84 35.87,144.94 36.25,144.94 36.38,145.07 36.38,145.39 36.51,145.52 36.76,145.52 36.89,145.39 36.89,145.07 37.02,144.94 37.17,144.94 38.41,146.19 38.41,146.77 38.54,146.9 38.91,146.9 39.03,147.02 39.03,149.52 38.91,149.64 v1(38.57,149.64)
  BOTTOM w0.102: U43.AA25 36.8,140.26 36.8,141.77 36.71,141.85 36.71,143.41 v1(36.21,143.91)
  BOTTOM w0.127: U38.D3 36.84,149.64 v1(38.57,149.64)
VMA_DM7: length 21.1
  TOP w0.111: v1(50.41,149.26) 51,149.85 51.22,149.85 51.39,149.68 U12.D3
  IN3 w0.102: v1(43.32,144.1) 43.39,144.18 47.64,144.18 48.48,145.02 48.48,146.29 49.23,147.05 49.23,148.29 50.2,149.26 v1(50.41,149.26)
  BOTTOM w0.102: 41.46,143.75 40.06,142.35 40.06,140.32 U43.U25
  BOTTOM w0.127: U39.D3 48.52,149.35 50.32,149.35 v1(50.41,149.26)
  BOTTOM w0.178: v1(43.32,144.1) 43.11,143.9 41.61,143.9 41.46,143.75
VMA_DQ0: length 23
  TOP w0.102: v1(62.34,138.75) 62.73,139.14 U13.F2
  IN1 w0.14: v1(50.9,133.68) 51.28,134.05 52.26,134.05 52.66,134.46 56.4,134.46 57.54,135.6 61.81,135.6 61.93,135.73 61.93,135.98 61.81,136.11 59.32,136.11 59.19,136.24 59.19,136.49 59.32,136.62 59.83,136.62 59.95,136.74 59.95,137.22 60.08,137.35 60.33,137.35 60.46,137.22 60.46,136.74 60.59,136.62 60.84,136.62 60.97,136.74 60.97,137.97 61.36,138.36 61.7,138.36 62.1,138.75 v1(62.34,138.75)
  BOTTOM w0.127: U43.E18 50.67,134.08 50.9,133.85 v1(50.9,133.68) ; v1(62.34,138.75) 62.73,139.14 U13.F2
VMA_DQ1: length 23.8
  TOP w0.127: U13.E3 61.93,139.94 v1(62.33,139.55)
  IN1 w0.14: v1(49.23,133.66) 49.9,134.33 52.14,134.33 52.62,134.82 53.56,134.82 54.02,135.27 56.63,135.27 58,136.64 58.2,136.64 58.3,136.53 58.3,136.1 58.45,135.95 58.68,135.95 58.81,136.08 58.81,137.25 58.73,137.33 58.73,137.33 58.48,137.58 58.48,137.58 58.05,138.01 58.05,138.64 58.35,138.95 58.61,138.95 58.71,138.85 58.71,138.41 58.8,138.32 59.32,138.32 59.45,138.19 59.45,137.76 59.57,137.63 59.83,137.63 59.95,137.76 59.95,138.9 60.08,139.03 60.33,139.03 60.46,138.9 60.46,138.65 60.59,138.52 60.84,138.52 60.97,138.65 60.97,139.16 61.1,139.28 62.06,139.28 v1(62.33,139.55)
  BOTTOM w0.127: v1(62.33,139.55) 62.73,139.95 U41.F7 ; U43.F18 49.65,134.08 v1(49.23,133.66)
VMA_DQ2: length 26.4
  TOP w0.102: v1(63.92,140.4) 64.33,139.99
  TOP w0.127: 64.33,139.99 U13.H3
  IN1 w0.14: v1(63.92,140.4) 64.3,140.4 64.42,140.27 64.42,138.42 64.3,138.29 63.29,138.29 63.16,138.17 63.16,137.3 63.29,137.17 63.61,137.17 63.74,137.04 63.74,136.81 63.61,136.69 63.08,136.69 62.95,136.56 62.95,136.28 63.08,136.15 63.59,136.15 63.71,136.03 63.71,135.75 63.59,135.62 63.08,135.62 62.95,135.49 62.95,135.21 63.08,135.09 63.84,135.09 63.97,134.96 63.97,134.71 63.84,134.59 57.55,134.59 56.18,133.22 54.21,133.22 53.88,133.54 51.85,133.54 51.12,132.82 v1(50.87,132.82)
  BOTTOM w0.127: v1(63.92,140.4) 64.33,139.99 U13.H3 ; v1(50.87,132.82) 50.5,132.45 U43.E16
VMA_DQ3: length 25.5
  TOP w0.102: U13.G2 v1(63.93,139.55)
  IN1 w0.102: v1(50.08,133.61) 50.42,133.26 51.17,133.26
  IN1 w0.14: 51.17,133.26 51.7,133.8 52.64,133.8 52.92,134.08 54.05,134.08 54.57,133.56 56.01,133.56 57.55,135.09 62.37,135.09 62.49,135.22 62.49,137.04 62.37,137.17 62.11,137.17 61.99,137.04 61.99,136.59 61.86,136.46 61.6,136.46 61.48,136.59 61.48,137.7 61.81,138.03 62.41,138.03 62.83,138.44 62.83,138.67 62.95,138.79 63.33,138.79 63.46,138.92 63.46,139.28 63.33,139.4 62.95,139.4 62.83,139.53 62.83,139.87 62.96,140 63.48,140 v1(63.93,139.55)
  BOTTOM w0.127: v1(63.93,139.55) U41.H8 ; U43.F17 49.71,133.24 v1(50.08,133.61)
VMA_DQ4: length 22.1
  TOP w0.102: U13.H7 64.28,143.15 v1(63.82,142.7)
  IN1 w0.102: 54.16,136.84 53.86,136.84 53.55,136.53 52.56,136.53 52.16,136.13 v1(51.71,136.13)
  IN1 w0.14: 54.16,136.84 55.11,136.84 55.52,137.25 55.52,139.06 56.27,139.81 56.27,142.46 56.65,142.84 57.41,142.84 57.67,142.59 57.67,141.21 57.82,141.06 58.1,141.06 58.25,141.21 58.25,141.59 58.36,141.7 59.19,141.7 59.57,142.08 62.75,142.08 62.87,142.21 62.87,142.46 63,142.59 63.71,142.59 v1(63.82,142.7)
  BOTTOM w0.127: v1(63.82,142.7) 64.28,143.15 U13.H7 ; v1(51.71,136.13) U43.D20
VMA_DQ5: length 19.4
  TOP w0.127: v1(62.32,143.54) 62.71,143.15 U13.F7
  IN1 w0.14: v1(51.69,136.96) 51.98,137.25 51.98,137.87 52.78,138.67 53.94,138.67 55.25,139.99 55.25,142.97 56.57,144.28 58.2,144.28 58.45,144.03 58.45,143.32 58.68,143.09 61.23,143.09 61.44,143.3 61.44,143.76 61.6,143.93 62.16,143.93 62.32,143.77 v1(62.32,143.54)
  BOTTOM w0.127: v1(51.69,136.96) 51.69,136.96 U43.D21 ; U41.E3 61.93,143.29 62.18,143.54 v1(62.32,143.54)
VMA_DQ6: length 22.6
  TOP w0.127: v1(63.94,143.53) 64.33,143.93 U13.H8
  IN1 w0.102: v1(50.09,136.11) 50.54,136.56 52,136.56 52.79,137.35 53.68,137.35 53.73,137.3 54.16,137.3
  IN1 w0.14: v1(63.94,143.53) 63.45,143.04 61.79,143.04 61.33,142.59 59.3,142.59 58.9,142.19 58.34,142.19 58.15,142.38 58.15,142.87 57.54,143.48 56.52,143.48 55.76,142.71 55.76,139.79 55.18,139.2 55.18,137.91 54.57,137.3 54.16,137.3
  BOTTOM w0.127: v1(63.94,143.53) 63.53,143.93 U41.G2 ; U43.F20 49.7,135.72 v1(50.09,136.11)
VMA_DQ7: length 22.2
  TOP w0.127: U13.F8 62.73,143.94 63.16,143.52 v1(63.16,143.54)
  IN1 w0.102: v1(50.05,136.96) 51.25,138.16 51.88,138.16 52.72,139 53.55,139 53.73,139.18 53.73,140.14
  IN1 w0.14: 53.73,140.14 53.73,141.39 54.7,142.35 54.7,143.14 55.23,143.68 56.42,144.87 59.5,144.87 59.62,144.75 59.62,144.13 59.75,144 60.08,144 60.21,144.13 60.21,144.75 60.33,144.87 62.08,144.87 62.69,144.26 62.69,143.98 63.16,143.52 v1(63.16,143.54)
  BOTTOM w0.127: U13.F8 62.73,143.94 63.16,143.52 v1(63.16,143.54) ; v1(50.05,136.96) 50.45,136.56 U43.E21
VMA_DQ8: length 20
  TOP w0.127: v1(63.12,131.68) 62.73,132.06 U16.F8
  IN1 w0.14: v1(63.12,131.68) 63.12,131.99 62.99,132.12 59.52,132.12 59.45,132.05 58.76,132.05 58.63,131.92 58.63,131.51 58.76,131.38 59.44,131.38 59.57,131.25 59.57,130.74 59.44,130.62 57.62,130.62 57.49,130.49 57.49,129.78 57.36,129.65 56.9,129.65 56.78,129.78 56.78,130.9 56.61,131.06 55.07,131.06 54,132.13 51.06,132.13 v1(50.91,131.98)
  BOTTOM w0.127: U16.F8 62.73,132.06 v1(63.12,131.68) ; v1(50.91,131.98) 50.91,131.98 50.91,131.98 50.91,131.99 50.65,131.99 50.5,131.84 U43.E15
VMA_DQ9: length 19.8
  TOP w0.127: v1(63.92,132.47) 64.3,132.08 U16.H8
  IN1 w0.14: v1(51.74,132.81) 52.21,133.29 52.75,133.29 53.23,132.81 54.1,132.81 55.05,131.86 56.45,131.86 56.91,132.32 56.91,133 57.74,133.84 58.02,133.84 58.15,133.71 58.15,133.41 58.28,133.29 58.53,133.29 58.66,133.41 58.66,133.86 58.78,133.99 59.53,133.99 59.7,133.82 59.7,133.44 59.83,133.32 60.08,133.32 60.21,133.44 60.21,133.86 60.33,133.99 63.29,133.99 63.43,133.84 63.43,132.95 v1(63.92,132.47)
  BOTTOM w0.127: U44.G2 63.53,132.09 v1(63.92,132.47) ; U43.D15 51.69,131.99 51.69,132.76 v1(51.74,132.81)
VMA_DQ10: length 21.4
  TOP w0.127: v1(63.77,130.74) 64.31,131.28 U16.H7
  IN1 w0.102: 53.2,132.4 50.49,132.4 v1(50.07,131.99) ; v1(63.77,130.74) 63.65,130.85 63.1,130.85 62.98,130.98 62.98,131.15 63.1,131.28 63.39,131.28 63.52,131.4 63.52,132.06
  IN1 w0.14: 63.52,132.06 63.52,132.29 62.89,132.92 62.35,132.92 61.98,132.55 61.35,132.55 60.98,132.92 60.55,132.92 60.16,132.52 59.72,132.52 59.33,132.92 58.63,132.92 58.51,132.79 58.51,132.55 58.38,132.42 58.05,132.42 57.92,132.55 57.92,132.79 57.79,132.92 57.5,132.92 57.36,132.78 57.36,132.17 56.67,131.48 55.06,131.48 54.06,132.48 53.27,132.48 53.2,132.4
  BOTTOM w0.127: U16.H7 64.31,131.28 v1(63.77,130.74) ; U43.F15 49.68,131.6 v1(50.07,131.99)
VMA_DQ11: length 22.7
  TOP w0.102: v1(62.32,131.69) U16.F7
  IN1 w0.102: 51.26,131.55 49.8,131.55 49.67,131.41 49.67,131.33 49.79,131.21 50.28,131.21 50.37,131.12 50.37,130.93 50.37,130.92 50.28,130.83 49.79,130.83 49.67,130.7 49.67,130.5 49.82,130.35 v1(50.09,130.35)
  IN1 w0.14: v1(62.32,131.69) 62.43,131.69 62.67,131.45 62.67,131.23 62.53,131.09 61.35,131.09 61.22,130.96 61.22,130.78 61.1,130.65 60.84,130.65 60.72,130.78 60.72,131.16 60.62,131.25 60.21,131.25 60.08,131.12 60.08,130.65 59.7,130.27 58.38,130.27 58.23,130.11 58.23,129.07 58.13,128.97 56.62,128.97 56.37,129.23 56.37,130.49 56.14,130.72 54.88,130.72 53.75,131.85 51.56,131.85 51.26,131.55
  BOTTOM w0.127: v1(62.32,131.69) 61.93,131.3 U44.E3 ; U43.F13 v1(50.09,130.35)
VMA_DQ12: length 20.5
  TOP w0.127: U16.H3 64.33,128.12 v1(63.97,128.49)
  IN1 w0.102: v1(52.51,129.52) 52.92,129.92 53.48,129.92 53.81,129.6 53.81,128.51
  IN1 w0.14: v1(63.97,128.49) 63.84,128.36 62.11,128.36 61.86,128.11 61.86,127.19 61.96,127.09 61.96,125.75 61.6,125.39 60.41,125.39 60.28,125.52 60.28,125.95 60.16,126.08 59.83,126.08 59.7,125.95 59.7,125.52 59.57,125.39 58.61,125.39 58.43,125.57 58.43,125.82 58.3,125.95 58.05,125.95 57.92,125.82 57.92,125.7 57.79,125.57 57.54,125.57 57.41,125.7 57.41,125.82 57.29,125.95 56.02,125.95 53.81,128.16 53.81,128.51
  BOTTOM w0.127: U16.H3 64.33,128.12 v1(63.97,128.49) ; v1(52.51,129.52) 52.49,129.52 U43.C13
VMA_DQ13: length 19.5
  TOP w0.127: U16.E3 61.93,128.05 v1(62.33,127.66)
  IN1 w0.14: v1(53.29,129.52) 53.4,129.41 53.4,127.47 53.53,127.35 53.92,127.35 54.05,127.22 54.05,126.84 53.92,126.71 53.48,126.71 53.35,126.58 53.35,126.23 53.48,126.1 54.98,126.1 55.76,125.31 55.76,124.93 55.89,124.81 56.27,124.81 56.4,124.93 56.4,125.31 56.52,125.44 56.91,125.44 57.03,125.31 57.03,124.93 57.16,124.81 61.86,124.81 62.33,125.27 v1(62.33,127.66)
  BOTTOM w0.127: v1(62.33,127.66) 62.73,128.07 U44.F7 ; U43.B13 v1(53.29,129.52)
VMA_DQ14: length 21.1
  TOP w0.127: U16.G2 63.53,127.27 v1(63.93,126.88)
  IN1 w0.102: 50.89,129.26 v1(50.89,129.53)
  IN1 w0.14: v1(63.93,126.88) 64.04,126.76 64.04,125.47 62.32,123.74 53.75,123.74 52.41,125.08 52.41,126.98 51.9,127.49 51.9,127.75 50.89,128.75 50.89,129.26
  BOTTOM w0.127: v1(63.93,126.88) U44.H8 ; U43.E13 v1(50.89,129.53)
VMA_DQ15: length 20.8
  TOP w0.102: U16.F2 v1(63.13,127.68)
  IN1 w0.102: 52.66,128.51 52.1,129.07 52.1,129.92 v1(51.68,130.34)
  IN1 w0.14: v1(63.13,127.68) 62.67,127.22 62.67,126.61 63,126.28 63,125.11 62.22,124.32 54.21,124.32 52.99,125.54 52.99,128.18 52.66,128.51
  BOTTOM w0.127: v1(51.68,130.34) 51.3,129.96 U43.D13 ; U16.F2 v1(63.13,127.68)
VMA_DQ16: length 14.7
  TOP w0.127: v1(59.95,127.65) 60.31,127.28 U16.C2
  IN3 w0.102: v1(59.95,127.65) 60.21,127.39 60.21,125.49 60,125.28 57.49,125.28 57.29,125.49 57.29,126.58 v1(56.78,127.09)
  BOTTOM w0.102: U43.B15 52.9,131.46 54.23,130.12 54.23,129.51 55.11,128.63 55.33,128.63 55.71,128.25 56.09,128.25 56.78,127.57 v1(56.78,127.09)
  BOTTOM w0.127: U16.C2 60.31,127.28 v1(59.95,127.65)
VMA_DQ17: length 13
  TOP w0.102: U16.C3 v1(60.73,127.68)
  IN3 w0.102: v1(54.95,129.61) 54.95,129.61 54.95,128.34 55.15,128.14 60.53,128.14 60.73,127.94 v1(60.73,127.68)
  BOTTOM w0.102: v1(54.95,129.61) 54.68,129.61 54.51,129.78 54.51,130.25 53.31,131.45 53.31,131.74 53.05,131.99 52.77,131.99 U43.C16
  BOTTOM w0.127: U44.D7 v1(60.73,127.68)
VMA_DQ18: length 14.3
  TOP w0.102: U16.A2 59.14,127.68 v1(59.14,127.72)
  IN3 w0.102: v1(56.02,127.09) 56.52,127.6 58.53,127.6 58.73,127.4 58.73,127.19 58.53,126.98 58.17,126.98 57.97,126.78 57.97,125.79 58.14,125.61 58.38,125.61 58.56,125.79 58.56,126.17 58.76,126.37 59.5,126.37 59.7,126.58 59.7,127.16 v1(59.14,127.72)
  BOTTOM w0.102: U43.A13 53.7,129.62 53.85,129.48 53.85,129.48 55.34,127.98 55.89,127.98 56.02,127.85 v1(56.02,127.09)
  BOTTOM w0.127: v1(59.14,127.72) 59.53,127.32 U44.B8
VMA_DQ19: length 17.4
  TOP w0.127: v1(59.04,128.9) 57.67,128.9 57.54,128.77 57.54,128.24 57.69,128.08 U16.A3
  IN3 w0.102: v1(59.04,128.9) 59.04,128.71 58.84,128.51 58.38,128.51 58.18,128.71 58.18,129.12 58.03,129.27 57.82,129.27 57.67,129.12 57.67,128.65 57.47,128.46 57.2,128.46 57.01,128.65 57.01,129.11 56.85,129.27 56.63,129.27 56.47,129.11 56.47,128.66 56.27,128.46 55.66,128.46 55.46,128.66 55.46,129.79 v1(54.95,130.29)
  BOTTOM w0.102: v1(54.95,130.29) 54.95,130.7 54.87,130.78 54.49,130.78 54.33,130.94 54.33,131.12 54.49,131.28 54.49,131.41 54.3,131.6 U43.A15
  BOTTOM w0.127: U16.A3 57.69,128.08 57.54,128.24 57.54,128.74 57.69,128.9 v1(59.04,128.9)
VMA_DQ20: length 13
  TOP w0.127: v1(58.13,131.28) 58.73,131.28 U16.A7
  IN3 w0.102: v1(55.59,132.74) 56.02,132.3 57.03,132.3 57.18,132.15 57.18,131.94 57.03,131.79 54.77,131.79 54.62,131.64 54.62,131.43 54.77,131.28 v1(58.13,131.28)
  BOTTOM w0.102: U43.B18 53.19,134.08 53.53,133.75 53.53,133.75 53.55,133.73 53.98,133.73 54.55,133.16 55.13,133.16 55.46,132.83
  BOTTOM w0.127: U16.A7 58.73,131.28 v1(58.13,131.28)
  BOTTOM w0.178: 55.46,132.83 55.55,132.74 v1(55.59,132.74)
VMA_DQ21: length 12.5
  TOP w0.127: v1(58.1,131.97) 58.35,131.72 59.17,131.72 U16.B8
  IN3 w0.102: v1(56.27,132.78) 57.03,132.78 57.39,132.42 57.87,132.42 58.23,132.78 58.52,132.78 58.72,132.58 58.72,132.18 59.33,131.57 59.33,131.33 59.16,131.16 58.91,131.16 v1(58.1,131.97)
  BOTTOM w0.102: U43.A18 53.97,134.08 54.58,133.47 55.46,133.47
  BOTTOM w0.127: v1(58.1,131.97) 58.1,132.6 58.18,132.68 58.38,132.68 58.73,132.33 U44.A2
  BOTTOM w0.178: v1(56.27,132.78) 55.59,133.47 55.46,133.47
VMA_DQ22: length 11.5
  TOP w0.127: U16.D7 v1(60.73,131.68)
  IN3 w0.102: v1(60.73,131.68) 60.73,132.04 60.89,132.19 61.33,132.19 61.48,132.34 61.48,132.55 61.33,132.7 60.73,132.7 59.44,133.99 v1(55.65,133.99)
  BOTTOM w0.102: U43.A19 55.12,134.88 55.33,134.68 55.35,134.68 55.46,134.56
  BOTTOM w0.127: U44.C3 v1(60.73,131.68)
  BOTTOM w0.178: v1(55.65,133.99) 55.56,134.08 55.56,134.46 55.46,134.56
VMA_DQ23: length 12
  TOP w0.127: v1(59.95,131.66) 60.33,132.04 U16.C8
  IN3 w0.102: v1(59.95,131.66) 59.95,132.86 59.75,133.06 59,133.06 58.49,133.57 58,133.57 57.92,133.49 57.92,133.12 57.76,132.95 57.53,132.95 57.36,133.12 57.36,133.49 57.28,133.57 55.32,133.57 v1(54.9,133.99)
  BOTTOM w0.102: U43.C19 52.49,134.49 54.39,134.49 v1(54.9,133.99)
  BOTTOM w0.127: U16.C8 60.33,132.04 v1(59.95,131.66)
VMA_DQ24: length 15
  TOP w0.102: v1(59.92,143.54) U13.C8
  IN3 w0.102: v1(59.92,143.54) 59.92,144.59 59.76,144.76 55.45,144.76 51.97,141.27 51.97,140.08 52.21,139.84 52.91,139.84 v1(53.31,139.44)
  BOTTOM w0.127: v1(53.31,139.44) 52.93,139.06 U43.B24 ; v1(59.92,143.54) U13.C8
VMA_DQ25: length 16.1
  TOP w0.127: v1(60.76,143.54) 61.13,143.16 U13.D7
  IN3 w0.102: v1(60.76,143.54) 60.95,143.35 61.43,143.35 61.55,143.22 61.55,142.87 61.43,142.74 59.6,142.74 58.94,142.08 58.39,142.08 58.01,141.7 55.33,141.7 55.2,141.57 55.2,139.99 55.08,139.86 54.85,139.86 54.72,139.73 54.72,139.48 54.85,139.35 55.13,139.35 55.25,139.23 55.25,138.95 55.13,138.82 v1(54.72,138.82)
  BOTTOM w0.127: U41.C3 60.37,143.15 v1(60.76,143.54) ; v1(54.72,138.82) 54.58,138.68 52.57,138.68 U43.C23
VMA_DQ26: length 12.3
  TOP w0.127: U13.A7 58.72,143.14 v1(58.72,142.62)
  IN3 w0.102: v1(58.72,142.62) 58.02,142.62 57.92,142.71 57.92,142.97 57.79,143.09 57.54,143.09 57.41,142.97 57.41,142.33 57.29,142.21 57.03,142.21 56.91,142.33 56.91,142.97 56.78,143.09 56.52,143.09 56.4,142.97 56.4,142.33 56.27,142.21 56.02,142.21 55.89,142.33 55.89,142.97 55.76,143.09 55.51,143.09 55.38,142.97 55.38,142.33 55.25,142.21 54.68,142.21 53.88,141.41 53.88,140.8 54.19,140.5 v1(54.19,140.14)
  BOTTOM w0.127: v1(58.72,142.62) 58.73,142.63 U13.A7 ; v1(54.19,140.14) 53.98,140.14 U43.A25
VMA_DQ27: length 13.4
  TOP w0.102: U13.B8 v1(59.13,143.55)
  IN3 w0.102: v1(59.13,143.55) 58.61,143.55 58.43,143.73 58.43,144.23 58.3,144.36 58.05,144.36 57.92,144.23 57.92,143.68 57.79,143.55 57.54,143.55 57.41,143.68 57.41,144.21 57.29,144.33 57.03,144.33 56.9,144.21 56.9,143.68 56.78,143.55 55.21,143.55 53.35,141.69 53.35,140.86 53.78,140.43 53.78,139.88 v1(54.16,139.5)
  BOTTOM w0.127: v1(54.16,139.5) 54.14,139.5 U43.A24 ; U41.A2 v1(59.13,143.55)
VMA_DQ28: length 15.2
  TOP w0.127: v1(59.13,139.55) 58.73,139.16 U13.A2
  IN3 w0.102: v1(59.13,139.55) 59.31,139.55 59.57,139.28 59.57,138.47 59.39,138.29 58.84,138.29 58.74,138.4 58.74,139.05 58.61,139.18 58.43,139.18 58.3,139.05 58.3,137.66 58.18,137.54 57.92,137.54 57.79,137.66 57.79,139.03 57.67,139.16 57.46,139.16 57.34,139.03 57.34,136.51 57.21,136.38 56.47,136.38 56.35,136.51 v1(56.35,136.76)
  BOTTOM w0.127: U43.A21 54.82,136.56 ; U41.B8 59.52,139.15 v1(59.13,139.55)
  BOTTOM w0.178: 54.82,136.56 55.02,136.76 v1(56.35,136.76)
VMA_DQ29: length 16.8
  TOP w0.127: v1(57.94,140.12) 58.11,139.95 U13.A3
  IN3 w0.102: v1(57.94,140.12) 58.41,140.12 58.54,139.99 58.54,139.67 58.41,139.54 57.16,139.54 56.86,139.23 56.86,137.83 56.73,137.7 56.32,137.7 56.19,137.57 56.19,137.35 56.32,137.22 56.79,137.22 v1(56.86,137.15)
  BOTTOM w0.102: U43.B21 53.09,136.56 53.44,136.21 53.45,136.21 53.94,135.72 54.28,135.72 54.67,136.11 55.46,136.11
  BOTTOM w0.127: v1(57.94,140.12) 58.11,139.95 U13.A3
  BOTTOM w0.178: v1(56.86,137.15) 56.86,138.24 56.98,138.36 57.41,138.36 57.54,138.24 57.54,136.24 57.41,136.11 55.46,136.11
VMA_DQ30: length 18.5
  TOP w0.102: v1(59.93,139.54) 60.32,139.15 U13.C2
  IN3 w0.102: v1(58.3,137.15) 59.27,137.15 59.39,137.28 59.39,137.7 59.52,137.83 59.78,137.83 59.9,137.7 59.9,137.28 60.03,137.15 60.47,137.15 61.39,138.08 61.39,138.34 60.97,138.76 60.97,138.92 60.84,139.05 60.59,139.05 60.46,138.92 60.46,138.34 60.33,138.21 60.06,138.21 59.93,138.34 v1(59.93,139.54)
  BOTTOM w0.102: 55.46,135.47 53.73,135.47 53.08,136.13 52.51,136.13 U43.C20
  BOTTOM w0.127: v1(59.93,139.54) 60.32,139.15 U13.C2
  BOTTOM w0.178: v1(58.3,137.15) 58.84,136.62 58.84,135.9 58.41,135.47 55.46,135.47
VMA_DQ31: length 17
  TOP w0.102: U13.C3 60.33,139.91 v1(60.72,139.53)
  IN3 w0.102: v1(60.72,139.53) 61.17,139.99 62.55,139.99 62.82,139.72 62.82,138.57 62.54,138.29 62.1,138.29 60.48,136.68 58.14,136.68 57.54,136.08 55.83,136.08 55.38,136.53 53.7,136.53 53.31,136.92 v1(53.31,136.94)
  BOTTOM w0.127: v1(60.72,139.53) 61.13,139.95 U41.D7 ; v1(53.31,136.94) 53.29,136.96 52.5,136.96 U43.C21
VMA_DQ32: length 25.6
  TOP w0.102: U12.H7 48.47,152.57 v1(48.07,152.17)
  IN1 w0.102: v1(41.77,137.03) 41.77,137.28 41.4,137.65 41.4,138.28 41.21,138.47 41.21,139.92 41.3,140.01 41.3,140.43 41,140.73 40.8,140.73 40.13,141.4 40.13,142.35 ; v1(48.07,152.17) 47.71,151.81 46.92,151.81 46.47,152.26 46.06,152.26 45.81,152.01
  IN1 w0.14: 40.13,142.35 40.13,143.46 40.67,144 40.67,145.63 41.48,146.43 41.48,148.27 41.79,148.59 41.79,149.37 41.91,149.49 42.13,149.49 42.38,149.23 42.52,149.23 42.81,149.52 42.81,149.66 42.52,149.95 42.52,150.1 42.81,150.38 42.95,150.38 43.24,150.1 43.38,150.1 43.67,150.38 43.67,150.53 43.42,150.78 43.42,151 43.82,151.4 45.2,151.4 45.81,152.01
  BOTTOM w0.127: v1(41.77,137.03) 41.69,137.1 41.69,137.29 41.81,137.41 42.15,137.41 U43.R22 ; v1(48.07,152.17) 48.47,152.57 U12.H7
VMA_DQ33: length 20.7
  TOP w0.102: v1(47.28,152.21) U12.H8
  IN1 w0.102: v1(47.28,152.21) 46.9,152.21 46.64,152.47 45.89,152.47 45.87,152.45 45.84,152.45
  IN1 w0.14: 45.84,152.45 45.49,152.45 44.85,151.81 43.65,151.81 41.43,149.58 41.43,148.82 40.6,148 40.6,147.09 40.33,146.82 40.33,144.18 39.77,143.62 39.77,141.39 v1(40.9,140.26)
  BOTTOM w0.127: U39.G2 47.67,151.82 v1(47.28,152.21) ; U43.R24 41.46,139.47 41.2,139.47 40.93,139.74 40.93,140.23 v1(40.9,140.26)
VMA_DQ34: length 21.1
  TOP w0.102: v1(48.85,150.63) 48.48,151 U12.F7
  IN1 w0.102: 41.49,142.35 41.49,141.75 41.54,141.7 41.54,140.77 41.71,140.6 41.71,139.7 42.48,138.93 42.48,138.32 41.99,137.83 v1(41.8,137.83)
  IN1 w0.14: v1(48.85,150.63) 48.57,150.92 46.93,150.92 46.55,150.54 46.13,150.54 46.03,150.64 44.98,150.64 42.63,148.28 42.63,146.54 41.74,145.65 41.74,143.75 41.36,143.37 41.36,142.6 41.49,142.47 41.49,142.35
  BOTTOM w0.127: U43.T22 41.37,137.42 41.78,137.83 41.78,137.83 v1(41.8,137.83) ; v1(48.85,150.63) 48.47,150.25 U39.E3
VMA_DQ35: length 24.1
  TOP w0.102: v1(47.25,151.4) 47.65,151 U12.F8
  IN1 w0.102: 41.08,142.38 41.08,141.95 40.98,141.85 40.58,141.85 40.48,141.75 40.48,141.48 40.6,141.37 41.11,141.37 41.28,141.19 41.28,140.73 41.51,140.51 41.51,139.52 42.22,138.81 42.22,138.37 42.09,138.24 41.85,138.24 41.67,138.42 41.67,138.57 v1(41.77,138.67) ; 47.24,151.41 45.85,151.41
  IN1 w0.14: 45.85,151.41 45.46,151.02 44.19,151.02 44.05,150.89 44.05,150.21 42.61,148.77 42.29,148.77 42.15,148.62 42.15,148.14 41.82,147.81 41.82,147.38 42.2,147 42.2,146.62 41.02,145.44 41.02,144.5 41.28,144.23 41.28,143.87 40.57,143.16 40.57,142.9 41.08,142.39 41.08,142.38 ; v1(47.25,151.4) 47.24,151.41
  BOTTOM w0.127: v1(47.25,151.4) 47.3,151.35 47.3,151.34 47.32,151.36 47.32,151.36 47.67,151 U12.F8 ; U43.R23 42.5,138.26 42.81,138.57 42.81,138.75 42.65,138.9 42.54,138.9 42.31,138.67 v1(41.77,138.67)
VMA_DQ36: length 26
  TOP w0.127: v1(52.87,152.2) U12.G2
  IN1 w0.14: v1(52.87,152.2) 52.07,153 51.8,153 51.64,152.84 51.64,151.44 51.34,151.14 51.34,150.38 50.91,149.95 50.12,149.95 49.59,149.43 49.59,147.98 49.46,147.84 48.83,147.84 48.7,147.97 48.7,148.48 48.5,148.68 47.76,148.68 46.82,147.74 46.82,146.93 46.36,146.47 46.36,145.6 46.49,145.48 47.38,145.48 47.51,145.35 47.51,145.02 47.38,144.89 46.49,144.89 46.36,144.76 46.36,144.48 46.49,144.36 47.2,144.36 47.33,144.23 47.33,143.87 47.2,143.75 46.49,143.75 46.36,143.62 46.36,143.27 45.09,142 45.09,141.74 43.6,140.25 43.45,140.25 v1(43.44,140.26)
  BOTTOM w0.127: U39.H8 52.47,152.6 v1(52.87,152.2) ; v1(43.44,140.26) 43.84,139.86 U43.N25
VMA_DQ37: length 24.8
  TOP w0.102: U12.H3 51.2,152.6 v1(51.13,152.68)
  IN1 w0.14: v1(43.44,141.06) 43.84,141.47 44.31,141.47 44.74,141.89 44.74,142.78 44.87,142.91 45.45,142.91 45.58,143.04 45.58,143.39 45.45,143.52 44.87,143.52 44.74,143.65 44.74,144 44.87,144.13 45.73,144.13 45.86,144.26 45.86,144.64 45.73,144.76 45.42,144.76 45.3,144.89 45.3,145.3 45.42,145.42 45.81,145.42 45.93,145.55 45.93,145.88 45.81,146.01 45.42,146.01 45.3,146.14 45.3,146.44 45.42,146.57 45.73,146.57 45.86,146.69 45.86,147 45.73,147.13 44.61,147.13 44.48,147.25 44.48,147.56 44.61,147.68 45.2,147.68 45.32,147.81 45.32,148.1 45.45,148.23 46.72,148.23 47.5,149 48.46,149 48.78,149.32 49.12,149.32 50.01,150.21 50.81,150.21 51.06,150.46 51.06,151.42 51.39,151.74 51.39,152.42 v1(51.13,152.68)
  BOTTOM w0.127: U12.H3 51.59,152.68 v1(51.13,152.68) ; U43.N26 43.84,140.66 v1(43.44,141.06)
VMA_DQ38: length 26.8
  TOP w0.127: v1(52.08,150.57) 51.71,150.2 U12.E3
  IN1 w0.102: 44.87,140.7 43.81,139.64 43.81,138.25 44.22,137.84
  IN1 w0.14: 44.87,140.7 44.87,140.71 44.91,140.75 45.21,140.75 45.6,141.14 45.6,141.29 47.03,142.71 48.35,142.71 48.64,143 48.64,143.2 48.34,143.49 48.34,143.74 48.51,143.91 48.71,143.91 49.04,143.58 49.22,143.58 49.63,143.99 49.63,144.17 49.32,144.49 49.32,144.67 49.5,144.86 49.68,144.86 49.99,144.55 50.19,144.55 50.36,144.72 50.36,144.92 50.23,145.05 50.23,145.25 50.4,145.42 50.6,145.42 50.73,145.29 50.92,145.29 51.27,145.63 51.27,145.86 51.11,146.01 50.4,146.01 50.28,146.14 50.28,146.47 50.43,146.62 51.32,146.62 51.63,146.3 51.81,146.3 52.09,146.58 52.09,146.76 51.37,147.48 50.94,147.48 50.81,147.61 50.81,147.99 50.94,148.12 51.5,148.12 51.63,148.24 51.63,149.36 51.75,149.49 52.31,149.49 52.43,149.62 52.43,150.44 52.31,150.57 v1(52.08,150.57) ; 44.22,137.84 v1(44.23,137.83)
  BOTTOM w0.127: U39.F7 51.67,150.97 v1(52.08,150.57) ; U43.N23 43.84,138.22 v1(44.23,137.83)
VMA_DQ39: length 25.8
  TOP w0.127: v1(52.07,151.39) 52.45,151 U12.F2
  IN1 w0.14: v1(52.07,151.39) 51.65,150.97 51.65,150.28 51.06,149.7 50.22,149.7 49.85,149.33 49.85,147.68 50.2,147.33 50.2,147.1 50.07,146.97 47.41,146.97 47.31,146.87 47.31,146.21 47.41,146.11 49.72,146.11 49.84,145.98 49.84,145.63 49.72,145.5 48.17,145.5 48.04,145.37 48.04,144.99 48.17,144.87 48.78,144.87 48.9,144.74 48.9,144.41 48.78,144.28 47.99,144.28 47.86,144.15 47.86,143.62 47.46,143.21 46.84,143.21 45.58,141.95 45.58,141.76 43.41,139.59 v1(43.41,139.45)
  BOTTOM w0.127: v1(43.41,139.45) 43.66,139.2 43.7,139.2 U43.N24 ; U12.F2 52.45,151 v1(52.07,151.39)
VMA_DQ40: length 22.2
  TOP w0.102: v1(40.21,150.61) 40.6,151 U11.F2
  IN1 w0.14: v1(40.09,138.68) 40.28,138.5 40.57,138.5 40.65,138.57 40.65,139.41 40.01,140.05 40.01,140.38 38.68,141.72 38.34,141.72 38.21,141.84 38.21,142.1 38.34,142.22 38.67,142.22 38.77,142.33 38.77,143.95 38.64,144.08 38.34,144.08 38.21,143.95 38.21,143.67 38.08,143.54 37.85,143.54 37.72,143.67 37.72,144.3 38.69,145.27 38.69,146.37 39.35,147.03 39.35,150.03 39.75,150.42 39.75,151.54 39.91,151.7 40.19,151.7 40.33,151.57 40.33,151.21 40.45,151.1 40.68,151.1 40.8,150.97 40.8,150.69 40.72,150.61 v1(40.21,150.61)
  BOTTOM w0.127: v1(40.21,150.61) 40.6,151 U11.F2 ; v1(40.09,138.68) 39.68,138.27 U43.V23
VMA_DQ41: length 23.8
  TOP w0.102: U11.H3 39.76,152.6 v1(39.39,152.23)
  IN1 w0.14: v1(40.14,137) 39.91,137 39.53,137.38 39.53,137.76 39.38,137.91 39,137.91 38.9,138.01 38.9,138.42 39,138.52 39.23,138.52 39.38,138.67 39.38,138.94 39.71,139.27 39.71,139.63 39.51,139.84 39.51,140.17 38.58,141.1 38.05,141.1 36.66,142.49 36,142.49 35.77,142.71 35.77,144.07 35.95,144.25 35.95,144.79 38.06,146.9 38.06,149.75 38.67,150.36 38.67,150.97 38.77,151.07 39.3,151.07 39.41,151.17 39.41,151.58 39.3,151.68 38.74,151.68 38.64,151.78 38.64,152.11 38.76,152.23 v1(39.39,152.23)
  BOTTOM w0.127: U43.V22 40.1,137 v1(40.14,137) ; v1(39.39,152.23) 39.76,152.6 U11.H3
VMA_DQ42: length 24.2
  TOP w0.102: v1(40.21,152.21) 40.21,151.93 40.35,151.8 U11.G2
  IN1 w0.14: v1(40.95,137.88) 40.95,137.89 40.95,139.6 40.46,140.08 40.46,140.29 39.13,141.63 39.13,144.18 39.25,144.31 39.58,144.31 39.71,144.43 39.71,144.71 39.58,144.84 39.25,144.84 39.13,144.97 39.13,145.25 39.25,145.37 39.71,145.37 39.84,145.5 39.84,145.78 39.71,145.91 39.25,145.91 39.13,146.03 39.13,146.3 39.7,146.88 39.7,149.88 39.8,149.98 40.04,149.98 40.14,149.88 40.14,149.55 40.24,149.44 40.48,149.44 40.59,149.55 40.59,150.08 40.71,150.2 41.23,150.2 41.36,150.33 41.36,150.89 41.11,151.15 41.11,151.3 41.31,151.5 41.31,151.65 41.17,151.8 40.99,151.8 40.9,151.7 40.72,151.7 v1(40.21,152.21)
  BOTTOM w0.127: U38.H8 40.3,152.6 40.21,152.51 v1(40.21,152.21) ; U43.T23 41.36,138.56 41.04,138.88 40.85,138.88 40.73,138.75 40.73,138.56 40.95,138.34 v1(40.95,137.88)
VMA_DQ43: length 24.5
  TOP w0.111: v1(39.31,150.62) 39.28,150.59 39.28,150.23 39.44,150.07 39.67,150.07 U11.E3
  IN1 w0.14: v1(40.92,137.02) U43.U22 40.52,138.07 40.34,138.25 39.78,138.25 39.66,138.37 39.66,138.86 40.07,139.26 40.07,139.64 39.76,139.94 39.76,140.27 38.64,141.39 38.18,141.39 37.85,141.72 37.85,142.63 37.68,142.81 36.99,142.81 36.86,142.94 36.31,142.94 36.18,143.06 36.18,143.34 36.31,143.47 36.69,143.47 36.82,143.6 36.82,143.91 36.29,144.43 36.29,144.63 36.69,145.02 36.87,145.02 37.3,144.59 37.47,144.59 37.68,144.79 37.68,144.97 37.3,145.35 37.3,145.53 37.5,145.73 37.68,145.73 37.99,145.41 38.17,145.41 38.35,145.59 38.35,145.77 38.11,146.01 38.11,146.29 39,147.18 39,150.23 39.31,150.54 v1(39.31,150.62)
  BOTTOM w0.127: v1(39.31,150.62) 39.31,151.14 39.49,151.32 39.67,151.32 39.8,151.19 U38.F7 ; U43.U22 v1(40.92,137.02)
VMA_DQ44: length 22.5
  TOP w0.102: U11.F7 36.6,151 v1(36.22,150.62)
  IN1 w0.14: v1(37.62,139.48) 37.42,139.48 37,139.91 35.54,139.91 32.93,142.52 32.93,144.18 32.39,144.71 32.39,145.07 32.52,145.2 33.94,145.2 34.07,145.32 34.07,146.26 34.2,146.39 34.78,146.39 34.91,146.52 34.91,146.85 34.78,146.98 34.25,146.98 33.87,147.36 33.87,149.72 34.1,149.95 34.76,149.95 34.91,150.1 34.91,150.73 35.22,151.04 35.79,151.04 v1(36.22,150.62)
  BOTTOM w0.127: v1(36.22,150.62) 36.6,150.23 U38.E3 ; v1(37.62,139.48) 37.63,139.47 38.41,139.47 38.52,139.36 38.52,139.19 38.43,139.11 38.09,139.11 U43.Y24
VMA_DQ45: length 21.7
  TOP w0.111: U11.F8 35.8,151 v1(36.22,151.38)
  IN1 w0.14: v1(36.77,139.46) 36.69,139.54 35.42,139.54 32.5,142.47 32.5,144 31.92,144.58 31.92,145.55 32.05,145.68 33.03,145.68 33.16,145.81 33.16,146.14 33.03,146.26 32.05,146.26 31.92,146.39 31.92,146.72 32.05,146.85 32.83,146.85 33.36,147.38 33.36,150 34.25,150.89 34.58,150.89 35.09,151.4 36.19,151.4 v1(36.22,151.38)
  BOTTOM w0.127: U43.AA24 37.17,139.06 v1(36.77,139.46) ; v1(36.22,151.38) 36.19,151.38 35.82,151 U11.F8
VMA_DQ46: length 21.8
  TOP w0.102: v1(35.4,152.23) 35.77,152.6 U11.H8
  IN1 w0.14: v1(37.63,137.83) 35.76,138.23 31.09,142.9 31.09,147.46 32.36,150.38 34.22,152.24 35.39,152.24 v1(35.4,152.23)
  BOTTOM w0.127: U38.G2 35.8,151.82 v1(35.4,152.23) ; U43.Y22 v1(37.63,137.83)
VMA_DQ47: length 23.5
  TOP w0.111: v1(37.01,152.2) 36.61,152.6 U11.H7
  IN1 w0.102: 35.81,151.81 36.61,151.81 v1(37.01,152.2)
  IN1 w0.14: 35.81,151.81 35.77,151.77 34.97,151.77 34.53,151.32 33.95,151.32 32.74,150.11 32.74,148.68 32.61,148.55 32.09,148.55 31.96,148.42 31.96,148.09 32.09,147.96 32.61,147.96 32.74,147.84 32.74,147.46 32.61,147.33 31.56,147.33 31.44,147.2 31.44,143.04 35.34,139.13 36.36,139.13 v1(36.81,138.68)
  BOTTOM w0.127: v1(37.01,152.2) 36.61,152.6 U11.H7 ; v1(36.81,138.68) 36.81,138.69 37.2,138.3 U43.AA23
VMA_DQ48: length 15
  TOP w0.102: v1(35.39,147.39) 35.8,147.79 U11.B8
  IN3 w0.102: v1(33.22,144.67) 33.22,143.43 33.33,143.32 33.51,143.32 33.66,143.48 33.66,144.16 35.95,146.44 36.97,146.44 37.07,146.54 37.07,146.9 36.97,147 35.78,147 v1(35.39,147.39)
  BOTTOM w0.102: 33.26,142.35 33.38,142.22 34.28,142.22 34.7,141.81 U43.AD27
  BOTTOM w0.127: v1(35.39,147.39) 35.78,147 U38.A2
  BOTTOM w0.178: v1(33.22,144.67) 32.72,144.18 32.72,142.88 33.26,142.35
VMA_DQ49: length 18.5
  TOP w0.102: U11.A7 36.58,147 v1(36.18,147.41)
  IN3 w0.102: v1(36.18,147.41) 36.18,147.69 36.05,147.82 34.1,147.82 33.84,147.56 33.84,147.28 34.3,146.82 34.3,146.68 33.99,146.37 33.99,146.21 34.21,145.99 34.39,145.99 34.78,146.39 34.96,146.39 35.1,146.25 35.1,146.07 34.25,145.22 33.03,145.22 32.9,145.35 32.9,145.69 33.03,145.82 v1(33.59,145.82)
  BOTTOM w0.102: U43.AB25 35.98,140.28 35.98,140.78 35.75,141.01 35.75,141.81 35.91,141.96 35.91,142.43 35.73,142.6 35.09,142.6 34.63,143.06 34.63,143.49
  BOTTOM w0.127: v1(36.18,147.41) 36.58,147 U11.A7
  BOTTOM w0.178: v1(33.59,145.82) 34.63,144.79 34.63,143.49
VMA_DQ50: length 15.6
  TOP w0.102: U11.D7 36.84,149.4 v1(37.21,149.03)
  IN3 w0.102: v1(37.21,149.03) 37.16,149.08 34.25,149.08 32.02,146.85 v1(32.02,143.85)
  BOTTOM w0.102: 32.6,142.35 32.98,141.97 33.97,141.97 34.31,141.63 34.31,141.05 U43.AD26
  BOTTOM w0.127: U38.C3 36.78,148.6 v1(37.21,149.03)
  BOTTOM w0.178: 32.6,142.35 32.02,142.93 v1(32.02,143.85)
VMA_DQ51: length 17.2
  TOP w0.102: v1(36.18,148.2) 35.8,148.58 U11.C8
  IN3 w0.102: v1(33.39,142.86) 34.05,142.86 34.17,142.74 34.17,142.51 34.01,142.35 32.71,142.35 32.48,142.58 32.48,146.67 33.99,148.19 34.63,148.19 35.14,148.7 35.68,148.7 v1(36.18,148.2)
  BOTTOM w0.102: 34,142.86 34.08,142.86 35.09,141.85 35.09,140.51 35.55,140.04 U43.AC25
  BOTTOM w0.127: U11.C8 35.8,148.6 36.18,148.23 v1(36.18,148.2)
  BOTTOM w0.178: 34,142.86 v1(33.39,142.86)
VMA_DQ52: length 16.2
  TOP w0.111: U11.C3 40.2,149.01 40.21,149.01 v1(40.22,149.01)
  IN3 w0.102: v1(40.22,149.01) 40.48,149.01 40.61,149.14 40.61,150.08 40.48,150.21 40.29,150.21 40.17,150.08 40.17,149.62 40.04,149.49 39.89,149.49 39.76,149.62 39.76,150.12 39.64,150.24 39.46,150.24 39.34,150.12 39.34,146.69 39.21,146.57 38.87,146.57 38.74,146.44 38.74,146.21 38.87,146.08 39.25,146.08 39.38,145.96 39.38,145.76 39.25,145.63 38.34,145.63 37.16,144.46 v1(37.16,144.16)
  BOTTOM w0.102: v1(37.16,144.16) 37.07,144.06 37.07,142 37.2,141.87 37.2,141.74 U43.AA27
  BOTTOM w0.127: v1(40.22,149.01) 39.83,149.4 U38.D7
VMA_DQ53: length 16
  TOP w0.111: U11.A3 39.8,146.35 v1(39.82,146.34)
  IN3 w0.102: v1(37.51,143.28) 37.51,142.72 35.57,140.78 35.39,140.78 35.14,141.03 35.14,141.21 35.98,142.05 35.98,142.4 37.65,144.07 37.65,144.5 38.47,145.32 39.65,145.32 39.82,145.48 v1(39.82,146.34)
  BOTTOM w0.102: U43.AA26 37.2,140.87 37.59,141.26 37.59,141.9 37.43,142.06 37.43,143.2 v1(37.51,143.28)
  BOTTOM w0.127: U11.A3 39.8,146.35 v1(39.82,146.34)
VMA_DQ54: length 17.7
  TOP w0.102: v1(40.17,147.39) 40.21,147.39 U11.A2
  IN3 w0.102: v1(38.31,142.68) 38.41,142.58 38.41,142.15 36.29,140.04 36.11,140.04 35.8,140.35 35.8,140.53 37.83,142.56 37.83,142.96 37.96,143.09 37.96,144.38 38.59,145.01 40.11,145.01 40.24,145.14 40.24,147.32 v1(40.17,147.39)
  BOTTOM w0.102: U43.W26 38.66,140.66 38.16,141.16 38.16,142.54 v1(38.31,142.68)
  BOTTOM w0.127: v1(40.17,147.39) 40.17,147.4 40.2,147.4 U38.B8
VMA_DQ55: length 19.2
  TOP w0.102: v1(40.18,148.21) 40.57,148.6 U11.C2
  IN3 w0.102: v1(40.18,148.21) 40.18,148.49 40.3,148.62 40.87,148.62 41,148.49 41,147.99 40.87,147.86 40.73,147.86 40.61,147.74 40.61,147.23 40.56,147.18 40.56,146.14 40.69,146.01 41.03,146.01 41.16,145.88 41.16,145.65 41.03,145.53 40.69,145.53 40.56,145.4 40.56,144.79 40.43,144.66 39.35,144.66 39.23,144.54 39.23,144.31 39.35,144.18 39.74,144.18 39.86,144.06 39.86,143.85 39.73,143.72 38.97,143.72 38.85,143.6 38.85,143.16 38.72,143.04 38.53,143.04 38.4,143.16 38.4,144.23 v1(38.69,144.52)
  BOTTOM w0.102: 38.19,143.75 38.19,143.3 37.73,142.84 37.73,142.23 37.92,142.04 37.92,141.21 37.66,140.95 37.66,140.62 37.47,140.43 37.47,140.09 37.58,139.98 37.92,139.98 U43.Y25
  BOTTOM w0.127: U11.C2 40.57,148.6 v1(40.18,148.21)
  BOTTOM w0.178: 38.19,143.75 38.19,144.01 v1(38.69,144.52)
VMA_DQ56: length 20.7
  TOP w0.102: v1(52.06,147.41) U12.A2
  IN3 w0.102: v1(52.06,147.41) 52.06,145.81 52.18,145.68 53.48,145.68 53.6,145.55 53.6,145.3 53.48,145.17 53.1,145.17 52.97,145.04 52.97,144.7 52.25,143.99 52.06,143.99 51.86,144.18 51.72,144.18 51.52,143.98 51.52,143.84 51.71,143.65 51.72,143.64 51.72,143.49 51.52,143.3 51.38,143.3 51.19,143.49 51.05,143.49 50.85,143.29 50.85,143.14 51.03,142.96 51.03,142.77 50.8,142.53 49.21,142.53 48.68,142 47.69,142 47.23,141.54 46.71,141.54 45.87,142.38 43.93,142.38 43.75,142.21 43.75,141.57 43.67,141.49 42.99,141.49 v1(42.55,141.05)
  BOTTOM w0.127: U39.B8 52.45,147.8 v1(52.06,147.41) ; U43.R26 42.16,140.66 v1(42.55,141.05)
VMA_DQ57: length 20.8
  TOP w0.102: v1(50.8,147.07) 51.6,147.07 U12.A3
  IN3 w0.102: v1(50.8,147.07) 50.8,146.28 50.68,146.16 50.07,146.16 49.97,146.06 49.97,145.71 50.07,145.61 51.16,145.61 51.27,145.51 51.27,145.25 51.14,145.13 50.53,145.13 50.42,145.02 50.42,144.88 50.73,144.58 50.73,144.38 50.58,144.24 50.38,144.24 50.08,144.54 49.88,144.54 49.67,144.33 49.67,144.13 49.99,143.81 49.99,143.63 49.85,143.49 49.62,143.49 49.33,143.79 49.13,143.79 48.49,143.16 v1(43.88,143.16)
  BOTTOM w0.102: v1(43.88,143.16) 43.83,143.1 43.24,143.1 42.71,142.58 42.71,142.29 42.34,141.93 42.08,141.93 41.77,141.63 41.77,140.53 41.36,140.12 U43.T25
  BOTTOM w0.127: v1(50.8,147.07) 51.6,147.07 U12.A3
VMA_DQ58: length 19.4
  TOP w0.102: v1(52.06,148.19) U12.C2
  IN3 w0.102: v1(52.06,148.19) 52.47,147.78 52.47,146.29 52.6,146.16 53.98,146.16 54.1,146.03 54.1,145.2 50.84,141.94 49.2,141.94 47.91,140.64 45.96,140.64 45.83,140.77 45.83,141.81 45.7,141.94 v1(44.17,141.94)
  BOTTOM w0.127: v1(52.06,148.19) U12.C2 ; v1(44.17,141.94) 44.03,141.79 44.03,141.65 U43.N27
VMA_DQ59: length 20
  TOP w0.111: v1(51.07,149.17) 51.08,149.17 51.1,149.17 U12.C3
  IN3 w0.102: v1(51.07,149.17) 51.07,149.56 51.2,149.69 51.5,149.69 51.62,149.56 51.62,145.22 51.75,145.09 52.43,145.09 52.56,144.97 52.56,144.73 52.42,144.59 51.53,144.59 50.01,143.07 49.27,143.07 48.88,142.69 43.42,142.69 v1(43.37,142.63)
  BOTTOM w0.102: U43.R27 42.35,141.65 42.43,141.65 43.04,142.26 43.04,142.3 v1(43.37,142.63)
  BOTTOM w0.127: U39.D7 51.31,149.4 v1(51.07,149.17)
VMA_DQ60: length 19
  TOP w0.111: v1(48.06,147.41) 48.06,147.65 47.9,147.8 U12.B8
  IN3 w0.102: v1(48.06,147.41) 48.06,147.68 47.93,147.81 46.92,147.81 46.8,147.68 46.8,146.95 46.92,146.82 47.15,146.82 47.28,146.69 47.28,146.17 47.15,146.04 46.49,146.04 46.36,146.17 46.36,146.44 46.24,146.57 45.98,146.57 45.86,146.44 45.86,146.17 45.73,146.04 45.47,146.04 45.35,146.17 45.35,146.92 45.22,147.05 44.97,147.05 44.84,146.92 44.84,146.14 44.1,145.39 v1(43.16,145.39)
  BOTTOM w0.102: 40.12,143.75 39.44,143.06 39.44,141.98 39.29,141.84 39.29,141.25 39.68,140.86 U43.V26
  BOTTOM w0.127: v1(48.06,147.41) 47.67,147.02 U39.A2
  BOTTOM w0.178: 40.12,143.75 41.22,144.84 42.33,144.84 42.88,145.39 v1(43.16,145.39)
VMA_DQ61: length 18.8
  TOP w0.102: v1(48.04,146.54) 48.47,146.97 U12.A7
  IN3 w0.102: v1(43.43,144.83) 43.43,144.66 43.56,144.54 44.26,144.54 44.38,144.66 44.38,145.17 44.51,145.3 44.79,145.3 44.92,145.17 44.92,144.66 45.04,144.54 45.32,144.54 45.45,144.66 45.45,145.5 45.58,145.63 45.88,145.63 46.01,145.5 46.01,144.66 46.14,144.54 46.47,144.54 46.59,144.66 46.59,145.5 46.72,145.63 47,145.63 47.13,145.5 47.13,144.66 47.25,144.54 47.53,144.54 47.66,144.66 47.66,146.41 47.79,146.54 v1(48.04,146.54)
  BOTTOM w0.102: 40.79,143.75 39.79,142.75 39.79,141.57 U43.V27
  BOTTOM w0.127: v1(48.04,146.54) 48.47,146.97 U12.A7
  BOTTOM w0.178: v1(43.43,144.83) 43.03,144.83 42.78,144.59 42.57,144.38 41.42,144.38 40.79,143.75
VMA_DQ62: length 19.4
  TOP w0.111: v1(48.96,148.86) 48.47,149.35 U12.D7
  IN3 w0.102: v1(43.77,145.91) 43.77,146.95 45.78,148.95 45.78,149.87 45.91,150 46.69,150 46.82,149.87 46.82,148.8 46.95,148.68 47.2,148.68 47.33,148.8 47.33,149.18 47.46,149.31 47.71,149.31 47.84,149.18 47.84,148.8 47.96,148.68 48.22,148.68 48.47,148.93 48.89,148.93 v1(48.96,148.86)
  BOTTOM w0.102: U43.W27 38.88,141.46 38.88,141.93 39.11,142.16 39.11,143.4 39.46,143.75
  BOTTOM w0.127: v1(48.96,148.86) 48.73,148.86 U39.C3
  BOTTOM w0.178: 39.46,143.75 41,145.3 42.12,145.3 42.73,145.91 v1(43.77,145.91)
VMA_DQ63: length 17.4
  TOP w0.102: v1(48.05,148.21) 47.67,148.58 U12.C8
  IN3 w0.102: v1(48.05,148.21) 46.73,148.21 46.54,148.4 45.81,148.4 44.28,146.87 v1(44.28,146.29)
  BOTTOM w0.102: 38.8,143.75 38.8,142.69 38.5,141.68 38.5,141.26 38.71,141.05 39.05,141.05 39.28,140.82 39.28,140.5 U43.W25
  BOTTOM w0.127: U12.C8 47.67,148.58 v1(48.05,148.21)
  BOTTOM w0.178: 38.8,143.75 38.8,143.85 40.7,145.75 41.91,145.75 42.57,146.41 44.15,146.41 v1(44.28,146.29)
VMA_RDQS0: length 23
  TOP w0.102: v1(62.95,141.56) 62.7,141.31 62.7,140.88 63.23,140.35 63.23,140.07 63.35,139.95 U13.G3
  IN1 w0.102: 54.16,135.66 54.14,135.66 54.1,135.7 53.03,135.7 51.89,134.56 50.57,134.56 50.33,134.81 50.33,135.11 v1(50.11,135.33)
  IN1 w0.14: 54.16,135.66 56.45,135.66 57.64,136.86 57.64,138.81 58.82,139.99 62.38,139.99 62.85,140.46 62.85,141.46 v1(62.95,141.56)
  BOTTOM w0.102: v1(62.95,141.56) 62.7,141.82 62.7,142.1 63.23,142.64 63.23,143.05 63.34,143.15 U41.G3 ; U43.F19 v1(50.11,135.33)
VMA_RDQS1: length 19.3
  TOP w0.102: U16.G3 63.23,128.38 63.23,128.7 62.82,129.11 62.82,129.51 v1(63.07,129.76)
  IN1 w0.102: v1(52.5,131.18) 53.69,131.18 54.52,130.36 54.52,129.27 54.81,128.97 54.87,128.97 54.89,128.95 ; v1(63.07,129.76) 62.97,129.76 62.75,129.98 62.75,130.15 62.49,130.41 61.93,130.41 61.17,129.65 61.17,129.14 60.77,128.74 60.72,128.74 60.7,128.73
  IN1 w0.14: 60.7,128.73 60.43,128.46 55.38,128.46 54.89,128.95
  BOTTOM w0.102: v1(63.07,129.76) 62.82,130 62.82,130.58 63.23,130.99 63.23,131.18 63.34,131.28 U44.G3 ; U43.C14 52.1,130.52 52.21,130.41 52.38,130.41 52.5,130.53 v1(52.5,131.18)
VMA_RDQS2: length 13.7
  TOP w0.102: U16.B7 59.85,130.96 59.85,130.67 59.57,130.39 59.57,129.88 v1(59.35,129.65)
  IN3 w0.102: v1(59.35,129.65) 59.46,129.65 59.66,129.85 59.66,130.07 59.48,130.25 57.23,130.25 56.88,129.9 56.21,129.9 55.94,129.64 v1(55.94,129.53)
  BOTTOM w0.102: v1(55.94,129.53) 55.94,129.62 55.43,130.13 55.43,131.2 53.88,132.76 53.54,132.76 53.45,132.66 53.45,132.52 53.57,132.4 U43.A16 ; v1(59.35,129.65) 59.6,129.4 59.6,128.66 59.83,128.42 59.83,128.18 59.73,128.08 U44.B7
VMA_RDQS3: length 14.5
  TOP w0.102: v1(59.62,141.49) 59.83,141.7 59.83,142.86 U13.B7
  IN3 w0.102: v1(54.19,137.74) 54.09,137.84 53.87,137.84 53.75,137.72 53.75,137.5 53.97,137.27 55.1,137.27 56.21,138.38 56.21,139.41 57.58,140.78 58.54,140.78 58.74,140.58 59.64,140.58 60.05,140.98 60.06,141 60.06,141.13 59.86,141.34 59.86,141.34 59.71,141.49 v1(59.62,141.49)
  BOTTOM w0.102: U41.B7 59.73,139.95 59.83,140.05 59.83,141.28 v1(59.62,141.49) ; v1(54.19,137.74) 53.91,137.52 U43.A22
VMA_RDQS4: length 24.2
  TOP w0.102: U12.G3 51.52,151.65 51.29,151.65 51.11,151.48 51.11,151.23 51.03,151.15 50.91,151.15 50.78,151.28 50.78,151.5 v1(50.38,151.91)
  IN1 w0.102: v1(42.53,139.46) 42.53,139.6 41.92,140.22 41.92,141.38 42.67,142.13 42.67,142.31 42.63,142.35 42.63,142.38 ; v1(50.38,151.91) 50.04,151.57 49.82,151.57 49.28,151.04 49.28,150.48 48.98,150.17 48.65,150.17 48.35,150.48 47.04,150.48 46.74,150.17 45.87,150.17 45.83,150.21 45.81,150.21
  IN1 w0.14: 42.63,142.38 42.63,143.71 42.22,144.11 42.22,145.51 43.11,146.4 43.11,148.19 45.13,150.21 45.81,150.21
  BOTTOM w0.102: v1(50.38,151.91) 50.09,151.62 49.95,151.62 49.83,151.5 48.77,151.5 U39.G3 ; U43.P25 42.99,139.86 v1(42.53,139.46)
VMA_RDQS5: length 24
  TOP w0.13: U11.G3 39.8,151.67 39.69,151.56 38.9,151.56 38.75,151.4 38.46,151.4 38.39,151.48 38.38,151.48 v1(38.22,151.64)
  IN1 w0.102: 36.57,147.05 36.57,147.08 36.61,147.11 36.61,148.03 36.76,148.18 36.76,148.52 36.59,148.7 36.59,149.38 36.97,149.76 36.97,150.25 36.69,150.53 36.69,151.06 37.01,151.39 37.96,151.39 v1(38.22,151.64) ; v1(38.46,137.84) 38.06,138.24 38.06,139.68 37.68,140.06 37.42,140.06 37.17,140.32 35.74,140.32 35.46,140.6 35.41,140.6 35.39,140.61
  IN1 w0.14: 35.39,140.61 33.89,142.11 33.89,144.47 34.97,145.55 35.17,145.55 36.57,146.95 36.57,147.05
  BOTTOM w0.102: U43.W22 v1(38.46,137.84) ; v1(38.22,151.64) 37.97,151.39 37.27,151.39 37.16,151.5 36.9,151.5 U38.G3
VMA_RDQS6: length 17
  TOP w0.13: U11.B7 36.97,148.17 37.08,148.17 37.15,148.24 38.29,148.24 v1(38.52,148.01)
  IN3 w0.102: v1(38.52,148.01) 38.28,148.24 38.12,148.24 38.01,148.13 38.01,146.49 37.39,145.88 36.18,145.88 34.3,143.99 34.3,143.62 34.68,143.24 34.83,143.24 34.91,143.32 34.91,143.85 35.04,143.98 35.22,143.98 35.34,143.85 v1(35.34,143.75)
  BOTTOM w0.102: v1(38.52,148.01) 38.52,148.16 38.59,148.24 38.85,148.24 39.15,147.94 39.35,147.94 39.46,147.84 39.46,147.58 39.56,147.48 39.71,147.48 39.8,147.57 U38.B7 ; v1(35.34,143.75) 35.34,143.54 35.45,143.44 36,143.44 36.38,143.06 36.38,141.83 36.21,141.66 36.21,141.51 36.27,141.46 U43.AB27
VMA_RDQS7: length 20.2
  TOP w0.13: v1(50.3,147.83) 50.05,148.08 48.75,148.08 U12.B7
  IN3 w0.102: v1(42.2,142.48) 42.2,142.68 42.35,142.83 42.94,142.83 43.7,143.59 48.33,143.59 48.68,143.94 48.68,144.36 48.98,144.67 49.39,144.67 49.69,144.97 49.69,145.36 49.36,145.69 49.36,145.99 49.87,146.5 49.87,147.99 49.97,148.09 50.17,148.09 50.3,147.97 v1(50.3,147.83)
  BOTTOM w0.102: v1(50.3,147.83) 50.7,147.83 50.85,147.68 51.14,147.68 51.33,147.87 51.33,148.05 51.44,148.16 51.56,148.16 51.67,148.04 U39.B7 ; U43.T27 41.51,141.31 41.51,141.11 41.41,141 41.15,141 40.91,141.25 40.91,141.52 41.95,142.56 42.12,142.56 v1(42.2,142.48)
VMA_WDQS0: length 23
  TOP w0.102: v1(62.26,141.56) 62.49,141.33 62.49,140.8 63.03,140.27 63.03,140.05 62.93,139.95 U13.F3
  IN1 w0.102: v1(50.93,135.31) 50.87,135.37 50.66,135.37 50.53,135.24 50.53,134.89 50.66,134.76 51.81,134.76 52.95,135.91 54.1,135.91 54.14,135.94 54.16,135.94
  IN1 w0.14: v1(62.26,141.56) 62.37,141.56 62.57,141.36 62.57,140.57 62.26,140.27 58.71,140.27 57.36,138.92 57.36,136.97 56.33,135.94 54.16,135.94
  BOTTOM w0.102: U41.F3 62.93,143.15 63.03,143.05 63.03,142.72 62.49,142.18 62.49,141.8 v1(62.26,141.56) ; U43.E19 50.7,134.68 50.83,134.68 50.93,134.77 v1(50.93,135.31)
VMA_WDQS1: length 19.2
  TOP w0.102: v1(62.4,129.77) 62.62,129.55 62.62,129.02 63.03,128.62 63.03,128.38 U16.F3
  IN1 w0.102: 54.69,128.75 54.67,128.77 54.67,128.83 54.31,129.18 54.31,130.28 53.61,130.98 52.9,130.98 52.69,130.77 52.31,130.77 51.87,131.21 v1(51.71,131.21) ; v1(62.4,129.77) 62.55,129.92 62.55,130.07 62.4,130.21 62.02,130.21 61.38,129.57 61.38,129.06 60.92,128.6 60.92,128.55 60.9,128.53
  IN1 w0.14: 54.69,128.75 55.27,128.18 60.55,128.18 60.9,128.53
  BOTTOM w0.102: v1(62.4,129.77) 62.62,130 62.62,130.67 63.03,131.08 63.03,131.18 62.93,131.28 U44.F3 ; U43.C15 v1(51.71,131.21)
VMA_WDQS2: length 13.8
  TOP w0.102: U16.C7 60.06,131 60.06,130.59 59.78,130.31 59.78,129.91 v1(60.04,129.65)
  IN3 w0.102: v1(60.04,129.65) 59.87,129.83 59.87,130.15 59.56,130.46 57.15,130.46 56.79,130.1 56.06,130.1 v1(55.94,130.22)
  BOTTOM w0.102: v1(60.04,129.65) 59.8,129.42 59.8,128.74 60.03,128.51 60.03,128.18 60.14,128.08 U44.C7 ; U43.B16 53.46,132.96 53.96,132.96 55.63,131.29 55.63,130.34 55.76,130.22 v1(55.94,130.22)
VMA_WDQS3: length 14.7
  TOP w0.102: U13.C7 60.03,142.85 60.03,141.74 v1(60.26,141.5)
  IN3 w0.102: v1(60.26,141.5) 60.26,140.91 60.25,140.9 59.73,140.38 58.66,140.38 58.46,140.58 57.67,140.58 56.41,139.32 56.41,138.29 55.19,137.07 53.89,137.07 53.54,137.41 53.54,137.52 v1(53.31,137.76)
  BOTTOM w0.102: v1(60.26,141.5) 60.03,141.28 60.03,140.05 60.14,139.95 U41.C7 ; U43.B22 52.9,137.49 53.17,137.76 v1(53.31,137.76)
VMA_WDQS4: length 24.3
  TOP w0.102: v1(50.37,151.27) 50.5,151.27 50.83,150.94 51.11,150.94 51.32,151.15 51.32,151.39 51.38,151.45 51.52,151.45 51.58,151.4 51.58,151.1 U12.F3
  IN1 w0.102: 42.91,142.38 42.91,142.35 42.87,142.31 42.87,142.05 42.12,141.3 42.12,140.3 42.28,140.14 42.41,140.14 v1(42.55,140.28) ; 45.81,149.93 45.83,149.93 45.87,149.97 46.82,149.97 47.13,150.28 48.26,150.28 48.57,149.97 49.06,149.97 49.49,150.39 49.49,150.95 49.9,151.37 50.28,151.37 v1(50.37,151.27)
  IN1 w0.14: 45.81,149.93 45.25,149.93 43.39,148.08 43.39,146.29 42.5,145.4 42.5,144.23 42.91,143.82 42.91,142.38
  BOTTOM w0.102: U39.F3 48.77,151.3 49.91,151.3 50.03,151.42 50.23,151.42 v1(50.37,151.27) ; U43.R25 42.16,139.73 42.07,139.64 41.83,139.64 41.74,139.74 41.74,140.1 41.92,140.28 v1(42.55,140.28)
VMA_WDQS5: length 24.3
  TOP w0.13: v1(38.22,150.95) 38.44,151.17 38.84,151.17 39,151.32 39.56,151.32 39.8,151.08 U11.F3
  IN1 w0.102: 35.59,140.81 35.61,140.79 35.61,140.74 35.82,140.52 37.25,140.52 37.51,140.27 37.76,140.27 38.26,139.77 38.26,138.89 v1(38.49,138.67) ; 36.85,147.05 36.85,147.08 36.81,147.11 36.81,147.94 36.97,148.1 36.97,148.61 36.79,148.78 36.79,149.3 37.17,149.67 37.17,150.33 36.89,150.61 36.89,150.98 37.09,151.18 37.99,151.18 v1(38.22,150.95)
  IN1 w0.14: 36.85,147.05 36.85,146.83 35.29,145.27 35.09,145.27 34.17,144.36 34.17,142.23 35.59,140.81
  BOTTOM w0.102: v1(38.49,138.67) 39.09,138.67 39.3,138.46 39.3,137.94 39.18,137.81 38.97,137.81 38.88,137.9 38.88,138.26 U43.W23 ; v1(38.22,150.95) 37.98,151.19 37.19,151.19 37.08,151.3 36.9,151.3 U38.F3
VMA_WDQS6: length 17.2
  TOP w0.13: v1(38.52,148.7) 38.52,148.58 38.41,148.47 37.05,148.47 36.99,148.4 36.8,148.4 U11.C7
  IN3 w0.102: v1(38.52,148.7) 38.27,148.45 38.03,148.45 37.8,148.22 37.8,146.58 37.31,146.08 36.1,146.08 34.1,144.08 34.1,143.53 34.59,143.04 v1(35.34,143.04)
  BOTTOM w0.102: v1(38.52,148.7) 38.52,148.51 38.59,148.44 38.94,148.44 39.23,148.14 39.37,148.14 39.46,148.23 39.46,148.68 39.53,148.75 39.65,148.75 U38.C7 ; U43.AB26 36.01,141.32 36.01,141.75 36.17,141.91 36.17,142.97 35.91,143.23 35.54,143.23 v1(35.34,143.04)
