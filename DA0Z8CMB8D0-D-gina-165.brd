# Allegro board DA0Z8CMB8D0-D-gina-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N109256958: length 3.6
  TOP w0.14: TP160.1 v1(125.92,131.33)
  BOTTOM w0.076: v1(125.92,131.33) 125.84,131.25 125.84,130.59 126.02,130.41 126.02,129.97 126.05,129.9 126.08,129.85 126.08,129.69 126.05,129.63 126.03,129.57 126.02,129.54 126.02,129.35 126.05,129.25 126.06,129.19 126.35,128.9 U45.C31
N109256960: length 3.1
  TOP w0.14: TP159.1 135.57,127.79 135.09,127.3 v1(135.09,127.11)
  BOTTOM w0.076: v1(135.09,127.11) 135.39,126.81 U45.F17
N109501275: length 6.4
  TOP w0.14: R794.2 R796.1 81.77,75.29 81.8,75.32 v3(81.82,75.32) 82.3,75.8 83.8,75.8 84.11,75.5 84.11,75.14 84.82,74.43 Q42.2
N111445857: length 106.9
  TOP w0.14: v1(198.71,42.27) 199.53,41.46 PR124.2
  TOP w0.254: v1(206.33,48.9) 207.55,50.12 207.7,50.12 PQ24.2 ; v1(176.49,71.13) PQ16.2 ; v1(203.67,42.53) 203.67,42.55 PQ29.2 201.35,41.56 PR125.1 201.2,41.46 PR124.2 ; PQ26.3 205.9,45.25 205.57,44.92 v1(205.57,44.81)
  IN1 w0.254: v1(176.49,71.13) 174.48,73.14 170.14,73.14 168.87,74.41 168.87,79.23 170.01,80.37 187.79,80.37 190.53,77.63 199.68,77.63 201.25,76.06 201.25,72.01 203.14,70.13 205.53,70.13 207.22,68.44 208.87,68.44 213.37,63.94 213.37,54.11 213.57,53.91 213.57,52.05 211.29,49.77 206.82,49.77 206.33,49.29 v1(206.33,48.9) 206.33,45.58 v1(205.57,44.81)
  BOTTOM w0.254: v1(205.57,44.81) 205.57,44.43 v1(203.67,42.53)
N111445887: length 7
  TOP w0.381: PR84.2 172.07,67.9 171.66,68.31 171.66,70.47 v1(172.04,70.85) 172.37,71.18 PQ16.3
N111445895: length 3.5
  TOP w0.14: PR117.2 v1(212.04,50.65)
  TOP w0.508: PR117.2 210.78,49.13 PQ24.3
N996593011: length 2.1
  TOP w0.14: TP99.1 157.87,44.51 SW1.1
N996593012: length 3.3
  TOP w0.14: TP100.1 168.23,40.12 167.73,40.12 167.03,40.81 SW1.4
N1024208981: length 2.1
  BOTTOM w0.14: SW2.1 100.73,46.37 TP155.1
N1024208982: length 2.7
  BOTTOM w0.14: TP156.1 108.78,40.66 SW2.4
N1077195233: length 1.4
  BOTTOM w0.14: U54.9 213.97,54.36 TP153.1
N10284479361: length 2.1
  TOP w0.14: U32.35 142.64,50.97 TP98.1
N102844793109: length 4.4
  TOP w0.14: TP97.1 137.25,56.24 139.15,58.15 139.15,58.66 139.42,58.93 U32.19

## Copper pours and planes (outline as drawn)
51211V_DRVL on TOP (solid shape): 193.61,75.84 193.61,75.32 193.59,75.28 193.56,75.27 192.77,75.27 192.74,75.29 192.74,75.7 192.21,76.23 192.21,76.54 192.45,76.78 192.67,76.78
51211V_DRVL on BOTTOM (solid shape): 183.47,76.31 183.47,75.9 183.37,75.8 182.08,75.8 182.03,75.85 182.03,76.49 182.05,76.51 183.27,76.51
51211V_SW on TOP (solid shape): 192.43,74.55 192.63,74.55 192.64,74.53 193.56,74.53 193.59,74.52 193.61,74.48 193.61,74.33 193.59,74.29 193.56,74.28 190.76,74.28 190.51,74.53 190.51,75.35 190.53,75.37 191.6,75.37
51211V_SW on BOTTOM (solid shape): 181.47,78.77 181.47,75.4 181.19,75.12 181.19,74 181.21,73.97 181.09,73.85 178.82,73.85 178.34,73.36 174.56,73.36 174.23,73.69 174.23,77.45 175.78,79 181.24,79
51211V_VBST on TOP (solid shape): 191.47,73.8 191.47,73.54 191.88,73.14 192.34,73.14 192.74,73.54 193.61,73.54 193.61,73.11 193.4,72.91 193.38,72.91 193.1,72.63 191.73,72.63 191.25,73.11 190.51,73.11 190.46,73.16 190.46,73.85 190.53,73.92 191.35,73.92
+1.5V on TOP (solid shape): 238.72,50.28 238.72,48.88 238.59,48.75 237.83,48.75 237.58,49.01 237.58,50.28 237.7,50.4 238.59,50.4
+1.05V on TOP (solid shape): 141.44,144.13 141.44,142.99 141.18,142.73 138.77,142.73 138.52,142.99 138.52,144.21 138.53,144.24 138.57,144.26 141.31,144.26
+1.05V on TOP (solid shape): outline of 105 points within 127.57,118.73 135.72,122.03
+1.05V on TOP (solid shape): outline of 128 points within 155.41,111.36 161.38,116.16
+1.5V on BOTTOM (solid shape): 147.04,47.52 147.91,47.52 149.09,46.34 151.85,46.34 152.23,45.96 152.23,43.04 151.72,42.53 149.69,42.53 149.18,42.02 145.63,42.02 145.25,41.64 145.25,40.89 144.99,40.64 141.83,40.64 141.65,40.82 141.65,47.37 141.8,47.52 147.04,47.52
+1.05V on BOTTOM (solid shape): outline of 112 points within 156.68,111.41 160.99,116.28
+1.5V on IN2 (solid shape): 238.85,51.29 238.85,49.89 238.72,49.77 237.83,49.77 237.58,50.02 237.58,51.29 237.7,51.42 238.72,51.42
+1.05V on SVCC (solid shape): outline of 410 points within 128.74,106.41 158.45,143.87
+1.05V_GFX on TOP (solid shape): outline of 203 points within 38.95,112.12 47.84,116.82
+1.05V_GFX on TOP (solid shape): outline of 560 points within 23.58,130.16 36.66,144.64
+1.05V_GFX on BOTTOM (solid shape): outline of 3564 points within 23.58,113.27 41.87,142.86
+1.05V_GFX on IN3 (solid shape): outline of 1373 points within 23.2,127.11 38.06,142.22
+1.05V_S5 on TOP (solid shape): 144.23,91.04 144.23,90.28 144.87,89.65 144.87,89.14 144.48,88.76 140.42,88.76 139.28,89.9 139.28,91.17 139.4,91.3 143.98,91.3
+1.05V_S5 on TOP (solid shape): 26.7,137.47 27.21,137.47 27.39,137.3 27.39,135.83 26.8,135.24 22.69,135.24 22.18,135.75 22.18,138.29 22.56,138.67 25.51,138.67
+1.05V_S5 on TOP (solid shape): outline of 454 points within 153.5,89.65 167.98,116.44
+1.05V_S5 on BOTTOM (solid shape): 174.84,85.2 174.84,78.85 173.69,77.71 173.69,73.9 173.31,73.52 168.36,73.52 168.11,73.77 168.11,79.23 168.23,79.36 168.87,79.36 169.38,79.87 169.38,85.2 169.88,85.71 174.33,85.71
+1.05V_S5 on BOTTOM (solid shape): 162.49,115.93 162.53,115.92 162.54,115.88 162.9,115.53 163.26,115.88 163.27,115.92 163.31,115.93 164.74,115.93 166.96,113.72 166.96,110.35 166.46,109.84 165.79,109.84 164.93,110.7 163.31,110.7 161.25,112.76 161.25,115.68 161.5,115.93
+1.05V_S5 on BOTTOM (solid shape): outline of 283 points within 77.99,85.84 156.71,98.53
+1.05V_S5 on IN2 (solid shape): 129.88,109.58 129.88,108.7 129.75,108.57 128.48,108.57 127.85,109.2 127.85,109.58 127.97,109.71 129.75,109.71
+1.05V_S5 on IN2 (solid shape): outline of 5759 points within 20.51,79.74 82.81,139.05
+1.05V_S5 on SVCC (solid shape): 170.65,111.53 170.65,103.49 170.68,103.3 170.79,103.13 177,96.93 177,87.57 176.66,87.23 176.26,87.23 176.07,87.2 175.9,87.08 175.14,86.32 175.03,86.16 174.99,85.96 174.99,83.94 175,83.85 175.01,83.77 175.01,80.53 174.35,79.87 171.34,79.87 171.31,79.9 170.65,80.56 170.65,94.09 170.61,94.28 170.5,94.45 167.29,97.65 167.21,98.04 166.83,98.12 166.74,98.2 166.71,98.66 166.25,98.7 164.8,100.14 164.8,114.07 165.14,114.41 167.77,114.41
+1.05V_VCCST on TOP (solid shape): 130.62,118.55 130.62,117.43 130.92,117.13 130.92,116.72 131.43,116.21 131.43,116.01 131.28,115.86 131.02,115.86 130.77,116.11 130.31,116.11 130.26,116.06 130.25,116.06 130.16,115.99 130.09,115.9 130.09,115.89 130.01,115.81 129.7,115.81 129.55,115.96 129.55,116.16 129.8,116.42 129.8,117.23 129.59,117.45 129.26,117.45 129.09,117.61 129.09,118.68 129.19,118.78 130.39,118.78
+1.05V_VCCST on BOTTOM (solid shape): 132.42,117.46 132.42,117.45 132.41,117.36 132.42,117.28 132.42,116.32 132.12,116.02 132.06,115.99 132.02,115.96 131.45,115.96 131.43,115.93 131.4,115.93 131.28,115.81 130.76,115.81 130.75,115.84 130.41,116.1 130.07,115.84 130.06,115.81 129.63,115.81 129.5,115.93 129.5,116.7 129.59,116.79 131.06,116.79 131.15,116.7 131.58,116.7 131.59,116.69 131.94,116.78 131.93,117.15 131.92,117.16 131.91,117.19 131.91,117.46 132.04,117.59 132.29,117.59
+1.05V_VCCST on IN2 (solid shape): 145.44,154.78 145.44,154.27 144.19,153.02 144.16,153.02 143.51,152.37 139.16,152.37 139.02,152.51 139.02,153.15 139.15,153.27 141.18,153.27 141.81,153.91 142.12,153.91 142.19,153.88 142.22,153.81 142.44,153.48 142.82,153.56 142.89,153.58 142.96,153.55 143.44,153.53 143.51,154.01 143.49,154.06 143.57,154.14 144.07,154.14 144.86,154.92 145.3,154.92
+1.05V_VCCST on IN2 (solid shape): outline of 548 points within 98.51,122.54 106.51,137.02
+1.05V_VCCST on IN3 (solid shape): outline of 1631 points within 97.88,115.81 131.78,126.22
+1.35V_GFX on TOP (solid shape): 78.47,136.36 78.47,134.48 78.34,134.35 76.92,134.35 76.79,134.48 76.79,134.86 77.06,135.48 77.51,135.93 77.51,136.39 77.71,136.59 78.24,136.59
+1.35V_GFX on TOP (solid shape): 39.63,137.25 39.63,134.84 39.51,134.71 38.62,134.71 38.49,134.84 38.49,135.86 38.36,135.98 36.97,135.98 36.84,136.11 36.84,136.87 37.35,137.38 39.51,137.38
+1.35V_GFX on TOP (solid shape): 46.59,151 46.59,150.98 46.64,150.84 46.76,150.74 46.77,150.74 47,150.51 47,150.06 46.9,149.81 47.01,149.56 47.38,149.19 47.38,147.67 47.71,147.34 47.71,147.33 47.76,147.2 47.87,147.11 47.88,147.09 47.89,147.06 47.89,146.9 47.04,146.05 45.93,146.05 45.65,146.34 45.65,146.81 46.08,147.23 46.11,147.25 46.15,147.23 46.7,146.68 47.04,146.68 47.23,146.86 47.23,147.07 46.98,147.33 46.98,147.5 47.23,147.75 47.23,147.96 47.04,148.15 46.41,148.15 46.33,148.16 46.25,148.15 45.73,148.15 45.48,148.4 45.48,150.59 46.11,151.22 46.36,151.22
+1.35V_GFX on TOP (solid shape): 45.29,137.18 45.48,137.05 45.71,137 45.97,137 46.2,137.05 46.4,137.18 46.49,137.27 46.51,137.28 46.54,137.28 46.8,137.26 47.04,137.36 47.75,137.36 47.89,137.23 47.91,137.23 47.97,137.17 47.97,136.12 47.85,136 46.35,136 46.33,136.02 44.89,136.02 44.37,135.51 44.37,134.71 44.29,134.62 43.65,134.62 43.44,134.69 43.24,134.62 42.92,134.62 42.5,135.04 42.5,136.25 42.88,136.64 44.28,136.64 44.32,136.68 44.33,136.68 44.48,136.77 44.56,136.92 44.57,136.93 44.8,137.17 44.8,137.25 44.91,137.36 45.11,137.36
+1.35V_GFX on TOP (solid shape): 61.05,165.46 61.05,163.68 60.86,163.5 60.78,163.47 60.7,163.51 60.34,163.66 60.06,163.38 60.06,163.37 59.79,163.1 59.79,161.85 59.45,161.51 59.45,160.9 59.43,160.86 59.4,160.85 59.01,160.85 58.64,160.71 58.43,160.37 58.41,160.34 58.37,160.33 58.05,160.24 57.95,159.92 57.96,159.91 57.95,159.88 57.29,159.22 57.29,156.55 57.13,156.39 56.34,156.39 56.02,156.71 56.02,157.25 54.46,158.81 54.24,158.81 54.21,158.83 54.2,158.86 54.2,158.89 54.11,159.25 53.75,159.34 53.72,159.34 53.69,159.35 51.6,161.45 51.6,161.61 51.59,161.61 51.59,161.71 51.79,161.91 57.62,161.91 58,162.29 58,162.37 58,162.37 58,163.39 58,163.39 58,163.69 59.01,164.7 59.01,165.46 59.14,165.59 60.92,165.59
+1.35V_GFX on TOP (solid shape): 39.2,164.19 39.2,163.85 39.19,163.82 39.16,163.8 38.37,163.58 38.31,163.58 37.98,163.48 37.76,163.21 37.76,163.2 37.72,163.16 36.33,163.16 34.81,161.64 34.81,159.6 34.68,159.48 34.05,159.48 33.92,159.35 33.92,158.59 34.05,158.46 35.06,158.46 35.19,158.33 35.19,158.08 35.06,157.95 34.05,157.95 33.92,157.83 33.92,157.19 34.05,157.06 34.31,157.06 34.43,157.05 34.54,157.06 35.06,157.06 35.19,156.94 35.19,156.56 35.06,156.43 34.93,156.43 34.81,156.56 32.27,156.56 32.14,156.68 32.14,158.08 31.68,158.54 31.65,158.61 31.67,158.68 31.7,158.72 31.72,158.76 31.74,158.79 31.77,158.8 31.95,158.8 31.96,158.79 32.12,158.65 32.33,158.62 32.75,158.97 32.33,159.32 32.12,159.29 31.96,159.15 31.95,159.14 31.75,159.14 31.73,159.16 31.72,159.18 31.7,159.23 31.67,159.27 31.6,159.31 31.53,159.32 31.25,159.32 31.23,159.32 31.16,159.35 31.12,159.42 31.12,161.53 30.64,162.02 30.64,163.51 30.93,163.8 37.93,163.8 38.14,164 38.14,164.2 38.26,164.32 39.07,164.32
+1.35V_GFX on TOP (solid shape): outline of 125 points within 58.05,137 61.35,139.41
+1.35V_GFX on TOP (solid shape): outline of 170 points within 67.98,121.99 76.57,132.63
+1.35V_GFX on TOP (solid shape): outline of 89 points within 58.05,122.64 65.16,127.45
+1.35V_GFX on TOP (solid shape): outline of 222 points within 67.95,137.69 77.48,149.95
+1.35V_GFX on TOP (solid shape): outline of 376 points within 47.89,129.78 51.52,137.23
+1.35V_GFX on TOP (solid shape): outline of 557 points within 70.72,92.8 82.91,103.62
+1.35V_GFX on BOTTOM (solid shape): 78.47,136.36 78.47,134.48 78.34,134.35 76.92,134.35 76.79,134.48 76.79,134.86 77.06,135.48 77.51,135.93 77.51,136.39 77.71,136.59 78.24,136.59
+1.35V_GFX on BOTTOM (solid shape): outline of 82 points within 50.33,156.22 60.98,165.61
+1.35V_GFX on BOTTOM (solid shape): outline of 157 points within 8.81,130.06 19.39,140.19
+1.35V_GFX on BOTTOM (solid shape): outline of 157 points within 68.08,122.01 76.59,132.68
+1.35V_GFX on BOTTOM (solid shape): outline of 143 points within 45.3,146.02 47.89,151.35
+1.35V_GFX on BOTTOM (solid shape): outline of 180 points within 58.43,131.92 63,134.71
+1.35V_GFX on BOTTOM (solid shape): outline of 196 points within 67.45,138.74 76.97,149.95
+1.35V_GFX on BOTTOM (solid shape): outline of 192 points within 30.74,155.83 40.23,164.3
+1.35V_GFX on BOTTOM (solid shape): outline of 197 points within 38.87,151.6 41.92,154.4
+1.35V_GFX on BOTTOM (solid shape): outline of 322 points within 58.18,122.52 65.03,127.35
+1.35V_GFX on BOTTOM (solid shape): outline of 222 points within 38.36,129.63 50.17,137.63
+1.35V_GFX on IN2 (solid shape): outline of 24558 points within 29.42,120.63 78.68,166.94
+1.35V_GFX on SVCC (solid shape): outline of 667 points within 2.03,99.3 86.57,172.43
+1.35V_SUS on TOP (solid shape): 166.62,62.56 166.62,61.95 167.8,60.77 177.3,60.77 177.48,60.59 177.48,54.49 177.5,54.47 177.5,53.07 177.28,52.84 173.31,52.84 172.47,52 166.91,52 164.35,54.57 164.35,55.61 164.25,55.71 164.25,62.81 164.5,63.06 166.11,63.06
+1.35V_SUS on TOP (solid shape): 101.56,55.1 101.59,55.09 101.61,55.05 101.61,54.18 101.6,54.16 101.58,54.14 101.5,54.07 101.44,53.99 101.43,53.97 101.41,53.96 97.88,53.96 97.62,54.21 97.62,54.85 97.88,55.1
+1.35V_SUS on TOP (solid shape): 122.77,55.1 122.77,54.21 122.51,53.96 117.25,53.96 117.17,54.01 117.16,54.1 117.19,54.23 117.18,54.35 117.18,54.38 117.2,54.4 117.37,54.57 118.26,54.57 119.04,55.36 122.51,55.36
+1.35V_SUS on TOP (solid shape): 81.87,63.1 81.87,62.47 81.37,61.96 79.84,61.96 79.46,61.58 79.46,61.07 79.97,60.56 81.24,60.56 81.46,60.34 81.51,60.28 81.62,60.18 81.62,59.42 82.23,58.81 82.23,58.8 82.28,58.71 82.36,58.64 82.38,58.62 82.38,58.6 82.38,58.4 81.75,57.77 81.75,55.86 81.24,55.36 81.24,55.35 81.19,55.29 81.19,54.4 81.24,54.35 81.24,54.09 81.11,53.96 78.57,53.96 78.32,54.21 78.32,54.62 78.33,54.65 78.35,54.65 78.55,54.97 78.35,55.3 78.32,55.31 78.32,55.34 78.32,63.1 78.83,63.61 81.37,63.61
+1.35V_SUS on TOP (solid shape): 110.1,55.48 110.13,55.47 110.15,55.43 110.15,54.81 110.14,54.78 110.13,54.77 110.32,54.11 110.52,54.77 110.5,54.78 110.49,54.81 110.49,55.43 110.51,55.47 110.54,55.48 114.13,55.48 114.39,55.23 114.39,54.21 114.13,53.96 108.04,53.96 107.97,53.99 107.94,54.06 107.94,54.35 107.93,54.42 107.9,54.47 107.88,54.54 107.91,54.61 108.09,54.78 108.09,55.26 108.31,55.48
+1.35V_SUS on TOP (solid shape): 107.76,55.48 107.8,55.45 107.79,55.4 107.78,55.38 107.78,54.91 107.42,54.55 107.41,54.55 107.29,54.48 107.24,54.35 107.24,54.06 107.21,53.99 107.14,53.96 104.86,53.96 104.82,53.97 104.81,54.01 104.79,54.12 104.74,54.22 104.73,54.24 104.73,54.27 105.1,54.64 105.15,54.64 105.61,55.1 105.71,55.12 105.78,55.04 106.23,54.76 106.46,55.24 106.47,55.34 106.55,55.38 106.85,55.38 106.96,55.48
+1.35V_SUS on TOP (solid shape): 102.72,55.1 102.75,55.1 102.88,54.96 103.18,54.96 103.2,54.95 103.22,54.93 103.5,54.76 103.81,54.89 103.88,54.93 103.95,54.9 104.14,54.82 104.35,54.86 104.38,54.87 104.42,54.85 104.63,54.85 104.72,54.78 104.7,54.67 104.39,54.36 104.37,54.36 104.17,54.23 104.1,54.01 104.08,53.97 104.05,53.96 102.11,53.96 102.09,53.97 102.08,53.99 102.02,54.08 101.94,54.14 101.92,54.16 101.91,54.19 101.91,55.05 101.93,55.09 101.96,55.1
+1.35V_SUS on TOP (solid shape): outline of 12972 points within 72.91,67.55 140.17,116.57
+1.35V_SUS on BOTTOM (solid shape): 201.68,55.33 201.68,54.47 201.58,54.37 199.93,54.37 199.78,54.52 199.78,55.25 200.03,55.51 201.51,55.51
+1.35V_SUS on BOTTOM (solid shape): 122.77,55.1 122.77,54.21 122.51,53.96 118.15,53.96 118.05,54.02 118.08,54.13 119.3,55.36 122.51,55.36
+1.35V_SUS on BOTTOM (solid shape): 152.23,50.31 152.23,48.99 152.54,48.68 152.54,47.15 152.49,47.1 150.96,47.1 150.33,47.74 150.33,49.93 150.4,50.1 150.38,50.28 150.37,50.3 150.38,50.33 150.58,50.53 152.01,50.53
+1.35V_SUS on BOTTOM (solid shape): 103.58,54.13 103.6,54.02 103.51,53.96 102.13,53.96 102.1,53.97 102.08,53.99 101.76,54.19 101.44,53.99 101.43,53.97 101.41,53.96 97.88,53.96 97.62,54.21 97.62,54.85 97.88,55.1 102.61,55.1
+1.35V_SUS on BOTTOM (solid shape): 109.37,55.15 109.37,55.04 109.96,54.45 109.97,54.43 110.09,54.2 110.35,54.11 110.38,54.11 110.39,54.1 110.4,54.06 110.39,54.03 110.32,53.96 106.07,53.96 106,53.99 105.97,54.07 105.98,54.22 105.98,54.45 106.38,54.85 106.49,55.08 106.41,55.32 106.4,55.43 106.49,55.48 109.04,55.48
+1.35V_SUS on BOTTOM (solid shape): 165.69,62.77 165.69,61.5 166.38,60.82 178.57,60.82 179.16,60.23 179.16,53.4 178.93,53.17 172.2,53.17 171,54.37 167.8,54.37 166.89,53.45 164.3,53.45 163.28,54.47 163.28,56.77 163.34,56.86 163.44,56.85 164.02,57.13 163.44,57.42 163.34,57.41 163.28,57.5 163.28,62.04 164.32,63.08 165.39,63.08
+1.35V_SUS on BOTTOM (solid shape): 66.25,55.23 67.27,55.23 67.52,54.97 67.52,54.22 67.65,54.09 67.66,54.08 67.73,54.01 67.83,53.98 67.97,53.97 68.11,53.98 68.21,54 68.29,54.08 68.29,54.08 68.68,54.47 69.68,54.47 69.94,54.21 69.94,53.7 69.55,53.32 69.55,52.43 69.3,52.18 69.12,52.18 69.04,52.22 69.03,52.32 68.95,52.67 68.61,52.78 68.59,52.78 68.57,52.79 68.54,52.82 67.78,52.82 67.65,52.69 67.65,52.44 67.64,52.41 67.61,52.39 67.42,52.24 67.37,52.01 67.37,52 67.37,51.97 66.94,51.55 66.51,51.55 66.38,51.67 66.38,51.98 66.41,52.05 66.48,52.08 66.77,52.23 66.81,52.56 66.81,52.57 66.81,52.98 66.38,53.41 66.38,53.7 66.13,53.96 65.74,53.96 65.62,54.09 65.62,55.23 65.74,55.36 66.13,55.36
+1.35V_SUS on BOTTOM (solid shape): outline of 427 points within 72.81,69.45 140.67,91.53
+1.35V_SUS on IN2 (solid shape): outline of 13817 points within 61.81,53.07 140.42,76.18
+1.35V_SUS on SVCC (solid shape): outline of 121 points within 57.62,49.5 169.63,79.74
+1.35V_SUS on IN3 (solid shape): outline of 3773 points within 65.36,63.48 92.54,77.96
+3V on TOP (solid shape): 59.37,109.23 59.37,108.7 59.24,108.57 58.38,108.57 57.8,107.99 56.63,107.99 56.47,108.15 56.47,109.33 56.6,109.46 59.14,109.46
+3V on TOP (solid shape): 226.4,37.83 226.4,37.73 226.4,36.94 226.32,36.86 226.07,36.86 226.03,36.81 224.49,36.81 224.37,36.94 224.37,37.83 224.49,37.96 226.27,37.96
+3V on TOP (solid shape): 228.18,45.45 228.18,45.2 227.42,44.43 227.42,43.42 227.29,43.29 226.45,43.29 226.15,43.29 226.02,43.42 226.02,45.2 226.4,45.58 228.05,45.58
+3V on BOTTOM (solid shape): 94.57,49.92 94.57,48.65 94.45,48.52 93.68,48.52 93.43,48.78 93.43,49.92 93.56,50.05 94.45,50.05
+3V on BOTTOM (solid shape): 81.37,51.42 81.37,49.01 80.98,48.62 79.59,48.62 79.46,48.75 79.46,49.64 79.33,49.77 78.44,49.77 78.32,49.89 78.32,50.66 79.21,51.55 81.24,51.55
+3V on BOTTOM (solid shape): 218.78,65.26 218.78,63.48 222.32,59.95 222.32,57.24 222.08,57.01 220.56,57.01 220.3,57.26 220.3,59.55 217.38,62.47 217.38,65.26 217.51,65.39 218.65,65.39
+3V on BOTTOM (solid shape): 239.35,45.07 239.35,44.05 239.3,44 239.27,44 239.26,44 239.06,44.02 238.87,43.93 237.96,43.93 237.7,44.18 237.7,44.81 238.08,45.2 239.23,45.2
+3V on BOTTOM (solid shape): 166.84,70.09 166.84,69.12 166.79,69.04 166.7,69.03 166.33,68.94 166.25,68.57 166.23,68.48 166.15,68.44 165.54,68.44 165.31,68.21 165.31,67.67 165.06,67.42 164.04,67.42 163.66,67.8 163.66,69.96 163.92,70.21 166.71,70.21
+3V on BOTTOM (solid shape): 116.8,47.48 116.8,43.54 117.31,43.04 121.97,43.04 122.04,43.11 122.04,43.2 122.05,43.22 122.12,43.31 122.14,43.39 122.14,43.7 122.13,43.75 122.1,43.81 122.09,43.82 122.09,43.86 122.16,43.93 122.64,43.93 122.89,43.67 122.89,42.02 122.64,41.77 115.27,41.77 114.77,42.27 114.77,46.59 114.39,46.97 114.36,46.97 114.32,46.99 114.31,47.02 114.31,47.09 112.56,47.09 112.56,47.02 112.54,46.99 112.51,46.97 111.85,46.97 111.08,47.74 110.58,47.74 110.32,47.99 110.32,48.75 110.56,48.99 115.29,48.99
+3V on IN1 (solid shape): 66.76,83.55 66.76,80.68 65.85,79.76 65.85,78.41 65.44,78 65.44,77.91 65.36,77.83 65.25,77.83 65.23,77.84 65.21,77.85 64.95,77.99 64.68,77.89 64.61,77.86 64.54,77.89 64.27,77.99 64.02,77.85 64,77.84 63.98,77.83 61.68,77.83 61.43,78.09 61.43,78.72 61.68,78.98 64.47,78.98 64.73,79.23 64.73,80.12 65.77,81.16 65.77,83.58 66,83.8 66.51,83.8
+3V on IN1 (solid shape): 71,94.34 71,90.48 69.86,89.34 68.08,89.34 67.78,89.65 67.78,91.02 69.32,91.02 69.33,90.96 69.34,90.91 69.36,90.85 69.39,90.8 69.42,90.76 69.46,90.71 69.5,90.68 69.55,90.65 69.61,90.63 69.66,90.62 69.72,90.61 69.77,90.61 69.83,90.62 69.88,90.64 69.94,90.66 69.98,90.7 70.02,90.73 70.06,90.78 70.09,90.83 70.11,90.88 70.13,90.93 70.14,90.99 70.14,91.05 70.13,91.1 70.11,91.16 70.09,91.21 70.06,91.26 70.02,91.3 69.98,91.34 69.94,91.37 69.88,91.4 69.83,91.41 69.77,91.42 69.72,91.42 69.66,91.42 69.61,91.41 69.55,91.38 69.5,91.36 69.46,91.32 69.42,91.28 69.39,91.23 69.36,91.18 69.34,91.13 69.33,91.07 69.32,91.02 67.78,91.02 67.78,94.34 68.28,94.85 70.49,94.85
+3V on IN1 (solid shape): 133.69,43.42 135.06,42.05 135.06,42.05 135.47,41.64 135.47,40.12 135.09,39.73 133.38,39.73 133.31,39.77 133.28,39.84 133.28,39.88 133.22,40.08 133.05,40.22 132.29,40.98 132.29,41.39 131.91,41.77 130.97,41.77 130.9,41.8 130.87,41.87 130.51,42.25 130.16,41.87 130.13,41.8 130.06,41.77 121.37,41.77 121.12,42.02 121.12,42.91 121.37,43.16 126.96,43.16 127.21,43.42 129.43,43.42
+3V on IN1 (solid shape): outline of 1429 points within 116.48,132.32 151.98,156.16
+3V on IN2 (solid shape): 136.36,42.02 136.36,40.24 136.1,39.99 134.83,39.99 133.94,40.88 132.6,40.88 132.56,40.89 132.55,40.93 132.55,42.4 132.93,42.78 135.59,42.78
+3V on IN2 (solid shape): outline of 391 points within 224.24,36.43 233.64,45.83
+3V on IN2 (solid shape): outline of 449 points within 56.73,63.74 63.46,78.85
+3V on IN2 (solid shape): outline of 499 points within 168.36,62.72 219.36,87.54
+3V on IN2 (solid shape): outline of 546 points within 67.89,45.58 112.23,49.26
+3V on IN2 (solid shape): outline of 5245 points within 58,93.33 118.96,163.18
+3V on SVCC (solid shape): 152.36,138.02 152.36,129.58 152.4,129.38 152.51,129.22 156.64,125.08 156.68,124.62 157.14,124.59 162.7,119.03 162.72,118.55 163.2,118.53 163.79,117.94 163.79,99.94 163.83,99.74 163.94,99.57 169.63,93.88 169.63,87.23 169.53,86.98 169.63,86.73 169.63,66.2 169.07,65.64 165.9,65.64 165.71,65.84 165.44,65.85 160.99,70.3 160.99,72.13 161.1,72.37 160.99,72.62 160.99,76.67 161.12,76.95 160.99,77.22 160.99,78.92 162.35,79.73 160.99,80.54 160.99,84.61 163.77,87.38 163.88,87.55 163.92,87.75 163.92,89.41 163.99,89.63 163.92,89.85 163.92,90.03 164.02,90.28 163.92,90.53 163.92,92.05 163.88,92.25 163.77,92.42 160.64,95.54 160.64,96.04 160.14,96.05 159.47,96.71 159.47,104.74 159.75,105.09 159.47,105.44 159.47,116.06 159.43,116.25 159.32,116.42 158.56,117.18 158.46,117.26 158.34,117.31 158.09,117.43 157.82,117.33 157.71,117.33 157.44,117.46 157.17,117.33 152.06,117.33 151.72,117.56 151.39,117.33 149.27,117.33 148.05,118.55 147.98,118.95 147.58,119.02 146.81,119.79 146.82,119.94 146.77,120.09 146.77,127.96 146.85,128.18 146.77,128.4 146.77,138.1 147.09,138.41 151.97,138.41
+3V on IN3 (solid shape): outline of 147 points within 218.32,44.36 228.43,64.5
+3V_GFX on TOP (solid shape): 32.98,112.76 32.98,111.44 32.93,111.39 31.25,111.39 31.15,111.49 31.15,112.84 31.2,112.89 32.85,112.89
+3V_GFX on TOP (solid shape): 27.01,114.08 27.01,111.62 26.88,111.49 26.25,111.49 26.12,111.62 26.12,112.38 25.41,113.09 25.41,114.09 25.65,114.33 26.76,114.33
+3V_GFX on TOP (solid shape): outline of 233 points within 47.08,120.63 51.9,128.63
+3V_GFX on TOP (solid shape): outline of 341 points within 25.23,115.55 38.06,126.35
+3V_GFX on BOTTOM (solid shape): 37.32,126.74 37.32,125.54 36.85,125.07 36.71,125.07 36.24,125.53 36.21,125.58 36.13,125.68 36.13,126.22 36.25,126.35 36.28,126.36 36.29,126.35 36.55,126.43 36.63,126.69 36.63,126.7 36.63,126.73 36.72,126.81 37.25,126.81
+3V_GFX on BOTTOM (solid shape): 49.11,129.27 49.11,129.07 49.1,129.04 49.08,129.03 48.9,128.72 49.08,128.41 49.1,128.39 49.11,128.37 49.11,127.39 49.1,127.37 49.08,127.35 48.9,127.04 49.08,126.73 49.1,126.71 49.11,126.69 49.11,125.59 48.77,125.25 48.76,125.25 48.63,125.2 48.55,125.1 48.53,125.09 48.5,125.08 48.09,125.08 47.81,125.36 47.81,125.38 47.75,125.54 47.61,125.65 47.6,125.66 47.58,125.68 47.58,127.77 47.88,128.06 47.89,128.07 48.16,128.36 47.99,128.72 47.97,128.74 47.96,128.77 47.96,128.91 47.98,128.94 47.99,128.94 48.13,129.06 48.19,129.23 48.19,129.25 48.35,129.4 48.98,129.4
+3V_GFX on BOTTOM (solid shape): outline of 170 points within 26.5,105.27 36.92,118.22
+3V_GFX on IN3 (solid shape): outline of 2711 points within 33.74,111.03 72.35,128.51
+3V_PCH_ME on TOP (solid shape): 155.89,127.79 155.89,126.78 155.81,126.7 155.48,126.7 155.44,126.67 155.43,126.67 155.37,126.62 155.32,126.56 155.32,126.55 155.1,126.33 155.1,126.05 155,125.96 154.57,125.96 154.08,126.46 154.08,126.68 154.16,126.77 154.69,126.77 154.7,126.78 154.79,126.78 154.94,126.84 155,126.98 155,127.08 155.03,127.11 155.03,127.12 155.25,127.34 155.25,127.79 155.26,127.83 155.3,127.84 155.84,127.84
+3V_S5 on TOP (solid shape): 9.74,166.1 9.74,164.96 10.12,164.58 10.12,164.19 9.99,164.07 8.85,164.07 8.34,164.58 8.34,165.97 8.59,166.23 9.61,166.23
+3V_S5 on TOP (solid shape): 167.67,76.06 167.67,71.82 166.96,71.1 166,71.1 165.97,71.08 164.96,71.08 164.37,71.66 164.37,72.35 164.83,72.35 164.83,72.3 164.84,72.24 164.85,72.19 164.88,72.14 164.91,72.1 164.94,72.06 164.98,72.03 165.03,72 165.08,71.98 165.13,71.97 165.19,71.97 165.24,71.97 165.29,71.98 165.34,72 165.39,72.03 165.43,72.06 165.46,72.1 165.49,72.14 165.52,72.19 165.53,72.24 165.54,72.3 165.54,72.35 165.53,72.4 165.52,72.45 165.49,72.5 165.46,72.55 165.43,72.58 165.39,72.62 165.34,72.64 165.29,72.66 165.24,72.68 165.19,72.68 165.13,72.68 165.08,72.66 165.03,72.64 164.98,72.62 164.94,72.58 164.91,72.55 164.88,72.5 164.85,72.45 164.84,72.4 164.83,72.35 164.37,72.35 164.37,75.8 165.17,76.6 167.13,76.6
+3V_S5 on TOP (solid shape): 155.15,111.62 155.15,109.97 155.91,109.2 155.91,108.93 155.86,108.84 155.75,108.85 155.31,108.84 155.21,108.41 155.22,108.33 155.16,108.27 155.15,107.6 155.6,108.09 155.59,108.18 155.65,108.23 155.7,108.26 155.75,108.29 155.86,108.3 155.91,108.21 155.91,107.3 156.3,106.92 156.3,105.39 156.17,105.27 155.25,105.27 153.22,107.3 153.22,107.65 154.14,108.57 154.14,108.67 154.18,108.71 154.18,111.47 154.14,111.51 154.14,111.74 154.26,111.87 154.9,111.87
+3V_S5 on BOTTOM (solid shape): outline of 140 points within 159.6,72.73 168.49,97.14
+3V_S5 on IN2 (solid shape): outline of 925 points within 144.74,95.13 165.16,113.9
+3V_WLAN on BOTTOM (solid shape): 216.61,70.77 216.61,69.31 216.62,69.31 216.62,69.07 218.65,67.04 218.65,65.77 218.53,65.64 217.13,65.64 217,65.52 214.97,65.52 214.72,65.77 214.72,70.6 214.97,70.85 216.54,70.85
+3VCC_S5 on IN2 (solid shape): outline of 143 points within 133.94,115.93 137.25,118.6
+3VPCU on TOP (solid shape): 132.3,44.37 132.3,43.51 132.25,43.46 130.55,43.46 130.5,43.51 130.5,44.5 130.55,44.55 132.13,44.55
+3VPCU on TOP (solid shape): 27.14,166.1 27.14,164.45 26.76,164.07 25.1,164.07 24.98,164.19 24.98,165.97 25.23,166.23 27.01,166.23
+3VPCU on TOP (solid shape): 166.46,68.31 167.76,68.31 168.26,67.8 168.26,67.01 167.92,66.66 165.69,66.66 165.44,66.91 165.44,68.18 165.69,68.44 166.33,68.44
+3VPCU on TOP (solid shape): 217.38,66.02 217.38,63.36 215.99,61.96 214.97,61.96 214.72,62.21 214.72,63.86 215.22,64.37 215.22,66.15 215.35,66.28 217.13,66.28
+3VPCU on TOP (solid shape): 25.87,116.19 25.87,115.05 25.61,114.79 23.96,114.79 23.57,114.4 23.57,113.41 23.32,113.16 22.04,113.16 21.93,113.27 21.93,114.39 21.94,114.42 21.98,114.44 22.02,114.44 23.8,116.21 23.8,116.27 23.81,116.3 23.85,116.32 25.74,116.32
+3VPCU on TOP (solid shape): 13.55,155.69 13.55,152 12.61,151.07 12.53,151.04 12.46,151.08 12.14,151.21 11.86,151.02 11.85,151 11.82,150.99 11.01,150.99 10.75,151.24 10.75,151.88 11.51,152.64 11.98,152.64 12,152.63 12.02,152.62 12.61,152.74 12.26,153.22 12.18,153.25 12.15,153.32 12.15,155.69 12.4,155.94 13.29,155.94
+3VPCU on TOP (solid shape): outline of 143 points within 153.37,62.09 161.41,74.75
+3VPCU on BOTTOM (solid shape): 215.86,64.63 215.86,62.72 215.6,62.47 215.6,61.96 215.35,61.71 214.21,61.71 213.95,61.96 213.95,64.75 214.08,64.88 215.6,64.88
+3VPCU on BOTTOM (solid shape): 130.12,46.86 130.3,46.68 130.3,45.97 130.75,45.52 130.9,45.52 130.91,45.5 131.87,45.5 131.9,45.47 131.9,45.45 131.9,45.25 131.89,45.21 131.86,45.2 130.91,45.2 130.9,45.19 130.9,45.01 130.91,45 131.85,45 131.89,44.99 131.9,44.95 131.9,44.55 131.96,44.49 132.4,44.49 132.4,44.48 132.4,43.43 132.25,43.28 131.92,43.28 131.02,42.38 131.02,42.25 131.01,42.22 130.97,42.2 130.69,42.2 130.68,42.21 130.35,42.21 130.16,41.94 130.16,41.86 130.18,41.78 130.17,41.68 130.08,41.64 124.04,41.64 123.93,41.74 123.93,43.14 124.06,43.27 124.06,45.9 124.04,45.93 124.04,46.6 124.16,46.72 124.5,46.72 127.85,46.72 127.99,46.86 128.98,46.86
+3VPCU on BOTTOM (solid shape): outline of 89 points within 167.47,61.58 178.52,72.88
+3VPCU on IN1 (solid shape): outline of 821 points within 40.09,41.77 103.08,46.72
+3VPCU on IN1 (solid shape): outline of 1983 points within 22.06,49.26 50.5,115.93
+3VPCU on IN2 (solid shape): outline of 2879 points within 99.4,41.89 216.24,81.84
+3VPCU on IN3 (solid shape): 35,50.72 35.28,50.72 36.1,49.89 36.28,49.89 39.46,46.72 43.65,46.72 43.9,46.47 43.9,44.18 43.34,43.62 39.4,43.62 33.36,49.67 33.36,50.45 33.64,50.73 34.98,50.73
+3VPCU on IN3 (solid shape): outline of 247 points within 148.42,72.2 154.52,74.52
+3VPCU_EC on IN2 (solid shape): outline of 180 points within 141.82,66.66 148.42,73.9
+5V on TOP (solid shape): 90.13,150.1 90.13,149.59 89.62,149.08 89.24,149.08 88.99,148.83 88.99,148.32 88.86,148.19 88.61,148.19 87.97,148.83 87.97,148.95 87.84,149.08 87.84,150.35 87.97,150.48 89.75,150.48
+5V on TOP (solid shape): 102.57,163.81 102.57,160.13 102.51,160.03 102.47,159.92 102.47,159.9 102.32,159.75 102.32,159.5 102.19,159.37 99.78,159.37 99.65,159.5 99.65,160.38 99.91,160.64 101.18,160.64 101.43,160.89 101.43,161.91 101.05,162.29 99.78,162.29 99.65,162.42 99.65,163.43 99.91,163.69 99.91,164.19 100.03,164.32 102.07,164.32
+5V on TOP (solid shape): 243.16,55.1 243.16,53.31 243.13,53.26 243.12,53.26 242.94,53 243.03,52.7 243.06,52.63 243.03,52.56 242.91,52.43 242.15,52.43 242.02,52.56 242.02,54.21 241.77,54.47 241.13,54.47 241,54.34 241,52.69 240.75,52.43 237.07,52.43 235.9,51.27 235.27,51.27 235.06,51.06 235.06,50.76 235.09,50.74 235.09,50.45 234.53,49.89 234.13,49.89 234.09,49.92 234.08,49.94 233.7,50.12 233.41,49.79 233.13,49.51 233.13,48.5 233,48.37 232.24,48.37 231.99,48.62 231.99,50.02 231.86,50.15 231.55,50.15 231.33,50.23 231.11,50.15 230.97,50.15 230.46,49.64 230.46,47.61 230.34,47.48 229.32,47.48 229.07,47.74 229.07,49.39 228.43,50.02 228.43,51.04 228.56,51.16 230.21,51.16 230.34,51.29 233.26,51.29 237.45,55.48 242.78,55.48
+5V on TOP (solid shape): outline of 1868 points within 59.65,42.78 169.74,52.47
+5V on BOTTOM (solid shape): 93.3,50.02 93.3,48.62 93.2,48.52 92.27,48.52 92.16,48.62 92.16,50.02 92.29,50.15 93.18,50.15
+5V on BOTTOM (solid shape): 219.36,46.11 219.36,43.34 219.13,43.11 215.17,43.11 215.15,43.09 214.92,43.09 214.82,43.19 214.82,46.24 215.05,46.47 219.01,46.47
+5V on BOTTOM (solid shape): 39.46,73.97 39.46,72.93 39.28,72.75 36.28,72.75 36.03,73.01 36.03,73.9 36.15,74.02 37.96,74.02 38.08,74.15 39.28,74.15
+5V on BOTTOM (solid shape): 190.84,83.42 190.84,83.26 190.84,83.25 190.6,82.16 190.71,81.05 190.72,81.03 190.71,81.01 190.59,80.88 189.06,80.88 188.55,81.39 188.55,83.17 188.93,83.55 190.71,83.55
+5V on BOTTOM (solid shape): 97.6,154.42 97.63,154.4 97.75,154.11 98,154.01 98.04,153.99 98.05,153.95 98.05,153.93 98.05,153.77 97.42,153.15 95.59,153.15 92.41,149.97 90.76,149.97 90,149.21 88.1,149.21 87.97,149.34 87.97,150.22 88.48,150.73 89.37,150.73 90.75,152.11 90.78,152.11 90.8,152.1 91.27,152.13 91.3,152.6 91.29,152.64 91.3,152.67 93.05,154.42
+5V on BOTTOM (solid shape): outline of 98 points within 8.75,161.4 11.13,165.77
+5V on IN1 (solid shape): outline of 316 points within 95.72,153.27 102.57,161.65
+5V on IN2 (solid shape): outline of 831 points within 165.69,39.61 240.75,56.75
+5V on IN2 (solid shape): outline of 1175 points within 34.88,42.66 62.44,47.99
+5V on SVCC (solid shape): outline of 533 points within 27.95,41.05 93.43,150.86
+5V on IN3 (solid shape): outline of 302 points within 165.82,50.66 190.41,85.58
+5V_FAN1 on BOTTOM (solid shape): 188.68,85.45 188.68,83.68 188.17,83.16 188.17,81.52 186.78,81.52 186.65,81.64 186.65,83.42 187.03,83.8 187.03,85.45 187.16,85.58 188.55,85.58
+5V_FAN2 on BOTTOM (solid shape): 17.1,156.63 17.1,155.94 16.85,155.69 15.96,155.69 15.71,155.43 14.82,155.43 13.93,156.32 13.93,156.6 14.08,156.75 16.98,156.75
+5V_FAN2 on BOTTOM (solid shape): 12.91,166.23 12.91,164.32 13.04,164.19 13.04,162.8 12.91,162.67 11.65,162.67 11.65,164.21 11.52,164.21 11.52,164.7 11.77,164.96 11.77,166.23 11.9,166.35 12.79,166.35
+5V_FAN2 on IN1 (solid shape): 12.79,166.23 12.79,164.32 13.29,163.81 13.29,161.27 16.21,158.35 16.21,155.94 15.71,155.43 14.84,155.43 13.42,156.85 13.42,157.26 14.57,157.26 14.57,157.21 14.58,157.15 14.6,157.1 14.62,157.06 14.65,157.01 14.68,156.97 14.73,156.94 14.77,156.91 14.82,156.89 14.87,156.88 14.93,156.88 14.98,156.88 15.03,156.89 15.08,156.91 15.13,156.94 15.17,156.97 15.21,157.01 15.24,157.06 15.26,157.1 15.27,157.15 15.28,157.21 15.28,157.26 15.27,157.31 15.26,157.36 15.24,157.41 15.21,157.46 15.17,157.5 15.13,157.53 15.08,157.56 15.03,157.57 14.98,157.59 14.93,157.59 14.87,157.59 14.82,157.57 14.77,157.56 14.73,157.53 14.68,157.5 14.65,157.46 14.62,157.41 14.6,157.36 14.58,157.31 14.57,157.26 13.42,157.26 13.42,158.23 11.52,160.13 11.52,162.92 11.01,163.43 11.01,166.23 11.13,166.35 12.66,166.35
+5V_HDD on TOP (solid shape): 33.73,78.11 34.35,78.11 34.5,77.96 34.5,76.56 34.76,76.31 35.14,76.31 35.39,76.56 37.68,76.56 37.8,76.44 37.8,74.41 37.55,74.15 35.65,74.15 35.39,73.9 35.39,73.26 35.26,73.14 33.61,73.14 33.23,73.52 33.23,78.1 33.36,78.23 33.61,78.23
+5V_HDD on BOTTOM (solid shape): 39.39,76.02 39.39,74.98 39,74.58 38.03,74.58 38.03,74.58 37.8,74.58 37.49,74.27 34.36,74.27 34.34,74.26 34.31,74.26 34.28,74.27 33.79,74.76 33.79,76.16 33.87,76.23 39.18,76.23
+5V_KB on TOP (solid shape): 75.31,51.02 75.31,50.47 75.02,50.18 75.02,48.88 74.76,48.62 71.84,48.62 71.59,48.88 71.59,51.04 71.71,51.16 75.16,51.16
+5V_KB_R on BOTTOM (solid shape): outline of 86 points within 66.28,47.38 70.66,51.98
+5V_S5 on TOP (solid shape): 10.67,120.68 10.67,119.55 8.79,119.55 8.09,120.25 6.94,120.25 6.69,120.51 6.69,121.65 6.94,121.9 9.45,121.9
+5V_S5 on TOP (solid shape): 242.78,109.84 242.78,109.08 240.5,106.79 239.73,106.79 239.1,107.43 239.1,107.81 239.86,108.57 239.86,109.46 240.37,109.97 242.66,109.97
+5V_S5 on BOTTOM (solid shape): 220.02,49.67 220.02,46.97 219.9,46.85 216.44,46.85 216.06,47.23 216.06,47.96 215.81,48.22 214.99,48.22 214.94,48.27 214.94,50.15 214.97,50.17 219.52,50.17
+5V_S5 on BOTTOM (solid shape): 232.24,80.07 232.24,79.41 232.95,78.7 232.95,77.15 232.37,76.56 232.37,76.06 232.11,75.8 231.23,75.8 230.13,76.9 230.13,80.15 230.31,80.32 231.99,80.32
+5V_S5 on BOTTOM (solid shape): 91.19,45.07 91.27,45.04 91.3,44.97 91.5,44.64 91.89,44.7 91.96,44.72 92.02,44.7 92.28,44.61 92.52,44.71 92.59,44.75 92.67,44.71 92.92,44.61 93.17,44.7 93.24,44.73 93.56,44.6 93.87,44.73 94.19,44.6 94.51,44.73 94.58,44.7 94.94,44.62 95.18,44.9 95.2,44.93 95.23,44.94 99.27,44.94 99.65,44.56 99.65,42.15 99.4,41.89 98,41.89 97.62,42.27 88.73,42.27 88.22,42.78 88.22,44.69 88.6,45.07
+5V_S5 on BOTTOM (solid shape): outline of 784 points within 36.79,42.78 65.62,46.47
+5V_S5 on IN2 (solid shape): outline of 3804 points within 161.71,45.07 241.13,108.82
+5V_S5 on IN3 (solid shape): 218.53,51.42 218.53,51.11 218.49,51.04 218.42,51.01 218.04,50.66 218.42,50.3 218.49,50.27 218.53,50.2 218.53,49.01 218.14,48.62 216.11,48.62 215.99,48.75 215.99,50.02 216.24,50.28 216.87,50.28 216.89,50.29 216.91,50.31 216.94,50.31 217.34,50.55 217.16,50.98 217.14,50.98 217.13,51.01 217.13,51.93 217.38,52.18 217.76,52.18
+5V_S5 on IN3 (solid shape): outline of 1201 points within 97.75,37.86 164.8,50.28
+5V_S5 on IN3 (solid shape): outline of 2204 points within 5.98,42.59 39.18,121.9
+5VA on TOP (solid shape): 241.13,36.18 241.13,35.8 241.64,35.29 241.64,35.17 241.64,34.65 241.51,34.53 240.75,34.53 239.99,35.29 239.99,36.18 240.12,36.31 241,36.31
+5VA on TOP (solid shape): 241.26,51.16 241.26,50.66 242.15,49.77 242.15,48.88 244.18,46.85 244.18,40.37 243.93,40.12 243.04,40.12 242.78,40.37 242.78,40.88 243.16,41.26 243.16,46.34 241.26,48.24 241.26,48.75 241,49.01 240.24,49.01 240.12,48.88 239.35,48.88 239.1,49.13 239.1,50.28 238.72,50.66 237.96,50.66 237.83,50.78 237.83,51.29 237.96,51.42 241,51.42
+5VA on IN2 (solid shape): 243.93,41.26 243.93,40.24 243.42,39.73 243.42,37.58 241.39,35.54 241.39,34.78 241.13,34.53 240.24,34.53 240.12,34.65 240.12,35.8 242.4,38.08 242.4,40.24 243.54,41.39 243.8,41.39
+5VPCU on BOTTOM (solid shape): 227.16,67.04 227.16,66.02 226.48,65.34 223.45,65.34 223.17,65.06 223.17,63.66 223.55,63.28 224.16,63.28 224.37,63.08 224.37,62.59 224.24,62.47 222.08,62.47 221.7,62.85 221.7,66.66 222.21,67.17 227.03,67.17
+5VPCU on BOTTOM (solid shape): outline of 149 points within 205.19,41.51 214.72,54.64
+5VPCU on IN2 (solid shape): outline of 561 points within 210.78,50.78 224.24,65.64
+V1.05DX_MODPHY on TOP (solid shape): outline of 1174 points within 136.2,122.67 141.56,144.38
+V1.05DX_MODPHY on BOTTOM (solid shape): outline of 114 points within 137.54,122.28 140.17,124.55
+V1.05M_VCCASW on TOP (solid shape): outline of 97 points within 153.88,116.09 160.16,119.24
+V1.05M_VCCASW on BOTTOM (solid shape): 156.71,119.36 156.77,119.34 156.84,119.3 156.91,119.28 156.93,119.28 156.98,119.24 157.03,119.24 157.15,119.12 157.52,119.12 157.55,119.11 157.57,119.09 157.57,119.03 157.54,118.98 157.44,118.85 157.41,118.68 157.6,118.34 157.98,118.37 158.02,118.38 158.05,118.36 158.07,118.33 158.07,118.29 158.07,117.08 157.69,116.7 157.06,116.7 156.8,116.95 156.8,117.21 156.88,117.46 156.8,117.7 156.8,118.22 156.78,118.25 156.78,118.26 156.67,118.47 156.47,118.57 156.45,118.58 156.42,118.6 156.3,118.6 156,118.9 155.97,118.98 156.02,119.06 156.11,119.13 156.17,119.23 156.22,119.28 156.3,119.28 156.48,119.27 156.64,119.34
+V1.05M_VCCASW on BOTTOM (solid shape): 139.11,116.87 139.13,116.87 139.14,116.86 139.3,116.78 139.48,116.81 139.49,116.81 139.92,116.81 140.04,116.7 140.04,116.54 140.01,116.51 140.01,116.23 140,116.22 140.14,115.88 140.48,116.03 140.48,116.04 140.51,116.06 140.62,116.06 140.64,116.04 140.65,116.03 140.71,115.93 140.81,115.87 140.87,115.82 140.88,115.75 140.86,115.65 140.87,115.55 140.87,115.52 140.86,115.5 140.73,115.37 140.69,115.33 140.67,115.29 140.29,114.92 140.17,114.92 140.07,115.02 140.06,115.04 140.06,115.05 139.96,115.35 139.66,115.45 139.64,115.45 139.62,115.46 139.53,115.55 139.53,115.87 139.54,115.89 139.55,115.9 139.53,116.35 139.09,116.26 139.09,116.26 139.02,116.19 138.77,116.19 138.52,116.44 138.52,116.82 138.57,116.87
+V1.05M_VCCASW on IN2 (solid shape): outline of 1353 points within 138.26,114.54 158.33,119.28
+V1.05S_APLLOPI on TOP (solid shape): 156.8,113.65 156.8,111.49 157.57,110.73 157.57,109.13 157.56,109.1 157.54,109.09 157.51,109.08 156.3,109.08 155.41,109.97 155.41,110.59 156.63,110.59 156.63,110.54 156.64,110.49 156.66,110.44 156.68,110.39 156.71,110.34 156.75,110.31 156.79,110.27 156.84,110.25 156.88,110.23 156.94,110.21 156.99,110.21 157.04,110.21 157.09,110.23 157.14,110.25 157.19,110.27 157.23,110.31 157.27,110.34 157.3,110.39 157.32,110.44 157.34,110.49 157.35,110.54 157.35,110.59 157.34,110.65 157.32,110.7 157.3,110.75 157.27,110.79 157.23,110.83 157.19,110.86 157.14,110.89 157.09,110.91 157.04,110.92 156.99,110.92 156.94,110.92 156.88,110.91 156.84,110.89 156.79,110.86 156.75,110.83 156.71,110.79 156.68,110.75 156.66,110.7 156.64,110.65 156.63,110.59 155.41,110.59 155.41,111.62 154.77,112.25 154.77,113.65 155.03,113.9 156.55,113.9
+V1.05S_CORE_PCH on TOP (solid shape): 133.94,122.67 134.32,122.67 134.58,122.41 134.58,122.28 134.45,122.16 133.69,122.16 133.26,121.73 131.81,121.73 131.71,121.62 131.71,121.42 131.4,121.12 131,121.12 130.72,121.4 130.13,121.4 130.01,121.52 130.01,122.03 130.13,122.16 130.77,122.16 130.9,122.03 131.07,122.03 131.07,122.03 131.2,122.01 131.32,122.03 131.33,122.03 131.4,122.03 131.68,122.31 131.68,122.82 132.29,123.43 133.18,123.43
+V1.05S_CORE_PCH on IN2 (solid shape): outline of 89 points within 130.8,121.14 138.25,126.12
+V1.05S_CORE_PCH on IN3 (solid shape): outline of 400 points within 131.02,116.32 140.74,122.67
+V1.5S_VCCATS on TOP (solid shape): outline of 189 points within 135.21,124.93 136.79,128.63
+V3.3S_VCCPTS on IN2 (solid shape): outline of 394 points within 139.02,124.44 143.85,128.63
+V3.3S_VCCSDIO on IN2 (solid shape): outline of 148 points within 148.17,122.41 151.34,124.7
+VCCIN on TOP (solid shape): 130.39,150.48 130.39,149.84 131.15,149.08 131.15,147.23 130.21,146.29 130.21,146.11 130.19,146.09 130.19,145.66 130.19,145.61 130.21,145.39 130.83,144.76 131.76,144.76 131.89,144.64 131.89,144.36 132.1,144.14 132.2,144.14 132.29,144.13 132.39,144.14 132.53,144.14 132.67,144.28 132.67,144.69 132.75,144.76 136.1,144.76 136.36,144.51 136.36,141.41 136.15,141.21 134.91,141.21 134.71,141.41 134.71,142.48 134.32,142.86 133.05,142.86 132.8,142.6 132.8,141.97 132.42,141.59 131.21,141.59 131.12,141.65 131.13,141.75 130.84,142.33 130.56,141.75 130.57,141.65 130.48,141.59 125.34,141.59 124.96,141.97 124.96,150.24 125.07,150.34 125.07,150.35 125.32,150.61 130.26,150.61
+VCCIN on TOP (solid shape): outline of 581 points within 109.94,115.93 128.37,128
+VCCIN on BOTTOM (solid shape): 134.07,144 138.13,144 139.53,142.6 139.53,139.43 139.28,139.18 135.85,139.18 135.47,139.56 134.07,139.56 133.18,140.45 133.18,142.53 132.52,143.19 132.52,143.7 132.98,144.15 132.98,144.56 133.05,144.64 133.44,144.64
+VCCIN on BOTTOM (solid shape): outline of 136 points within 118.83,139.52 131.78,154.87
+VCCIN on BOTTOM (solid shape): outline of 1249 points within 109.56,115.17 132.42,128.25
+VCCIN on IN2 (solid shape): outline of 4463 points within 108.61,120.51 136.48,150.33
+VCCIN on SVCC (solid shape): 132.8,148.87 132.8,147.06 132.84,146.86 132.95,146.69 135.62,144.02 135.78,143.91 135.98,143.87 137.67,143.87 138.13,143.41 138.13,134.1 138.17,133.9 138.28,133.74 138.64,133.38 138.64,129.48 137.67,128.51 133.44,128.51 133.24,128.47 133.08,128.36 132.06,127.34 131.95,127.18 131.91,126.98 131.91,124.53 131.32,123.94 130.13,123.94 129.88,124.04 129.63,123.94 129.25,123.94 129.05,123.9 128.88,123.79 127.87,122.77 127.76,122.6 127.72,122.41 127.72,118.6 116.3,118.6 116.1,118.56 115.93,118.45 113.64,116.17 113.6,116.12 113.56,116.06 105.55,116.06 105.52,116.12 105.47,116.17 104.72,116.92 104.62,117.23 104.32,117.32 103.08,118.56 103.08,130.84 107.1,134.86 109.68,134.86 109.88,134.9 110.05,135.01 116.91,141.87 117.15,141.97 117.26,142.22 120.85,145.81 121.3,145.9 121.39,146.35 121.78,146.74 122.49,147.27 123.02,147.98 124.63,149.59 132.08,149.59
AGND_CPU on BOTTOM (solid shape): 151.06,152.56 151.06,151.75 150.76,151.45 149.39,151.45 149.31,151.37 149.31,148.91 149.25,148.84 146.73,148.84 146.6,148.97 146.6,152.53 146.73,152.65 150.97,152.65
AGND_DDR on BOTTOM (solid shape): 199.17,60.56 199.17,52.23 197.85,50.91 197.57,50.91 197.27,51.22 197.27,52.23 197.67,52.64 197.67,53.83 197.57,53.93 196.43,53.93 196.3,54.06 196.3,56.02 196.5,56.22 197.54,56.22 197.76,56.44 197.78,56.44 197.78,57.37 197.75,57.37 197.71,57.39 197.7,57.42 197.7,58.02 197.49,58.23 197.49,60.49 197.85,60.84 198.89,60.84
GND on TOP (solid shape): 30.99,157.01 30.99,154.24 30.88,154.14 30.43,154.14 29.59,154.98 29.59,157.03 29.7,157.14 30.86,157.14
GND on TOP (solid shape): 94.7,86.09 94.7,81.39 94.45,81.14 93.3,81.14 93.05,81.39 93.05,86.09 93.3,86.34 94.45,86.34
GND on TOP (solid shape): 96.48,71.87 96.48,65.13 96.1,64.75 93.3,64.75 93.05,65.01 93.05,71.61 93.43,71.99 96.35,71.99
GND on TOP (solid shape): 122.77,53.45 122.77,52.69 122.51,52.43 116.04,52.43 115.78,52.69 115.78,53.45 116.04,53.7 122.51,53.7
GND on TOP (solid shape): 156.42,104.89 156.42,101.58 156.3,101.46 154.52,101.46 154.39,101.58 154.39,104.89 154.52,105.01 156.3,105.01
GND on TOP (solid shape): 217.76,87.87 217.76,84.06 217.64,83.93 213.83,83.93 213.7,84.06 213.7,87.87 213.83,87.99 217.64,87.99
GND on TOP (solid shape): 236.94,42.15 236.94,38.08 236.81,37.96 232.75,37.96 232.62,38.08 232.62,42.15 232.75,42.27 236.81,42.27
GND on TOP (solid shape): 32.98,78.22 32.98,73.52 32.72,73.26 31.96,73.26 31.45,73.77 31.45,78.22 31.58,78.34 32.85,78.34
GND on TOP (solid shape): 9.48,126.98 9.48,124.19 8.72,123.43 7.96,123.43 7.88,123.51 7.88,123.55 7.88,123.56 7.88,127.04 8.09,127.24 9.23,127.24
GND on TOP (solid shape): 39.2,123.94 39.2,115.81 38.69,115.3 36.28,115.3 36.15,115.43 36.15,119.24 38.19,121.27 38.19,123.94 38.31,124.06 39.07,124.06
GND on TOP (solid shape): 63.71,120 63.71,117.84 62.95,117.08 60.66,117.08 60.03,116.44 59.65,116.44 59.39,116.7 59.39,120 59.52,120.13 63.59,120.13
GND on TOP (solid shape): 122.89,89.01 122.89,87.36 122.13,86.6 118.07,86.6 117.94,86.72 117.94,90.15 118.07,90.28 121.62,90.28
GND on TOP (solid shape): 131.53,139.18 131.53,136.51 131.02,136 128.36,136 127.72,136.64 127.72,139.18 127.85,139.3 131.4,139.3
GND on TOP (solid shape): 185.81,78.9 185.81,76.69 185.66,76.54 183.07,76.54 182.89,76.72 182.89,78.98 183.02,79.1 183.02,79.13 183.09,79.21 185.51,79.21
GND on TOP (solid shape): 203.92,56.35 203.92,53.96 203.84,53.88 202.29,53.88 202.22,53.96 202.22,54.26 202.24,54.29 202.24,56.5 202.32,56.58 203.69,56.58
GND on TOP (solid shape): 195.54,77.05 195.54,72.45 195.41,72.32 193.96,72.32 193.81,72.48 193.81,76.46 193.79,76.49 193.79,77.07 193.96,77.25 195.33,77.25
GND on TOP (solid shape): 64.78,122.27 64.78,121.38 64.65,121.25 59.56,121.25 59.19,121.62 59.19,122.27 59.32,122.39 64.65,122.39
GND on TOP (solid shape): 94.83,127.24 94.83,124.19 94.7,124.06 92.92,124.06 92.8,124.19 92.8,126.09 92.92,126.22 93.3,126.22 93.56,126.48 93.56,127.22 93.7,127.36 94.7,127.36
GND on TOP (solid shape): 103.72,146.29 103.72,145.78 104.35,145.14 104.35,143.75 103.84,143.24 99.4,143.24 99.15,143.49 99.15,144.38 99.91,145.14 99.91,146.29 100.03,146.41 103.59,146.41
GND on TOP (solid shape): 141.82,148.83 141.82,147.05 141.72,146.95 136.89,146.95 136.58,147.25 136.58,148.09 136.69,148.19 137.22,148.19 137.45,148.42 137.45,148.68 137.75,148.98 141.66,148.98
GND on TOP (solid shape): 179.16,83.17 179.16,80.78 178.14,79.77 177.12,79.77 177.05,79.84 177.05,80.63 176.79,80.88 175.22,80.88 175.09,81.01 175.09,83.17 175.85,83.93 178.39,83.93
GND on TOP (solid shape): 203.03,62.06 203.03,58.73 202.24,57.95 200.67,57.95 200.52,58.1 200.52,60.03 199.78,60.77 199.78,62.01 200.08,62.32 202.78,62.32
GND on TOP (solid shape): 132.93,152.13 132.93,150.73 132.55,150.35 131.02,150.35 130.51,150.86 124.67,150.86 124.16,151.37 124.16,152.26 124.29,152.38 128.23,152.38 128.61,152.76 132.29,152.76
GND on TOP (solid shape): 19.29,118.83 19.29,118.81 19.32,118.7 19.39,118.61 19.39,117.46 19.14,117.2 15.71,117.2 15.45,117.46 15.45,118.73 15.71,118.98 19.14,118.98
GND on TOP (solid shape): 35.65,82.28 35.65,81.77 37.8,79.61 37.8,77.58 37.68,77.45 35.52,77.45 35.39,77.58 35.39,79.61 34.25,80.76 34.25,82.15 34.5,82.41 35.52,82.41
GND on TOP (solid shape): 69.55,80.37 70.32,80.37 70.57,80.12 70.57,79.1 70.44,78.98 68.13,78.98 68.08,79 68.03,79.01 67.83,79.01 67.6,79.24 67.6,81.04 67.95,81.39 68.54,81.39
GND on TOP (solid shape): 56.09,110.35 56.09,107.81 55.97,107.68 53.55,107.68 53.3,107.93 53.3,109.2 53.04,109.46 50.25,109.46 50,109.71 50,110.6 50.25,110.85 55.58,110.85
GND on TOP (solid shape): 58.89,166.1 58.89,164.83 57.87,163.81 57.87,162.54 57.51,162.18 51.59,162.18 51.42,162.35 51.42,162.76 51.41,162.78 51.41,163.45 50.39,164.46 50.39,166.23 50.52,166.35 58.63,166.35
GND on TOP (solid shape): 42.83,120.13 42.87,120.11 42.88,120.08 42.88,116.95 43.01,116.82 43.65,116.82 43.9,116.57 43.9,114.16 43.39,113.65 42.25,113.65 41.87,114.03 41.87,116.44 41.61,116.7 41.61,120 41.74,120.13
GND on TOP (solid shape): 57.49,65.26 57.49,63.85 57.15,63.52 57.07,63.52 57.07,63.51 55.21,63.51 54.87,63.18 53.82,63.18 53.81,63.17 53.65,63.17 53.54,63.27 53.54,64.01 53.69,64.15 54.55,64.15 54.74,64.35 54.73,64.36 54.73,65.52 54.99,65.77 56.98,65.77
GND on TOP (solid shape): 40.52,165.24 40.52,164.81 40.4,164.68 38.31,164.68 37.98,164.35 37.98,164.02 37.91,163.95 30.7,163.95 30.44,163.69 30.44,161.91 30.87,161.48 30.87,158.84 30.74,158.71 29.24,158.71 29.04,158.91 29.04,164.83 29.86,165.65 40.12,165.65
GND on TOP (solid shape): 129.63,125.21 129.63,123.94 128.48,122.79 128.48,122.41 127.97,121.9 115.66,121.9 115.4,122.16 114.13,122.16 113.88,121.9 113.88,121.4 113.75,121.27 112.73,121.27 112.61,121.4 112.61,124.57 112.86,124.82 113.75,124.82 114,124.57 114,124.32 114.26,124.06 128.36,124.06 128.61,124.32 128.61,125.33 128.74,125.46 129.37,125.46
GND on TOP (solid shape): 66.05,93.96 66.05,87.44 65.92,87.31 61.15,87.31 61.1,87.36 61.1,88.76 58.89,90.97 58.89,93.2 59.42,93.74 59.9,93.74 60.51,94.34 65.67,94.34
GND on TOP (solid shape): 191.58,65.9 191.58,64.96 191.13,64.51 191.13,58.95 190.86,58.68 190.08,58.68 189.95,58.56 189.95,57.87 189.72,57.64 186.19,57.64 185.94,57.9 185.94,60.05 184.31,61.68 184.31,62.34 184.79,62.82 186.83,62.82 187.31,63.31 187.28,63.33 187.28,66.18 188.05,66.94 190.53,66.94
GND on TOP (solid shape): 130.44,67.29 130.44,66.91 131,66.35 131,65.62 130.92,65.54 130.74,65.54 130.46,65.82 130.46,66.28 129.14,67.6 127.8,67.6 127.59,67.4 127.59,66.74 127.72,66.61 127.72,64.32 127.62,64.22 127.36,64.22 127.24,64.35 127.24,66.89 126.88,67.24 126.88,67.9 127.03,68.06 127.44,68.06 128.02,68.64 129.09,68.64
GND on TOP (solid shape): 74.06,76.76 74.06,75.46 74.15,75.37 75.35,75.37 75.45,75.47 75.45,76.67 75.6,76.82 77.05,76.82 77.94,75.93 80.02,75.93 80.27,75.68 80.27,75.09 80.22,75.04 79.82,75.04 79.46,74.69 79.46,73.53 79.08,73.15 77.92,73.15 77.83,73.24 68.82,73.24 67.57,74.48 67.57,74.74 67.62,74.79 71.46,74.79 71.84,75.17 71.84,76.56 72.09,76.82 74,76.82
