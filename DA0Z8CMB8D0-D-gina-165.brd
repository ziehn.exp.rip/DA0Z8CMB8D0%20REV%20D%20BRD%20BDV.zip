# Allegro board DA0Z8CMB8D0-D-gina-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ35: length 42.9
  IN3 w0.089: v1(134.25,101.78) 134.23,101.78 133.86,101.41 133.86,99.62 135.28,98.21 137.57,98.21 140.62,95.16 140.62,94.76 143.72,91.66 144.25,91.66 147.66,88.25 147.98,88.25 149.81,86.42 149.81,84.41 151.4,82.82 151.4,80.59 150.52,79.71 150.52,77.13 v1(150.58,77.07)
  BOTTOM w0.076: v1(134.25,101.78) 133.1,102.93 133.1,105.76 132.93,105.94 132.93,106.73 132.83,106.83 132.83,107.57 132.53,107.86 U45.AW21
  BOTTOM w0.14: JDIM1.174 150.68,76.97 v1(150.58,77.07)
M_B_DQ36: length 44.3
  IN3 w0.089: v1(146.78,82.27) 147.02,82.03 147.15,82.03 147.2,82.08 147.2,82.86 147.15,82.91 146.91,82.91 146.82,83 146.82,83.21 146.91,83.3 147.18,83.3 147.25,83.37 147.25,83.65 147.17,83.73 146.91,83.73 146.82,83.82 146.82,84.03 146.91,84.12 147.19,84.12 147.25,84.19 147.25,84.43 147.16,84.52 146.91,84.52 146.82,84.61 146.82,84.85 146.92,84.95 147.18,84.95 147.25,85.02 147.25,85.5 146.95,85.8 146.71,85.8 145.13,87.39 145.02,87.39 144.45,87.95 144.01,87.95 139.71,92.25 139.17,92.25 137.84,93.58 137.84,93.71 138.2,94.06 138.2,94.19 138.04,94.34 137.92,94.34 137.56,93.98 137.43,93.98 137.28,94.14 137.28,94.26 137.64,94.62 137.64,94.75 137.48,94.9 137.36,94.9 137,94.54 136.88,94.54 136.72,94.69 136.72,94.82 137.06,95.16 137.06,95.32 136.94,95.43 136.78,95.43 136.44,95.1 136.32,95.1 136.21,95.21 136.21,95.34 136.54,95.67 136.54,95.82 136.43,95.92 136.28,95.92 135.98,95.61 135.81,95.61 134.4,97.03 134.4,97.24 132.55,99.09 132.55,99.35 132.47,99.42 132.24,99.42 132.17,99.5 132.17,99.81 132.24,99.88 132.5,99.88 132.55,99.93 132.55,100.19 132.47,100.26 v1(132.12,100.26)
  BOTTOM w0.076: U45.AV23 130.8,108.36 130.8,107.7 130.75,107.6 130.72,107.56 130.72,107.18 130.86,107.04 130.86,105.56 131.04,105.38 131.04,101.33 v1(132.12,100.26)
  BOTTOM w0.14: JDIM1.163 147.38,82.51 147.14,82.27 v1(146.78,82.27)
M_B_DQ37: length 45.1
  IN3 w0.089: v1(148.88,77.19) 148.88,77.19 148.88,76.97 149.03,76.82 149.34,76.82 149.49,76.97 149.49,79.94 148.32,81.11 148.32,85.72 147.32,86.72 147.08,86.72 144.94,88.86 144.42,88.86 139.11,94.17 139.11,94.57 138.54,95.13 136.95,96.73 136.05,96.73 135.32,97.47 134.93,97.47 133.08,99.32 133.08,101.9 v1(132.12,102.86)
  BOTTOM w0.076: U45.AU23 131.95,109.4 132.15,109.19 132.15,108.95 132.13,108.94 132.13,108.56 132.15,108.54 132.15,108.35 132.14,108.34 132.08,108.2 132.08,107.99 132.15,107.84 132.15,107.71 132.1,107.6 132.08,107.55 132.08,106.88 132.41,106.54 132.41,105.65 132.57,105.5 132.57,103.32 v1(132.12,102.86)
  BOTTOM w0.14: JDIM1.166 148.28,76.95 148.53,77.19 v1(148.88,77.19)
M_B_DQ38: length 44
  IN3 w0.089: v1(134.25,99.92) 134.25,99.5 135.36,98.38 137.83,98.38 140.92,95.29 140.92,94.89 143.85,91.96 144.38,91.96 147.79,88.55 148.11,88.55 150.17,86.49 150.17,85.86 150.3,85.73 150.48,85.73 150.55,85.81 150.81,85.81 150.94,85.68 150.94,84.95 150.81,84.82 150.44,84.82 150.33,84.71 150.33,84.55 150.44,84.44 150.73,84.44 150.8,84.36 150.8,83.96 151.71,83.06 151.71,80.93 151.89,80.74 v1(152.18,80.74)
  BOTTOM w0.076: v1(134.25,99.92) 133.87,99.92 132.75,101.04 132.75,105.6 132.59,105.76 132.59,106.6 132.24,106.94 132.24,107.51 132.29,107.62 132.31,107.67 132.31,107.87 132.29,107.93 132.25,108.02 132.24,108.03 132.24,108.16 132.27,108.21 132.29,108.27 132.43,108.4 U45.AV21
  BOTTOM w0.14: v1(152.18,80.74) 151.43,80.74 151.09,81.09 151.09,82.08 150.98,82.19 JDIM1.175
M_B_DQ39: length 44.7
  IN3 w0.089: v1(134.25,103.01) 133.61,102.37 133.61,99.54 135.13,98.03 137.32,98.03 140.31,95.04 140.31,94.64 143.6,91.35 144.12,91.35 146.42,89.06 147.53,87.94 147.77,87.94 149.5,86.21 149.5,84.29 151.1,82.69 151.1,80.71 150.08,79.7 v1(150.08,78.72)
  BOTTOM w0.076: U45.AU21 132.43,109.16 132.72,108.87 132.72,108.63 132.7,108.61 132.7,108.34 132.83,108.22 132.83,107.8 132.99,107.64 132.99,106.92 133.09,106.82 133.09,106 133.31,105.79 133.31,103.96 v1(134.25,103.01)
  BOTTOM w0.14: JDIM1.176 151.28,77.52 v1(150.08,78.72)
M_B_DQ40: length 54
  IN1 w0.114: v1(134.15,105.51) 134.88,104.78 134.88,99.24 134.55,98.92 134.55,94.55 128.76,88.76 116.32,88.76 111.96,84.4 110.2,84.4 108.6,82.8 108.6,80.91 108.73,80.78 109.05,80.78 109.18,80.65 109.18,80.37 109.05,80.25 108.73,80.25 108.6,80.12 108.6,79.84 108.73,79.71 109.15,79.71 109.28,79.59 109.28,79.31 109.15,79.18 109,79.18 108.87,79.05 108.87,78.84 109,78.72 v1(109.28,78.72)
  BOTTOM w0.076: U45.AY19 133.59,107.42 133.59,106.44 134.15,105.88 v1(134.15,105.51)
  BOTTOM w0.14: JDIM1.40 108.08,77.52 v1(109.28,78.72)
M_B_DQ41: length 55.1
  IN1 w0.114: v1(107.52,79.98) 107.53,79.98 107.65,79.86 107.65,79.31 107.78,79.18 108.14,79.18 108.27,79.31 108.27,82.94 110.07,84.73 111.82,84.73 116.18,89.09 128.63,89.09 128.89,89.36 128.89,89.54 128.74,89.7 128.74,89.86 128.88,90 129.06,90 129.19,89.88 129.41,89.88 134.22,94.69 134.22,99.04 134.66,99.49 134.66,104.52 134.3,104.89 v1(134.15,104.89)
  BOTTOM w0.076: v1(134.15,104.89) 133.74,105.3 133.74,106.04 133.42,106.36 133.42,107.01 133.32,107.11 133.32,107.82 133.6,108.1 U45.AW19
  BOTTOM w0.14: JDIM1.41 108.38,80.85 v1(107.52,79.98)
M_B_DQ42: length 53.7
  IN1 w0.114: v1(135.98,103.97) 136.13,103.97 137.58,102.52 137.58,92.91 129.01,84.34 116.99,84.34 115.44,82.79 114.16,82.79 113.86,82.48 113.86,80.1 112.99,79.24 111,79.24 110.48,78.72 v1(110.45,78.72)
  BOTTOM w0.076: U45.AY17 134.96,107.29 135.2,107.05 135.2,106.29 135.85,105.65 135.85,104.1 v1(135.98,103.97)
  BOTTOM w0.14: v1(110.45,78.72) 110.48,78.72 111.68,77.52 JDIM1.52
M_B_DQ43: length 54.8
  IN1 w0.114: v1(136.21,102.08) 136.59,101.69 136.59,94.21 129.01,86.63 120.13,86.63 119.16,85.66 118.98,85.66 118.86,85.79 118.86,86 118.73,86.13 118.45,86.13 118.32,86 118.32,85.56 118.2,85.43 117.92,85.43 117.79,85.56 117.79,86 117.66,86.13 117.27,86.13 116.75,85.61 116.75,85.56 114.97,83.78 113.75,83.78 112.66,82.68 112.25,82.68 112.1,82.53 112.1,82.2 111.97,82.08 111.43,82.08 111.31,81.95 111.31,81.59 111.43,81.47 111.97,81.47 112.1,81.34 112.1,81.06 111.97,80.93 111.51,80.93 111.38,80.81 111.38,80.53 111.51,80.4 112.45,80.4 112.58,80.53 v1(112.58,80.74)
  BOTTOM w0.076: v1(136.21,102.08) 136.61,102.48 136.61,103.9 136.09,104.41 136.09,105.66 135.38,106.37 135.38,107.17 135.26,107.3 135.26,107.51 135.21,107.62 135.18,107.67 135.18,107.88 U45.AW17
  BOTTOM w0.14: JDIM1.51 111.38,82.26 111.45,82.19 111.45,81.87 v1(112.58,80.74)
M_B_DQ44: length 55.5
  IN1 w0.114: v1(134.25,103.65) 133.83,103.23 133.83,99.54 133.89,99.48 133.89,95.62 133.6,95.32 133.6,95.16 133.83,94.93 133.83,94.77 133.64,94.58 133.48,94.58 133.25,94.81 133.09,94.81 132.9,94.62 132.9,94.46 133.13,94.23 133.13,94.07 132.94,93.88 132.78,93.88 132.55,94.11 132.39,94.11 132.17,93.89 132.17,93.79 132.44,93.51 132.44,93.38 132.24,93.18 132.08,93.18 131.85,93.41 131.69,93.41 131.5,93.22 131.5,93.06 131.68,92.87 131.68,92.62 131.54,92.48 131.38,92.48 131.15,92.71 130.99,92.71 130.8,92.52 130.8,92.36 131.03,92.13 131.03,91.97 130.84,91.78 130.68,91.78 130.45,92.01 130.29,92.01 130.12,91.85 130.12,91.63 130.33,91.43 130.33,91.26 130.14,91.08 129.98,91.08 129.75,91.31 129.58,91.31 129.4,91.12 129.4,90.96 129.63,90.73 129.63,90.56 129.47,90.41 129.35,90.41 129.12,90.64 128.91,90.64 127.7,89.42 116.05,89.42 111.68,85.06 109.93,85.06 107.94,83.07 107.94,81.86 107.59,81.51 v1(107.52,81.51)
  BOTTOM w0.076: U45.AV19 133.72,108.62 133.16,108.05 133.16,107.04 133.26,106.94 133.26,106.29 133.56,105.98 133.56,104.32 134.23,103.65 v1(134.25,103.65)
  BOTTOM w0.14: v1(107.52,81.51) 108.01,82 108.01,82.51 107.78,82.74 JDIM1.39
M_B_DQ45: length 56.4
  IN1 w0.114: v1(112.58,82.27) 112.71,82.27 113.89,83.45 115.12,83.45 116.67,85 119.07,85 120.37,86.3 120.86,86.3 121.24,85.91 121.9,85.91 122,86.01 122,86.19 122.11,86.3 122.38,86.3 122.49,86.19 122.49,86.09 122.62,85.96 122.86,85.96 122.99,86.09 122.99,86.19 123.1,86.3 123.37,86.3 123.48,86.19 123.48,86 123.6,85.89 123.86,85.89 123.98,86 123.98,86.19 124.09,86.3 129.15,86.3 129.79,86.94 129.9,86.94 130.06,86.78 130.18,86.78 130.45,87.05 130.45,87.13 130.3,87.29 130.3,87.43 130.49,87.61 130.68,87.61 130.8,87.48 130.97,87.48 131.15,87.67 131.15,87.83 131,87.99 131,88.15 131.19,88.34 131.35,88.34 131.5,88.18 131.67,88.18 131.86,88.37 131.86,88.53 131.7,88.69 131.7,88.85 131.89,89.04 132.05,89.04 132.23,88.86 132.41,88.86 132.62,89.07 132.62,89.25 132.46,89.4 132.46,89.56 132.6,89.7 132.78,89.7 132.91,89.58 133.07,89.58 133.26,89.77 133.26,89.93 133.1,90.09 133.1,90.25 133.29,90.44 133.45,90.44 133.61,90.28 133.77,90.28 133.96,90.47 133.96,90.63 133.8,90.79 133.8,90.95 133.99,91.14 134.15,91.14 134.31,90.98 134.47,90.98 134.66,91.17 134.66,91.33 134.5,91.49 134.5,91.65 134.69,91.84 134.85,91.84 135.01,91.68 135.17,91.68 135.36,91.87 135.36,92.04 135.2,92.19 135.2,92.35 135.39,92.54 135.55,92.54 135.71,92.39 135.87,92.39 136.06,92.57 136.06,92.69 135.9,92.85 135.9,93.03 136.04,93.16 136.22,93.16 136.38,93 136.5,93 136.69,93.19 136.69,93.33 136.51,93.51 136.51,93.66 136.92,94.07 136.92,101.97 v1(136.21,102.69)
  BOTTOM w0.076: U45.AU19 134.38,109.4 134.58,109.19 134.58,108.35 134.57,108.34 134.51,108.2 134.51,107.99 134.58,107.84 134.58,107.71 134.51,107.55 134.51,107.24 134.87,106.87 134.87,106.16 135.16,105.87 135.16,103.09 135.4,102.85 136.04,102.85 v1(136.21,102.69)
  BOTTOM w0.14: v1(112.58,82.27) 112.11,82.27 111.98,82.4 JDIM1.53
M_B_DQ46: length 55.2
  IN1 w0.114: v1(110.45,77.19) 110.45,77.22 110.02,77.65 110.02,78.87 110.72,79.57 112.75,79.57 113.53,80.35 113.53,82.62 114.03,83.12 115.3,83.12 116.85,84.67 124.82,84.67 126.02,85.86 129.88,85.86 137.25,93.23 137.25,102.24 v1(136.18,103.31)
  BOTTOM w0.076: U45.AV17 134.96,108.51 134.72,108.27 134.67,108.16 134.67,108.03 134.68,108.01 134.72,107.93 134.72,107.93 134.75,107.87 134.75,107.67 134.67,107.51 134.67,107.3 135.04,106.94 135.04,106.23 135.57,105.7 135.57,103.82 136.07,103.31 v1(136.18,103.31)
  BOTTOM w0.14: v1(110.45,77.19) 110.84,77.19 111.08,76.95 JDIM1.50
M_B_DQ47: length 56.2
  IN1 w0.114: v1(109.28,77.19) 109.69,77.6 109.69,80.65 108.93,81.41 108.93,82.66 110.34,84.07 112.09,84.07 116.46,88.43 129.02,88.43 134.98,94.4 134.98,98.81 135.1,98.92 135.1,101.76 135.22,101.89 135.54,101.89 v1(135.67,101.76)
  BOTTOM w0.076: U45.AU17 135.26,109.1 135.26,108.35 135.35,108.26 135.35,107.71 135.4,107.6 135.42,107.55 135.42,107.39 135.55,107.26 135.55,106.43 136.32,105.66 136.32,104.47 136.86,103.92 136.86,102.38 136.63,102.14 136.63,101.95 136.6,101.92 136.6,101.92 136.37,101.69 135.75,101.69 v1(135.67,101.76)
  BOTTOM w0.14: v1(109.28,77.19) 108.68,76.59 JDIM1.42
M_B_DQ48: length 49.4
  IN3 w0.089: v1(156.55,78.85) 156.55,78.55 156.42,78.42 156.15,78.42 156.02,78.55 156.02,79.21 156.15,79.33 156.6,79.33 156.73,79.46 156.73,79.59 156.6,79.72 156.15,79.72 156.02,79.84 156.02,84.5 155.61,84.91 155.61,85.56 155.28,85.89 155.05,85.89 143.93,97.01 143.36,97.01 141.84,98.53 141.84,99.08 141.47,99.45 140.92,99.45 138.86,101.51 138.86,104.62 136.94,106.54 136.69,106.54 136.58,106.64 136.58,106.72 136.24,107.06 135.78,107.06 135.29,107.56 135.06,107.56 134.02,108.59 134.02,108.83 133.45,109.4 133.12,109.4 132.65,109.86 v1(132.65,110.23)
  BOTTOM w0.102: v1(132.65,110.23) 132.98,110.56 U45.AR21
  BOTTOM w0.14: v1(156.55,78.85) 156.09,78.85 155.81,78.57 155.81,77.01 156.08,76.74 JDIM1.192
M_B_DQ49: length 50.2
  IN3 w0.089: v1(152.49,78.68) 152.87,78.68 152.98,78.8 152.98,78.9 153.11,79.03 153.32,79.03 153.45,78.9 153.45,78.55 153.58,78.42 153.77,78.42 153.91,78.55 153.91,78.97 154.04,79.1 154.23,79.1 154.36,78.97 154.36,78.56 154.5,78.42 154.7,78.42 154.84,78.56 154.84,83.98 153.54,85.27 153.54,85.69 143.42,95.81 142.89,95.81 137.68,101.02 137.68,104.13 136.46,105.34 135.83,105.34 134.72,106.45 134.13,106.45 131.7,108.88 v1(131.7,110.21)
  BOTTOM w0.102: U45.AR22 132.05,110.56 v1(131.7,110.21)
  BOTTOM w0.14: JDIM1.182 153.08,78.09 v1(152.49,78.68)
M_B_DQ50: length 52
  IN3 w0.089: v1(156.73,82.25) 156.73,82.71 156.85,82.84 156.98,82.84 157.09,82.95 157.09,83.11 156.98,83.22 156.76,83.22 156.65,83.33 156.65,83.49 156.76,83.6 157.11,83.6 157.24,83.73 157.24,84.15 156.22,85.17 156.22,85.81 155.46,86.57 155.46,86.72 155.56,86.83 155.56,86.99 155.45,87.1 155.28,87.1 155.07,86.89 154.91,86.89 154.79,87.01 154.79,87.17 155.04,87.42 155.04,87.58 154.92,87.7 154.76,87.7 154.51,87.45 154.35,87.45 154.24,87.56 154.24,87.73 154.48,87.97 154.48,88.14 154.37,88.25 154.2,88.25 153.96,88.01 153.79,88.01 153.67,88.13 153.67,88.29 153.81,88.43 153.81,88.6 153.68,88.72 153.51,88.72 153.41,88.62 153.18,88.62 144.18,97.62 143.61,97.62 142.45,98.78 142.45,99.34 141.25,100.53 141.13,100.53 141,100.41 140.84,100.41 140.72,100.52 140.72,100.68 141.14,101.11 141.14,101.27 141.03,101.38 140.86,101.38 140.47,100.99 140.34,100.99 140.19,101.14 140.19,101.27 140.59,101.66 140.59,101.83 140.47,101.94 140.31,101.94 139.91,101.54 139.79,101.54 139.63,101.7 139.63,101.82 139.73,101.92 139.73,102.05 139.51,102.28 139.51,106.39 138.18,107.72 136.29,107.72 134.42,109.58 134.25,109.58 134.03,109.8 133.44,109.8 133.23,110.01 133.23,110.73 133.14,110.82 133.14,112.37 v1(132.68,112.83)
  BOTTOM w0.102: v1(132.68,112.83) 133.01,113.16 U45.AL21
  BOTTOM w0.14: v1(156.73,82.25) 156.38,82.59 JDIM1.193
M_B_DQ51: length 52.2
  IN3 w0.089: v1(153.98,82.27) 154.12,82.27 154.23,82.38 154.23,82.82 154.14,82.91 153.26,82.91 153.15,83.03 153.15,83.18 153.26,83.3 154.1,83.3 154.21,83.41 154.21,83.57 154.1,83.68 153.83,83.68 153.76,83.75 153.76,84.1 153.64,84.21 153.49,84.21 153.37,84.1 153.37,83.73 153.24,83.6 153.06,83.6 152.93,83.73 152.93,85.31 148.59,89.66 148.24,89.66 148.03,89.87 148.03,90 148.14,90.11 148.14,90.23 147.98,90.39 147.86,90.39 147.75,90.28 147.62,90.28 147.47,90.43 147.47,90.56 147.58,90.67 147.58,90.79 147.43,90.94 147.3,90.94 147.19,90.84 147.07,90.84 146.91,90.99 146.91,91.11 147.02,91.22 147.02,91.35 146.87,91.5 146.74,91.5 146.63,91.39 146.51,91.39 146.36,91.55 146.36,91.67 146.46,91.78 146.46,91.91 146.31,92.06 146.19,92.06 146.08,91.95 145.95,91.95 145.8,92.1 145.8,92.23 145.91,92.34 145.91,92.46 145.75,92.62 145.63,92.62 145.52,92.51 145.39,92.51 145.22,92.68 145.22,93.15 144.79,93.58 144.61,93.58 144.55,93.52 144.4,93.52 144.29,93.62 144.29,93.77 144.38,93.86 144.38,93.99 143.17,95.2 142.63,95.2 142.6,95.23 142.45,95.23 142.37,95.16 142.23,95.16 142.12,95.26 142.12,95.41 142.21,95.5 142.21,95.63 138.24,99.59 138.12,99.59 138.08,99.55 137.96,99.55 137.8,99.71 137.8,99.83 137.84,99.87 137.84,99.99 137.69,100.15 137.56,100.15 137.52,100.11 137.4,100.11 137.25,100.26 137.25,100.39 137.28,100.43 137.28,100.55 137.07,100.77 137.07,103.88 136.21,104.73 135.58,104.73 134.88,105.44 134.88,105.62 134.39,106.1 133.62,106.1 130.9,108.82 130.9,112.16 130.99,112.25 131.13,112.25 131.23,112.16 131.23,111.92 131.28,111.87 131.39,111.87 v1(131.7,112.18)
  BOTTOM w0.102: U45.AM22 132.03,112.51 v1(131.7,112.18)
  BOTTOM w0.14: JDIM1.183 153.38,82.33 153.56,82.15 153.86,82.15 v1(153.98,82.27)
M_B_DQ52: length 51.4
  IN3 w0.089: v1(152.49,77.16) 151.93,77.72 151.93,78.22 151.8,78.34 151.58,78.34 151.47,78.45 151.47,78.61 151.58,78.72 151.81,78.72 151.93,78.84 151.93,78.99 151.81,79.1 151.58,79.1 151.47,79.21 151.47,79.37 151.58,79.48 154.29,79.48 154.54,79.73 154.54,83.85 153.24,85.15 153.24,85.57 143.3,95.51 142.76,95.51 137.37,100.89 137.37,104 136.34,105.04 135.71,105.04 134.47,106.28 133.87,106.28 131.28,108.87 131.28,111.11 v1(131.7,111.53)
  BOTTOM w0.102: v1(131.7,111.53) 132.03,111.86 U45.AN22
  BOTTOM w0.14: JDIM1.180 152.49,75.64 152.49,77.15 v1(152.49,77.16)
M_B_DQ53: length 50.3
  IN3 w0.089: v1(132.65,110.88) 133.05,110.48 133.05,109.85 133.31,109.6 133.85,109.6 134.12,109.33 134.2,109.33 134.51,109.02 134.51,108.89 134.44,108.83 134.44,108.7 134.6,108.55 134.72,108.55 134.79,108.61 134.91,108.61 135.07,108.46 135.07,108.34 135,108.27 135,108.15 135.16,107.99 135.28,107.99 135.35,108.06 135.47,108.06 136.16,107.37 136.54,107.37 136.61,107.3 136.61,107.18 136.72,107.07 136.88,107.07 136.99,107.18 136.99,107.26 137.1,107.38 137.26,107.38 137.37,107.26 137.37,106.57 137.48,106.46 137.64,106.46 137.75,106.57 137.75,107.17 137.88,107.3 138.01,107.3 138.13,107.17 138.13,106.16 138.29,106 139.12,106 139.2,105.93 139.2,101.6 140.97,99.83 141.52,99.83 142.14,99.21 142.14,98.66 143.48,97.32 144.05,97.32 155.18,86.19 155.41,86.19 155.91,85.68 155.91,85.04 156.33,84.63 156.33,84.41 156.45,84.29 156.62,84.29 156.73,84.18 156.73,84.02 156.62,83.91 156.45,83.91 156.33,83.78 156.33,80.86 156.46,80.72 v1(156.73,80.72)
  BOTTOM w0.102: U45.AP21 132.98,111.21 v1(132.65,110.88)
  BOTTOM w0.14: JDIM1.191 155.78,81.27 156.33,80.72 v1(156.73,80.72)
M_B_DQ54: length 52.7
  IN3 w0.076: 134.96,109.47 134.62,109.81 134.35,109.81 134.12,110.04 134.12,111.06 134.04,111.13 134.04,113.04 133.92,113.16 133.29,113.16 132.97,113.48 v1(132.65,113.48)
  IN3 w0.089: v1(156.68,77.19) 157.28,77.8 157.28,81.67 157.18,81.77 157.18,82.61 157.54,82.97 157.54,84.27 156.52,85.29 156.52,86.45 156.4,86.57 156.27,86.57 156.16,86.46 156,86.46 155.88,86.58 155.88,86.75 156.01,86.88 156.01,87.04 154.03,89.02 153.78,89.26 152.99,89.26 144.33,97.93 143.77,97.93 143.47,98.23 143.47,98.9 143.13,99.24 143.1,99.24 141.96,100.38 141.49,100.85 141.49,101.51 140.75,102.25 140.09,102.25 139.89,102.45 139.89,106.44 138.3,108.02 136.41,108.02 134.96,109.47
  BOTTOM w0.102: v1(132.65,113.48) 132.98,113.81 U45.AK21
  BOTTOM w0.14: JDIM1.194 156.68,77.19 v1(156.68,77.19)
M_B_DQ55: length 53.4
  IN3 w0.089: v1(131.7,113.46) 130.51,112.27 130.51,108.77 133.37,105.92 134.32,105.92 134.7,105.54 134.7,105.18 135.45,104.43 136.08,104.43 136.76,103.75 136.76,100.36 137.91,99.22 138.12,99.22 141.72,95.62 141.72,95.22 142.22,94.73 142.66,94.73 144.19,93.2 144.67,93.2 144.92,92.96 144.92,92.56 148.12,89.35 148.46,89.35 152.58,85.23 152.58,83.1 153,82.68 153,82.47 152.91,82.38 152.8,82.38 152.69,82.27 152.69,82.11 152.8,82 153.34,82 153.45,81.89 153.45,81.73 153.34,81.62 152.72,81.62 152.61,81.51 152.61,81.35 152.72,81.24 153.34,81.24 153.45,81.13 153.45,80.97 153.34,80.86 152.8,80.86 152.69,80.75 152.69,80.59 152.8,80.48 153.73,80.48 v1(154,80.74)
  BOTTOM w0.102: U45.AK22 132.05,113.81 v1(131.7,113.46)
  BOTTOM w0.14: JDIM1.181 152.78,81.22 153.26,80.74 v1(154,80.74)
M_B_DQ56: length 68.6
  IN1 w0.076: 133.31,109.84 133.23,109.92 133.23,111.13 v1(133.63,111.53)
  IN1 w0.114: v1(117,82.27) 117.23,82.27 117.33,82.37 117.33,82.6 117.57,82.84 117.76,82.84 117.86,82.74 117.86,81.9 117.99,81.77 118.27,81.77 118.4,81.9 118.4,82.86 118.53,82.99 118.8,82.99 118.93,82.86 118.93,81.9 119.06,81.77 119.34,81.77 119.47,81.9 119.47,82.91 119.71,83.16 130.16,83.16 131,83.99 132.95,83.99 133.18,84.22 133.18,84.44 132.89,84.73 132.89,84.91 133.09,85.11 133.27,85.11 133.71,84.67 133.87,84.67 134.17,84.97 134.17,85.26 135.48,86.57 135.64,86.57 135.94,86.28 136.04,86.28 136.25,86.5 136.25,86.66 136,86.92 136,87.09 136.18,87.27 136.35,87.27 136.65,86.97 136.81,86.97 137,87.16 137,87.32 136.74,87.58 136.74,87.77 136.89,87.92 137.1,87.92 137.35,87.67 137.51,87.67 137.68,87.84 137.68,87.99 137.37,88.3 137.37,88.46 137.59,88.68 137.73,88.68 138.03,88.37 138.18,88.37 138.9,89.09 138.9,90.38 139.02,90.51 139.33,90.51 139.45,90.64 139.45,90.88 139.33,91.01 138.88,91.01 138.79,91.09 138.79,91.42 138.88,91.5 139.33,91.5 139.45,91.63 139.45,91.87 139.33,92 138.86,92 138.76,92.09 138.76,92.38 138.88,92.49 139.33,92.49 139.45,92.62 139.45,92.86 139.33,92.99 138.88,92.99 138.76,93.1 138.76,93.37 138.88,93.48 139.33,93.48 139.45,93.61 139.45,93.85 139.33,93.98 138.88,93.98 138.76,94.09 138.76,94.36 138.88,94.47 139.33,94.47 139.45,94.6 139.45,94.84 139.33,94.97 138.88,94.97 138.76,95.08 138.76,95.35 138.88,95.46 139.33,95.46 139.45,95.59 139.45,95.83 139.33,95.96 138.88,95.96 138.76,96.07 138.76,96.34 138.88,96.45 139.33,96.45 139.45,96.58 139.45,96.82 139.33,96.95 138.88,96.95 138.76,97.06 138.76,101.01 138.5,101.27 138.5,102.87 136.19,105.18 135.76,105.18 134.49,106.44 134.15,106.44 134.13,106.46 134.11,106.46 133.54,107.04 133.54,109.61 133.31,109.84
  BOTTOM w0.102: v1(133.63,111.53) 133.96,111.86 U45.AN20
  BOTTOM w0.14: JDIM1.69 116.78,82.49 v1(117,82.27)
M_B_DQ57: length 67.6
  IN1 w0.114: v1(117,80.74) 117.66,80.74 117.79,80.87 117.79,81.19 117.92,81.31 118.2,81.31 118.32,81.19 118.32,80.53 118.45,80.4 118.73,80.4 118.86,80.53 118.86,81.26 118.98,81.39 119.26,81.39 119.39,81.26 119.39,80.53 119.52,80.4 119.8,80.4 119.92,80.53 119.92,82.53 120.21,82.83 120.91,82.83 121.02,82.71 121.02,81.82 121.15,81.7 121.39,81.7 121.52,81.82 121.52,82.71 121.63,82.83 123.03,82.83 123.14,82.71 123.14,81.82 123.27,81.7 123.51,81.7 123.64,81.82 123.64,82.71 123.75,82.83 125.18,82.83 125.29,82.71 125.29,81.9 125.42,81.77 125.66,81.77 125.79,81.9 125.79,82.71 125.9,82.83 127.2,82.83 127.31,82.71 127.31,81.9 127.44,81.77 127.68,81.77 127.81,81.9 127.81,82.71 127.92,82.83 128.77,82.83 128.94,82.65 128.94,81.95 129.04,81.85 129.25,81.85 129.38,81.98 129.38,82.71 129.49,82.83 130.3,82.83 131.14,83.66 133.37,83.66 134.59,84.88 134.59,85.21 135.16,85.78 136.08,85.78 139.79,89.48 139.79,96.96 139.07,97.67 139.07,101.01 138.72,101.36 138.72,103.03 136.36,105.39 135.85,105.39 134.96,106.28 134.96,106.82 133.76,108.02 133.76,110.1 v1(133.63,110.23)
  BOTTOM w0.102: U45.AR20 133.96,110.56 v1(133.63,110.23)
  BOTTOM w0.14: v1(117,80.74) 117,80.74 116.29,81.46 116.29,81.9 116.18,82 JDIM1.67
M_B_DQ58: length 69.5
  IN1 w0.114: v1(134.48,113.37) 135.64,112.2 135.64,108.71 137.43,106.93 137.43,106.63 138.03,106.02 138.77,106.02 139.28,105.52 139.28,104.78 141.09,102.96 141.09,102.49 141.9,101.68 141.9,98.31 142.13,98.08 142.13,87.13 140.71,85.71 140.71,85.11 139.38,83.78 138.78,83.78 137.05,82.05 137.05,79.8 133.69,76.44 133.04,76.44 132.01,75.41 114.06,75.41 v1(112.28,77.19)
  BOTTOM w0.102: U45.AK18 134.88,113.81 134.48,113.4 v1(134.48,113.37)
  BOTTOM w0.14: JDIM1.56 112.88,76.59 v1(112.28,77.19)
M_B_DQ59: length 69.4
  IN1 w0.114: v1(134.45,112.76) 134.58,112.76 135.31,112.02 135.31,108.7 137.17,106.84 137.17,106.31 138.54,104.94 138.8,104.94 138.87,104.87 138.88,104.87 140.67,103.07 140.67,102.25 141.02,101.9 141.02,98.54 141.72,97.85 141.72,87.41 137.3,82.99 136.79,82.99 136.21,82.41 136.21,80.38 134.35,78.52 133.26,78.52 132.85,78.11 132.85,77.33 131.26,75.74 114.83,75.74 114,76.56 114,78.09 v1(114.51,78.6)
  BOTTOM w0.102: U45.AL18 134.91,113.16 134.51,112.76 v1(134.45,112.76)
  BOTTOM w0.14: JDIM1.58 113.48,77.52 114.51,78.55 v1(114.51,78.6)
M_B_DQ60: length 70.1
  IN1 w0.114: v1(133.56,113.56) 133.21,113.9 132.42,113.9 132.16,113.65 132.16,109.84 132.42,109.58 132.42,107.5 133.91,106.01 134.32,106.01 135.58,104.75 135.86,104.75 138.07,102.54 138.07,101.09 138.1,101.06 138.1,92.7 137.46,92.06 137.46,91.9 137.94,91.42 137.94,91.26 137.75,91.07 137.59,91.07 137.11,91.55 136.95,91.55 136.76,91.36 136.76,91.19 137.24,90.72 137.24,90.55 137.05,90.37 136.89,90.37 136.41,90.84 136.25,90.84 136.06,90.66 136.06,90.49 136.56,90 136.56,89.82 136.38,89.65 136.2,89.65 135.71,90.14 135.55,90.14 135.36,89.96 135.36,89.79 135.85,89.3 135.85,89.12 135.68,88.95 135.5,88.95 135.01,89.44 134.85,89.44 134.66,89.25 134.66,89.09 135.14,88.61 135.14,88.45 134.95,88.26 134.79,88.26 134.31,88.74 134.15,88.74 133.96,88.55 133.96,88.39 134.44,87.91 134.44,87.75 134.25,87.56 134.09,87.56 133.61,88.04 133.45,88.04 133.26,87.85 133.26,87.69 133.74,87.21 133.74,87.05 133.55,86.86 133.39,86.86 132.91,87.34 132.75,87.34 132.56,87.15 132.56,86.99 133.04,86.51 133.04,86.35 132.85,86.16 132.69,86.16 132.32,86.53 132.14,86.53 132.01,86.4 132.01,86.14 132.27,85.89 132.27,85.66 131.43,84.82 130.82,84.82 129.82,83.82 117.28,83.82 115.6,82.13 115.48,82.13 115.35,82.01 115.35,81.75 115.22,81.62 114.94,81.62 114.82,81.75 114.82,82.14 114.69,82.27 v1(114.38,82.27)
  BOTTOM w0.102: U45.AK20 133.77,113.56 v1(133.56,113.56)
  BOTTOM w0.14: JDIM1.59 113.78,82.66 114.17,82.27 v1(114.38,82.27)
M_B_DQ61: length 69.1
  IN1 w0.076: 132.93,109.2 133.05,109.33 133.05,111.36 133.18,111.49 133.18,111.73 v1(133.61,112.16)
  IN1 w0.102: 132.93,109.2 132.68,108.95
  IN1 w0.114: 132.68,108.95 132.68,107.58 134.03,106.23 134.41,106.23 135.67,104.96 136.03,104.96 138.29,102.7 138.29,101.18 138.43,101.04 138.43,91.21 138.31,91.09 138.31,90.69 138.57,90.43 138.57,90.23 138.39,90.05 138.26,90.05 137.98,90.33 137.8,90.33 137.68,90.2 137.68,89.94 138,89.62 138,89.44 137.83,89.27 137.65,89.27 137.15,89.77 136.99,89.77 136.8,89.58 136.8,89.42 137.24,88.98 137.24,88.8 137.07,88.63 136.89,88.63 136.56,88.96 136.38,88.96 136.21,88.79 136.21,88.61 136.54,88.28 136.54,88.1 136.37,87.93 136.19,87.93 135.74,88.37 135.56,88.37 135.39,88.2 135.39,88.02 135.84,87.58 135.84,87.4 135.66,87.23 135.48,87.23 135.02,87.69 134.88,87.69 134.7,87.5 134.7,87.32 135.1,86.92 135.1,86.74 134.93,86.56 134.75,86.56 134.35,86.97 134.18,86.97 134,86.78 134,86.62 134.23,86.38 134.23,86.2 134.06,86.03 133.88,86.03 133.64,86.27 133.48,86.27 131.54,84.32 130.86,84.32 130.02,83.49 117.6,83.49 116.46,82.34 116.46,81.59 116.33,81.47 115.71,81.47 115.58,81.34 115.58,81.06 115.71,80.93 116.16,80.93 116.29,80.81 116.29,80.53 116.16,80.4 115.55,80.4 115.4,80.25 115.4,79.98 115.29,79.87 115.01,79.87 114.89,79.98 114.89,80.5 114.65,80.74 v1(114.38,80.74)
  BOTTOM w0.102: v1(133.61,112.16) 133.96,112.51 U45.AM20
  BOTTOM w0.14: JDIM1.57 113.18,81.33 113.76,80.74 v1(114.38,80.74)
M_B_DQ62: length 65.6
  IN1 w0.114: v1(117.91,78.72) 118.21,78.42 120.05,78.42 120.25,78.22 120.25,76.64 120.38,76.51 121.21,76.51 121.34,76.64 121.34,77.2 121.44,77.3 121.7,77.3 121.83,77.17 121.83,76.75 121.95,76.63 125.31,76.63 125.43,76.75 125.43,77.15 125.55,77.28 125.79,77.28 125.92,77.15 125.92,76.75 126.04,76.63 127.47,76.63 127.59,76.75 127.59,77.16 127.7,77.28 127.97,77.28 128.08,77.16 128.08,76.75 128.2,76.63 128.93,76.63 129.04,76.75 129.04,77.15 129.17,77.28 129.41,77.28 129.54,77.15 129.54,76.75 129.65,76.63 130.3,76.63 130.95,77.28 130.95,78.85 131.58,79.49 133.69,79.49 134.07,79.87 134.07,82.15 135.7,83.78 137.15,83.78 141.06,87.68 141.06,97.52 140.36,98.21 140.36,101.51 140.01,101.86 140.01,103.11 138.62,104.5 138.36,104.5 136.67,106.19 136.67,106.66 134.81,108.53 134.81,110 v1(134.59,110.22)
  BOTTOM w0.102: v1(134.59,110.22) 134.59,110.23 134.91,110.56 U45.AR18
  BOTTOM w0.14: v1(117.91,78.72) 116.48,77.29 JDIM1.68
M_B_DQ63: length 66.6
  IN1 w0.114: v1(134.58,110.88) 135.06,110.41 135.06,108.59 136.93,106.73 136.93,106.25 138.45,104.72 138.71,104.72 138.78,104.65 140.34,103.08 140.34,102.11 140.69,101.76 140.69,98.41 141.39,97.71 141.39,87.55 137.29,83.45 135.9,83.45 134.58,82.13 134.58,81.82 134.71,81.7 135.01,81.7 135.14,81.57 135.14,81.29 135.01,81.16 134.68,81.16 134.58,81.06 134.58,80.78 134.73,80.63 135.08,80.63 135.2,80.5 135.2,80.22 135.08,80.1 134.65,80.1 134.45,79.89 134.45,79.74 133.82,79.1 131.91,79.1 131.53,78.72 131.53,77.07 130.77,76.3 121.9,76.3 121.78,76.18 120.18,76.18 119.77,76.59 119.77,77.83 119.64,77.96 119.36,77.96 119.24,77.83 119.24,76.41 119.11,76.29 118.83,76.29 118.7,76.41 118.7,76.69 118.58,76.82 118.3,76.82 118.17,76.69 118.17,76.49 118.04,76.36 117.59,76.36 117.46,76.49 117.46,77.06 117.59,77.19 v1(117.91,77.19)
  BOTTOM w0.102: U45.AP18 134.91,111.21 v1(134.58,110.88)
  BOTTOM w0.14: JDIM1.70 117.08,76.97 117.3,77.19 v1(117.91,77.19)
M_B_DQS0: length 42.3
  IN3 w0.076: v1(126.53,105.39) 126.72,105.58 127.04,105.58 127.2,105.43 127.2,100.72 127.85,100.07 127.85,98.51 127.92,98.43
  IN3 w0.089: 127.92,98.43 129.12,97.23 129.12,92.95 129.77,92.31 129.77,92.18 129.62,92.03 129.62,91.75 129.94,91.43 130.26,91.43 130.38,91.55 130.52,91.55 130.75,91.32 130.75,91.22 130.6,91.07 130.6,90.77 130.96,90.41 131.21,90.41 131.38,90.57 131.5,90.57 131.57,90.51 131.77,90.31 131.77,90.23 131.59,90.06 131.59,89.78 131.94,89.43 132.22,89.43 132.37,89.58 132.49,89.58 132.71,89.36 132.71,89.22 132.57,89.08 132.57,88.8 132.89,88.48 133.22,88.48 133.36,88.62 133.46,88.62 133.7,88.37 133.7,88.25 133.56,88.11 133.56,87.81 133.93,87.44 134.17,87.44 134.31,87.58 134.49,87.58 134.7,87.38 134.7,87.25 134.55,87.1 134.55,86.82 134.87,86.5 135.2,86.5 135.35,86.65 135.45,86.65 135.59,86.51 135.59,85.87 138.24,83.22 138.24,81.13 138.48,80.9 139.24,80.9 139.56,81.21 139.56,82.18 v1(139.65,82.27)
  BOTTOM w0.076: v1(126.53,105.39) 126.25,105.67 126.13,105.67 125.94,105.86 125.94,106.93 126.34,107.32 126.34,107.51 126.29,107.61 126.29,107.62 126.27,107.67 126.27,107.87 126.34,108.03 126.34,108.16 126.29,108.26 126.27,108.32 126.27,108.52 126.34,108.69 126.4,108.75 126.49,108.84 126.63,108.84 126.72,108.93 U45.AV30
  BOTTOM w0.14: v1(139.65,82.27) 139.58,82.34 JDIM1.137
M_B_DQS1: length 56.4
  IN1 w0.114: v1(98.51,78.55) 98.84,78.22 99.02,78.22 99.2,78.39 99.2,82.91 107.63,91.35 109.36,91.35 114.33,96.31 117.67,96.31 118.23,96.87 119.91,96.87 120.21,97.18 125.74,97.18 129.04,100.47 129.04,102.24 129.52,102.73 129.84,102.73 130.08,102.96 v1(130.08,103.04)
  BOTTOM w0.076: v1(130.08,103.04) 129.78,102.74 129.49,102.74 129.13,103.1 129.13,105.75 128.57,106.31 128.57,106.77 128.65,106.85 128.94,107.14 128.94,107.55 128.91,107.6 128.86,107.71 128.86,107.84 128.87,107.86 128.91,107.94 128.94,107.99 128.94,108.2 U45.AW26
  BOTTOM w0.14: JDIM1.12 99.68,76.69 99.51,76.86 99.51,77.96 99.22,78.25 98.8,78.25 v1(98.51,78.55)
M_B_DQS2: length 47.2
  IN3 w0.076: 127.63,109.49 127.63,109.5 127.45,109.68 127.45,111.76 127.61,111.92 127.8,111.92 128.01,112.13 v1(128.01,112.18)
  IN3 w0.089: v1(144.75,77.19) 144.53,77.19 144.34,77.01 144.34,76.8 144.51,76.63 145.14,76.63 145.5,76.99 145.5,78.07 144.1,79.47 144.1,83.19 142.38,84.9 142.38,86.07 132.65,95.81 132.65,96.93 130.5,99.08 130.5,105.36 129.83,106.04 129.83,107.29 127.63,109.49
  BOTTOM w0.102: v1(128.01,112.18) 128.34,112.51 U45.AM28
  BOTTOM w0.14: JDIM1.154 144.68,77.13 v1(144.75,77.19)
M_B_DQS3: length 59.9
  IN1 w0.076: 129.73,109.2 129.73,109.22 129.37,109.57 129.37,111.78 129.56,111.97 129.72,111.97 v1(129.93,112.18)
  IN1 w0.102: 129.73,109.2 129.73,109.18
  IN1 w0.114: 129.73,109.18 130.88,108.02 130.88,106.17 131.66,105.39 132.24,105.39 132.53,105.1 132.53,98.96 131.57,97.99 131.57,96.49 127.23,92.15 115.55,92.15 110.98,87.58 109.2,87.58 103.75,82.13 103.75,80.36 104.25,79.87 104.89,79.87 105.16,80.15 105.16,80.83 104.99,81.01 104.99,81.62 v1(105.11,81.75)
  BOTTOM w0.102: U45.AM25 130.25,112.51 v1(129.93,112.18)
  BOTTOM w0.14: JDIM1.29 104.78,82.81 104.61,82.64 104.61,82.47 104.92,82.16 104.92,81.94 v1(105.11,81.75)
M_B_DQS4: length 42.9
  IN3 w0.089: v1(149.85,82.27) 149.57,82.27 149.45,82.15 149.45,81.01 149.64,80.82 150.17,80.82 150.41,81.06 150.41,82.41 148.82,84 148.82,85.92 147.48,87.26 147.25,87.26 143.84,90.67 143.31,90.67 139.62,94.36 139.62,94.76 136.72,97.66 134.99,97.66 133.26,99.4 133.26,104.06 132.92,104.39 132.35,104.39 v1(132.12,104.16)
  BOTTOM w0.076: U45.AV22 131.86,108.92 131.78,108.84 131.63,108.84 131.54,108.75 131.47,108.68 131.47,108.66 131.4,108.52 131.4,108.32 131.43,108.26 131.47,108.16 131.47,108.03 131.4,107.87 131.4,107.67 131.43,107.62 131.43,107.61 131.47,107.51 131.47,107.32 131.38,107.23 131.38,105.79 131.56,105.62 131.56,104.58 131.71,104.43 131.85,104.43 v1(132.12,104.16)
  BOTTOM w0.14: v1(149.85,82.27) 149.78,82.34 JDIM1.171
M_B_DQS5: length 55
  IN1 w0.102: v1(135.59,100.06) 135.59,99.96 135.72,99.83 136,99.83 136.31,99.53 136.31,98.58 135.72,97.99 135.72,96.92 135.73,96.91 135.73,96.88
  IN1 w0.114: v1(110.25,82.27) 109.93,82.27 109.86,82.34 109.86,82.53 110.53,83.2 112.44,83.2 113.54,84.3 114.65,84.3 115.5,85.15 115.5,85.58 115.16,85.92 115.16,86.08 115.44,86.36 115.61,86.36 116,85.96 116.36,85.96 117.13,86.72 117.66,86.72 118.03,87.09 118.03,87.57 118.14,87.68 118.46,87.68 118.65,87.49 118.65,87.11 118.88,86.88 119.49,86.88 119.73,87.11 119.73,87.57 119.84,87.68 120.24,87.68 120.35,87.57 120.35,87.4 120.6,87.15 123.34,87.15 123.55,87.36 123.55,87.6 123.64,87.68 124.18,87.68 124.28,87.58 124.28,87.37 124.5,87.15 125.33,87.15 125.56,87.39 125.56,87.57 125.63,87.64 126.1,87.64 126.22,87.52 126.22,87.39 126.46,87.15 127.05,87.15 127.29,87.4 127.29,87.57 127.41,87.68 127.83,87.68 127.94,87.57 127.94,87.4 128.19,87.15 128.68,87.15 128.94,87.41 128.94,87.57 129.05,87.68 129.33,87.68 135.73,94.09 135.73,96.88
  BOTTOM w0.076: v1(135.59,100.06) 135.59,99.91 135.49,99.81 135.02,99.81 134.96,99.87 134.96,105.59 133.92,106.63 133.92,107.1 134.07,107.25 134.07,107.55 134.05,107.6 134,107.71 134,107.84 134.01,107.86 134.05,107.94 134.07,107.99 134.07,108.32 134.17,108.42 U45.AW18
  BOTTOM w0.14: JDIM1.47 110.18,82.34 v1(110.25,82.27)
M_B_DQS6: length 50.6
  IN3 w0.076: v1(132.68,112.18) 132.68,112.06 132.54,111.92 132.32,111.92 132.1,111.7 132.1,109.44 132.53,109 133.26,109 133.52,108.73 133.52,108.35
  IN3 w0.089: v1(154.95,77.19) 154.75,77.19 154.56,77 154.56,76.75 154.65,76.65 155.22,76.65 155.74,77.16 155.74,77.73 155.34,78.13 155.34,84.22 154.48,85.07 154.48,85.49 143.64,96.33 143.07,96.33 138.17,101.23 138.17,104.33 136.67,105.84 136.04,105.84 133.52,108.35
  BOTTOM w0.102: v1(132.68,112.18) 133.01,112.51 U45.AM21
  BOTTOM w0.14: v1(154.95,77.19) 154.88,77.13 JDIM1.188
M_B_DQS7: length 67.7
  IN1 w0.076: v1(134.56,112.16) 134.34,111.93 134.17,111.93 134.03,111.79 134.03,110.31 134.03,109.86 134.1,109.79 134.1,109.7 134.08,109.68
  IN1 w0.114: v1(115.35,77.19) 115.25,77.29 115.07,77.29 114.97,77.19 114.97,76.66 115.06,76.56 115.69,76.56 116.04,76.91 116.04,77.48 116.29,77.73 116.92,77.73 117.1,77.91 117.1,78.16 116.92,78.34 115.91,78.34 115.58,78.67 115.58,79.14 115.91,79.47 119.73,79.47 120.54,80.27 122.87,80.27 123.69,79.45 130.29,79.45 130.92,80.09 130.92,82.5 131.56,83.14 134,83.14 135.75,84.9 137.14,84.9 138.8,86.55 138.8,86.66 138.45,87.01 138.45,87.36 138.86,87.77 139.21,87.77 139.56,87.43 139.72,87.43 140.31,88.01 140.31,97.21 139.61,97.91 139.61,101.21 139.25,101.57 139.25,102.95 136.36,105.85 135.97,105.85 135.82,106.01 135.38,106.45 135.38,107.08 134.07,108.39 134.07,109.67 134.08,109.68
  BOTTOM w0.102: v1(134.56,112.16) 134.91,112.51 U45.AM18
  BOTTOM w0.14: v1(115.35,77.19) 115.28,77.13 JDIM1.64
M_B_DQS#0: length 42.4
  IN3 w0.076: 128.06,98.57 128.01,98.61 128.01,100.14 127.36,100.78 127.36,105.5 127.11,105.75 126.7,105.75 126.53,105.92 v1(126.53,106.23)
  IN3 w0.089: 128.06,98.57 129.31,97.31 129.31,93.03 129.96,92.39 129.96,92.1 129.81,91.95 129.81,91.83 130.02,91.62 130.18,91.62 130.3,91.74 130.6,91.74 130.94,91.4 130.94,91.14 130.79,90.99 130.79,90.85 131.04,90.6 131.13,90.6 131.3,90.76 131.58,90.76 131.76,90.59 131.96,90.39 131.96,90.16 131.78,89.98 131.78,89.86 132.01,89.62 132.14,89.62 132.29,89.77 132.57,89.77 132.9,89.44 132.9,89.14 132.76,89 132.76,88.88 132.97,88.67 133.14,88.67 133.28,88.81 133.54,88.81 133.89,88.45 133.89,88.17 133.75,88.03 133.75,87.89 134.01,87.63 134.09,87.63 134.24,87.77 134.57,87.77 134.89,87.46 134.89,87.17 134.74,87.02 134.74,86.9 134.95,86.69 135.12,86.69 135.27,86.84 135.53,86.84 135.78,86.59 135.78,85.95 138.43,83.3 138.43,81.21 138.56,81.09 139.16,81.09 139.37,81.29 139.37,81.96 139.05,82.28 v1(138.93,82.28)
  BOTTOM w0.076: U45.AW30 126.78,108.48 126.78,108.59 126.7,108.67 126.56,108.67 126.48,108.59 126.43,108.49 126.43,108.36 126.51,108.2 126.51,107.99 126.48,107.94 126.44,107.86 126.43,107.84 126.43,107.71 126.46,107.65 126.51,107.55 126.51,107.26 126.11,106.86 126.11,105.93 126.19,105.85 126.5,105.85 126.63,105.98 126.63,106.13 v1(126.53,106.23)
  BOTTOM w0.14: JDIM1.135 138.98,82.33 v1(138.93,82.28)
M_B_DQS#1: length 56.7
  IN1 w0.114: v1(130.08,102.39) 129.97,102.5 129.62,102.5 129.27,102.15 129.27,100.38 125.84,96.95 120.31,96.95 120,96.64 118.33,96.64 117.77,96.08 114.42,96.08 109.46,91.12 107.73,91.12 99.42,82.82 99.42,78.3 99.11,77.99 98.75,77.99 v1(98.52,77.76)
  BOTTOM w0.076: v1(130.08,102.39) 129.89,102.57 129.42,102.57 128.96,103.03 128.96,105.68 128.4,106.24 128.4,106.84 128.53,106.97 128.77,107.21 128.77,107.51 128.7,107.67 128.7,107.87 128.77,108.03 128.77,108.51 128.93,108.67 128.93,108.85 U45.AV26
  BOTTOM w0.14: v1(98.52,77.76) 98.74,77.97 99.16,77.97 99.27,77.86 99.27,76.87 99.08,76.68 JDIM1.10
M_B_DQS#2: length 47.3
  IN3 w0.076: 127.72,109.65 127.62,109.75 127.62,111.69 127.68,111.76 127.79,111.76 v1(128.01,111.53)
  IN3 w0.089: v1(143.95,77.19) 144.15,76.99 144.15,76.72 144.43,76.44 145.22,76.44 145.69,76.91 145.69,78.15 144.29,79.55 144.29,83.27 142.57,84.98 142.57,86.15 132.84,95.88 132.84,96.99 130.68,99.15 130.68,105.44 130.01,106.11 130.01,107.36 127.72,109.65
  BOTTOM w0.102: U45.AN28 128.34,111.86 v1(128.01,111.53)
  BOTTOM w0.14: v1(143.95,77.19) 144.08,77.06 JDIM1.152
M_B_DQS#3: length 60.1
  IN1 w0.076: v1(129.93,111.53) 129.93,111.63 129.75,111.81 129.63,111.81 129.54,111.71 129.54,109.65 129.85,109.33 129.88,109.33
  IN1 w0.114: v1(104.5,81.75) 104.76,81.49 104.76,80.92 104.94,80.74 104.94,80.24 104.79,80.1 104.35,80.1 103.98,80.46 103.98,82.04 109.29,87.35 111.07,87.35 115.64,91.92 127.32,91.92 131.8,96.4 131.8,97.91 132.75,98.87 132.75,105.19 132.33,105.61 131.75,105.61 131.1,106.26 131.1,108.11 129.88,109.33
  BOTTOM w0.102: v1(129.93,111.53) 130.67,111.53 130.77,111.63 130.77,111.77 130.67,111.87 130.33,111.87 U45.AN25
  BOTTOM w0.14: JDIM1.27 104.18,82.81 104.36,82.63 104.36,82.37 104.68,82.06 104.68,81.92 104.5,81.75 v1(104.5,81.75)
M_B_DQS#4: length 43.1
  IN3 w0.089: v1(149.05,82.27) 149.26,82.06 149.26,80.93 149.56,80.63 150.25,80.63 150.6,80.98 150.6,82.49 149.01,84.08 149.01,86 147.56,87.45 147.33,87.45 143.92,90.86 143.39,90.86 139.81,94.44 139.81,94.84 136.81,97.84 135.07,97.84 133.44,99.47 133.44,104.13 133,104.57 132.36,104.57 v1(132.12,104.81)
  BOTTOM w0.076: U45.AW22 131.86,108.6 131.79,108.67 131.7,108.67 131.61,108.59 131.57,108.49 131.57,108.36 131.64,108.2 131.64,107.99 131.62,107.94 131.57,107.86 131.57,107.84 131.57,107.71 131.59,107.65 131.64,107.55 131.64,107.26 131.55,107.17 131.55,105.86 131.72,105.69 131.72,104.65 131.78,104.59 131.9,104.59 v1(132.12,104.81)
  BOTTOM w0.14: v1(149.05,82.27) 149.18,82.4 JDIM1.169
M_B_DQS#5: length 55.2
  IN1 w0.102: v1(135.59,99.42) 135.8,99.63 135.92,99.63 136.1,99.44 136.1,98.66 135.52,98.08 135.52,96.92 135.51,96.91 135.51,96.88
  IN1 w0.114: 135.51,96.88 135.51,94.18 129.23,87.91 128.95,87.91 128.71,87.66 128.71,87.51 128.58,87.38 128.29,87.38 128.17,87.49 128.17,87.66 127.92,87.91 127.31,87.91 127.07,87.66 127.07,87.49 126.95,87.38 126.55,87.38 126.45,87.48 126.45,87.61 126.2,87.87 125.54,87.87 125.33,87.66 125.33,87.48 125.23,87.38 124.6,87.38 124.51,87.46 124.51,87.67 124.27,87.91 123.55,87.91 123.33,87.69 123.33,87.45 123.25,87.38 120.69,87.38 120.58,87.49 120.58,87.66 120.33,87.91 119.75,87.91 119.5,87.66 119.5,87.21 119.4,87.11 118.98,87.11 118.88,87.2 118.88,87.59 118.55,87.91 118.05,87.91 117.8,87.66 117.8,87.18 117.57,86.95 117.03,86.95 116.27,86.19 116.1,86.19 115.7,86.59 115.35,86.59 114.94,86.17 114.94,85.82 115.27,85.48 115.27,85.24 114.56,84.53 113.44,84.53 112.34,83.43 110.44,83.43 109.63,82.63 109.63,82.45 v1(109.45,82.27)
  BOTTOM w0.076: v1(135.59,99.42) 135.38,99.64 134.95,99.64 134.79,99.8 134.79,105.52 133.75,106.56 133.75,107.17 133.9,107.32 133.9,107.51 133.83,107.67 133.83,107.87 133.9,108.03 133.9,108.51 134.06,108.67 134.06,108.85 U45.AV18
  BOTTOM w0.14: v1(109.45,82.27) 109.58,82.4 JDIM1.45
M_B_DQS#6: length 50.7
  IN3 w0.076: 133.71,108.43 133.71,108.78 133.33,109.17 132.6,109.17 132.26,109.51 132.26,111.63 132.39,111.76 132.51,111.76 132.68,111.58 v1(132.68,111.53)
  IN3 w0.089: 133.71,108.43 136.12,106.03 136.75,106.03 138.36,104.41 138.36,101.3 143.15,96.52 143.72,96.52 154.67,85.57 154.67,85.15 155.53,84.3 155.53,78.21 155.93,77.81 155.93,77.09 155.3,76.46 154.57,76.46 154.36,76.67 154.36,76.98 v1(154.15,77.19)
  BOTTOM w0.102: U45.AN21 133.01,111.86 v1(132.68,111.53)
  BOTTOM w0.14: JDIM1.186 154.28,77.06 v1(154.15,77.19)
M_B_DQS#7: length 67.8
  IN1 w0.076: v1(134.58,111.53) 134.35,111.77 134.24,111.77 134.19,111.72 134.19,110.38 134.19,109.93 134.29,109.84 134.29,109.67
  IN1 w0.114: 134.29,109.67 134.29,108.48 135.59,107.17 135.59,106.54 136.06,106.07 136.44,106.07 139.48,103.03 139.48,101.66 139.81,101.33 139.81,101.31 139.84,101.28 139.84,98 140.53,97.3 140.53,87.91 139.82,87.2 139.47,87.2 139.12,87.55 138.96,87.55 138.68,87.27 138.68,87.11 139.03,86.76 139.03,86.46 137.24,84.67 135.85,84.67 134.1,82.91 131.66,82.91 131.15,82.41 131.15,79.99 130.38,79.23 123.59,79.23 122.77,80.04 120.63,80.04 119.83,79.24 116,79.24 115.81,79.04 115.81,78.77 116,78.57 117.02,78.57 117.33,78.26 117.33,77.82 117.02,77.5 116.38,77.5 116.26,77.38 116.26,76.82 115.78,76.34 114.97,76.34 114.74,76.56 114.74,77 v1(114.55,77.19)
  BOTTOM w0.102: U45.AN18 134.91,111.86 v1(134.58,111.53)
  BOTTOM w0.14: v1(114.55,77.19) 114.68,77.06 JDIM1.62
M_B_ODT0: length 1.4
  TOP w0.14: TP78.1 125.89,113.12 v1(125.61,112.83)
  BOTTOM w0.102: U45.AL32 125.93,113.16 v1(125.61,112.83)
M_B_ODT0_DIMM: length 3.6
  BOTTOM w0.33: 132.14,73.41 133.09,74.36 133.09,74.37 133.28,74.56 JDIM1.116
  BOTTOM w0.381: R709.2 132.13,73.4 132.14,73.41
M_B_ODT1_DIMM: length 3.4
  BOTTOM w0.33: 135.2,73.41 135.2,73.87 134.48,74.58 134.48,75.63 JDIM1.120
  BOTTOM w0.381: R710.2 135.2,73.41
M_B_RAS#: length 57.7
  IN2 w0.076: v1(123.7,112.18) 124.1,111.79 124.1,109.98 123.86,109.75 123.86,106.03 123.69,105.86 123.69,102.01 124.12,101.58 124.12,100.39
  IN2 w0.178: v1(132.11,77.17) 131.86,77.17 131.68,76.99 131.68,74.94 131.86,74.76 134.55,74.76 135.01,75.22 135.01,75.8 134.83,75.98 134.58,75.98 134.4,75.8 134.4,75.6 134.17,75.37 133.89,75.37 133.71,75.55 133.71,75.8 133.54,75.98 133.28,75.98 133.1,75.8 133.1,75.55 132.93,75.37 132.37,75.37 132.19,75.55 132.19,76.18 132.7,76.69 132.7,77.53 132.6,77.63 132.6,78.64 132.84,78.88 133.23,78.88 133.41,79.05 133.41,79.36 133.1,79.66 132.5,79.66 132.34,79.82 132.34,82.89 134.4,84.95 134.4,87.64 134.27,87.77 134.27,89.21 133.28,90.2 133.28,90.44 131.88,91.85 131.88,93.73 128.88,96.73 128.7,96.73 127.34,98.09 126.42,98.09 124.12,100.39
  BOTTOM w0.102: U45.AM35 124.03,112.51 v1(123.7,112.18)
  BOTTOM w0.216: JDIM1.110 131.48,76.54 v1(132.11,77.17)
M_B_WE#: length 57.2
  IN2 w0.076: v1(123.68,113.48) 124.26,112.9 124.26,110 124.82,109.44 124.82,102.85 124.72,102.75
  IN2 w0.178: 124.72,102.75 124.72,100.44 126.61,98.55 127.53,98.55 128.87,97.2 129.05,97.2 129.22,97.04 130.8,97.04 133.95,93.89 133.95,93.71 133.73,93.5 133.55,93.5 130.63,96.42 130.45,96.42 130.25,96.21 130.25,96.03 132.7,93.58 132.7,93.2 134.17,91.73 134.17,91.55 133.99,91.37 133.82,91.37 132.81,92.38 132.63,92.38 132.41,92.15 132.41,91.97 133.74,90.63 133.74,90.39 134.86,89.28 134.86,84.46 132.88,82.48 132.88,81.25 v1(133.38,80.74)
  BOTTOM w0.102: v1(123.68,113.48) 124.01,113.81 U45.AK35
  BOTTOM w0.216: v1(133.38,80.74) 132.87,80.74 132.38,81.24 JDIM1.113
MAIND: length 158.2
  TOP w0.14: PC82.2 182.46,46.72 v1(182.33,46.85)
  TOP w0.254: PC82.2 PR118.2 181.44,47.86 PQ25.3
  IN2 w0.114: v1(160.55,115.81) 160.38,115.81 160.31,115.73 160.31,111.72 160.87,111.15 160.87,110.6 161.2,110.28 162.55,110.28 165.9,106.92 165.9,97.53 162.23,93.85 162.23,87.14 161.27,86.19 161.27,82.66 162.43,81.51 162.43,79.3 v1(162.9,78.83)
  IN3 w0.089: v1(152.61,44.56) 153.27,45.22 154.49,45.22 154.77,44.94 154.77,44.56 155.25,44.08 162.52,44.08 v1(165.31,46.87) 165.59,46.59 169.76,46.59 171.41,48.24 180.93,48.24 v1(182.33,46.85) 182.74,47.25 196.9,47.25 204.8,39.35 v1(206.59,39.35)
  BOTTOM w0.14: v1(162.9,78.83) 162.65,78.57 162.65,74.79 163.41,74.02 163.41,72.5 165.19,70.72 166.58,70.72 167.01,70.29 167.01,68.49 PQ47.2 163.79,65.26 163.79,63.74 162.77,62.72 162.77,52.18 165.31,49.64 v1(165.31,46.87) ; PQ54.2 152.61,45.45 v1(152.61,44.56) ; v1(160.55,115.81) 160.56,115.8 PQ32.4 ; PQ55.4 215.26,40.92 214.33,39.99 207.22,39.99 v1(206.59,39.35)
MAINON: length 233.5
  TOP w0.203: R328.2 221.95,67.04 221.45,66.53 221.45,63.86 223.73,61.58 223.73,50.91 220.11,47.29 220.11,43.48 217.38,40.75 207.35,40.75 206.46,39.86 199.48,39.86 195.67,43.67 v1(195.67,46.14) ; U32.80 157.64,59.73 v1(157.71,59.81) 158.45,60.54 R347.1 ; PR110.1 196.1,49.95 v1(195.54,49.39) 195.03,49.89 193.1,49.89 192.11,50.89 192.11,51.55 190.86,52.79 PR109.1 182.23,52.79 181.85,52.41 PQ23.2 179.79,50.91 179.79,50.69 177.67,48.57 177.19,48.57 v1(176.36,47.74)
  IN2 w0.203: v1(200.4,84.31) 200.4,84.5 197.16,87.74 187.14,87.74 185.39,85.99 182.43,85.99 181.57,86.85 170.9,86.85 170.39,86.34 169.25,86.34 167.34,84.44 167.34,79.87 165.95,78.47 165.95,76.01 163.28,73.34 163.28,69.05 159.09,64.86 159.09,61.18 v1(157.71,59.81)
  IN3 w0.203: v1(176.36,47.74) 172.17,47.74 168.69,44.26 167.29,44.26 166.86,43.83 163.4,43.83 162.69,43.12 161.45,43.12 160.61,42.27 159.6,42.27 158.71,43.16 155.76,43.16 v1(154.36,44.56) 153.86,44.05 151.85,44.05 150.83,45.07 149.44,45.07 144.46,40.09 133.37,40.09 133.09,40.37 131.94,40.37 v1(131.48,39.91)
  BOTTOM w0.203: PR218.2 v1(131.48,39.91)
  BOTTOM w0.254: v1(157.71,59.81) 157.27,59.37 157.27,47.32 156.68,46.72 155.03,46.72 154.36,46.06 v1(154.36,44.56) ; v1(200.4,84.31) 200.4,80.29 200.36,80.25 200.36,75.55 199.6,74.79 199.43,74.79 PR171.1 ; v1(195.67,46.14) 195.67,49.26 v1(195.54,49.39)
MAINON_ON_G: length 164.9
  TOP w0.14: PQ28.2 137.3,45.4 138.26,44.43 v1(138.26,42.66) 138.26,42.27 139.79,40.75 146.52,40.75 149.06,38.21 168.36,38.21 169.38,39.23 169.38,43.42 171.66,45.7 173.95,45.7 174.52,46.28 175.78,46.28 PR119.1 ; v1(173.82,72.63) 174.39,72.63 175.45,71.57 175.45,67.09 PQ19.2
  TOP w0.254: 208.37,46.85 200.87,46.85 198.99,48.73 193.53,48.73 191.6,50.66 191.6,51.42 190.59,52.43 186.39,52.43 185,51.04 185,50.53 183.59,49.12 PR115.2 181.93,49.12 PQ23.3 ; v1(180.93,51.34) 180.63,51.04 PQ23.3 ; PQ23.3 179.28,49.08 PQ25.2 178.39,48.75 177.77,48.13 PR119.1
  IN1 w0.114: v1(169.12,86.98) 169.88,86.22 169.88,81.39 168.23,79.74 168.23,74.28 169.88,72.63 v1(173.82,72.63)
  IN3 w0.089: v1(180.93,51.34) 180.32,51.95 178.62,51.95 178.39,52.18 174.71,52.18 173.82,53.07 v1(173.82,72.63)
  BOTTOM w0.14: v1(169.12,86.98) 169.12,94.22 164.55,98.79 PQ33.2
MBCLK: length 186.5
  TOP w0.14: v1(30.59,61.29) 30.84,61.04 31.8,61.04 31.98,61.22 PR96.2 32.79,61.51 33.17,61.9 33.17,65.84 v1(33.74,66.4) 33.74,66.53 33.49,66.79 PD4.1 ; U32.110 149.04,69.31 150.15,70.42 150.15,71.79 149.99,71.95 149.99,72.86 v1(149.73,73.11) 150.08,73.46 150.08,74.91 149.94,75.05 R301.1
  IN1 w0.114: 59.83,62.92 59.83,61.25 58.49,59.92 58.49,56.23 60.12,54.59 61.9,54.59 64.06,52.43 65.19,52.43 65.85,51.77 67.62,51.77 68.2,51.19 70.88,51.19 72.22,49.85 77.18,49.85 77.66,50.33 81.93,50.33 82.29,49.98 89.03,49.98 89.9,50.85 96.9,50.85 97.37,50.38 110.79,50.38 112.81,48.35 118.12,48.35 119.67,49.91 128.13,49.91 130.88,52.66 132.81,52.66 136.01,55.86 136.01,56.41 136.74,57.13 137.37,57.13 140.56,60.32 140.56,66.2 143.6,69.24 143.6,69.82 144.89,71.12 146.52,71.12 147.1,71.7 147.8,71.7 148.98,72.88 149.5,72.88 v1(149.73,73.11) ; 59.83,62.92 v1(59.84,62.93) ; 59.83,62.92 59.27,62.36 59.27,61.45 58.63,60.82 57.11,60.82 56.97,60.68 56.97,58.92 57.49,58.4 57.49,56.01 52.15,50.67 49.92,50.67 49.48,50.23 38,50.23 36.26,48.49 33.73,48.49 31.71,50.52 31.71,51.27 30.56,52.42 30.56,57.78 31.23,58.45 31.23,60.65 v1(30.59,61.29)
  BOTTOM w0.14: PR202.1 60.22,63.31 v1(59.84,62.93)
MBDATA: length 184.1
  TOP w0.14: v1(148.24,72.73) 148.88,72.09 148.88,71.27 R313.1 148.64,69.66 U32.111 ; PR87.2 32.04,65.69 31.32,66.41 v1(31.32,66.86) 31.94,67.48 31.94,68.45 32.18,68.69 PD3.1
  IN1 w0.114: v1(31.32,66.86) 31.32,61.08 31.6,60.8 31.6,58.3 30.94,57.64 30.94,52.56 32.09,51.41 32.09,50.66 33.89,48.86 36.11,48.86 37.85,50.6 49.31,50.6 49.75,51.04 51.99,51.04 57.12,56.17 57.12,58.25 56.6,58.77 56.6,60.94 56.98,61.32 58,61.32 58.33,61.66 58.33,63.05 59.45,64.18 v1(59.82,64.18) 59.9,64.18 60.33,63.74 60.33,61.12 58.89,59.68 58.89,56.87 60.58,55.19 61.82,55.19 63.61,53.4 65.24,53.4 65.69,52.94 67.51,52.94 67.64,52.82 67.64,52.27 68.35,51.56 71.03,51.56 72.37,50.22 77.02,50.22 77.5,50.7 82.08,50.7 82.44,50.35 88.88,50.35 89.75,51.22 97.05,51.22 97.52,50.75 110.94,50.75 112.96,48.72 117.96,48.72 119.55,50.3 128,50.3 130.73,53.03 132.66,53.03 135.01,55.38 135.01,56.86 137.95,59.81 138.8,59.81 140.05,61.06 140.05,66.21 143.23,69.39 143.23,69.97 144.74,71.48 146.36,71.48 146.95,72.07 147.58,72.07 v1(148.24,72.73)
  BOTTOM w0.14: PR200.1 60.17,64.53 v1(59.82,64.18)
MCT4: length 1.1
  BOTTOM w0.127: R449.1 150.21,161.03 v1(150.71,161.53)
MDI0+: length 140.9
  TOP w0.127: R1.2 151.26,163.9 152.03,163.9 152.18,164.06 152.18,164.45 151.52,165.11 151.52,165.49 151.37,165.64 151.25,165.64 151.22,165.6 U1.5 U1.4 149.58,165.6 149.54,165.64 148.92,165.64 148.45,166.1 148.3,166.1 148.18,165.97 C9.2 147.67,166.1 146.52,166.1 146.44,166.02 v1(146.44,165.85) ; U24.1 219.48,89.84 219.08,89.44 v1(218.8,89.44)
  IN3 w0.076: v1(146.44,165.85) 146.44,166.2 146.57,166.33 147.73,166.33 149.03,165.03 149.03,154.21 149.91,153.33 149.91,152.97 151.07,151.81 152.06,151.81 152.43,151.44 152.43,142.46 151.89,141.91 151.89,140.12 152.19,139.81 152.19,138.04 154.22,136.01 154.22,131.92 157.91,128.23 157.91,127.45 169.53,115.83 169.53,105.74 185.33,89.94 194.33,89.94 195.2,90.8 196.75,90.8 198.76,88.8 215.6,88.8 215.77,88.63 218.13,88.63 218.51,89.01 218.51,89.38 218.58,89.44 v1(218.8,89.44)
MDI0-: length 140.9
  TOP w0.127: U24.2 218.98,90.18 218.7,89.9 218.53,89.9 v1(218.09,89.47) ; v1(146.44,166.73) 146.64,166.53 147.72,166.53 C7.2 148.63,166.53 149.1,166.07 149.54,166.07 149.58,166.1 U1.3 U1.6 151.18,166.1 151.22,166.07 151.55,166.07 151.95,165.67 151.95,165.29 152.61,164.63 152.61,163.88 152.21,163.47 151.26,163.47 R2.2
  IN3 w0.076: v1(218.09,89.47) 218.22,89.34 218.22,89.13 218.01,88.92 215.89,88.92 215.73,89.09 198.88,89.09 196.87,91.09 195.07,91.09 194.21,90.23 185.45,90.23 169.82,105.86 169.82,115.95 158.2,127.57 158.2,128.36 154.52,132.04 154.52,136.13 152.49,138.16 152.49,139.93 152.18,140.24 152.18,141.79 152.73,142.34 152.73,151.56 152.18,152.1 151.19,152.1 150.2,153.1 150.2,153.45 149.32,154.33 149.32,165.15 147.85,166.62 146.55,166.62 v1(146.44,166.73)
MDI1+: length 137.8
  TOP w0.127: v1(154.8,153.88) 154.49,154.19 154.49,154.62 154.29,154.82 154.29,155.34 C50.2 154.57,156.03 154.57,156.47 153.6,157.44 153.12,157.44 153.09,157.47 U8.2 U8.7 150.71,157.47 R27.2 ; v1(217.62,91.87) 217.6,91.85 217.6,91.59 217.98,91.21 U24.4
  IN3 w0.076: v1(217.62,91.87) 217.42,92.07 217.42,92.4 216.96,92.86 204.64,92.86 204.14,93.37 202.14,93.37 201.76,93.75 193.97,93.75 193.69,93.47 191.23,93.47 190.66,92.9 186.57,92.9 181.99,97.48 181.99,97.95 182.74,98.71 182.74,99.3 182.33,99.72 181.74,99.72 180.92,98.9 180.57,98.9 180.33,99.14 180.33,99.49 181.08,100.25 181.08,100.83 180.66,101.25 180.07,101.25 179.32,100.5 178.97,100.5 178.73,100.74 178.73,101.09 179.54,101.91 179.54,102.5 179.13,102.91 178.54,102.91 177.75,102.13 177.34,102.13 175.64,103.83 175.64,104.51 175.97,104.85 177.76,104.85 178.18,105.27 178.18,105.86 177.76,106.28 173.95,106.28 173.69,106.54 173.69,107.01 173.95,107.26 176.48,107.26 176.91,107.69 176.91,108.4 176.48,108.82 174.08,108.82 173.82,109.08 173.82,109.55 174.08,109.8 175.09,109.8 175.51,110.23 175.51,110.85 175.09,111.27 174.16,111.27 173.82,111.62 173.82,115.15 173.41,115.55 173.41,116.13 161.25,128.3 161.25,129.17 159.62,130.79 159.62,132.07 157.31,134.38 157.31,137.18 155.58,138.9 155.58,152.46 154.66,153.39 154.66,153.74 v1(154.8,153.88)
