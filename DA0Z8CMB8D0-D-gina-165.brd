# Allegro board DA0Z8CMB8D0-D-gina-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DEVSLP1: length 6.9
  TOP w0.14: v1(147.7,124.11) 147.49,124.32 146.31,124.32 TP26.1
  BOTTOM w0.076: U45.L2 144.47,123.31 145.09,123.31 145.18,123.4 145.79,123.4 146.66,124.28 147.52,124.28 v1(147.7,124.11)
  BOTTOM w0.14: R544.1 148.29,124.7 v1(147.7,124.11)
DGPU_D: length 14.7
  TOP w0.14: PR31.2 PC19.2 25.99,116.94 25.99,116.32 26.76,115.55 28.15,115.55 28.91,114.79 PQ6.3 27.64,114.16 27.26,114.54 25.1,114.54 PQ5.2 23.55,112.99 v1(21.55,112.99)
DGPU_D1: length 8.7
  TOP w0.14: v1(19.9,135.87) PQ3.3
  TOP w0.381: PC12.2 23.11,140.9 PQ4.4
  TOP w0.508: PC12.2 PR24.2 21.79,141.07 PQ3.3
DGPU_D2: length 30.4
  TOP w0.508: PQ42.3 72.37,81.62 v1(72.37,82.32) 72.37,88.43 71.94,88.86 71.94,90.64 v1(73.24,91.93) 74.6,93.3 PQ10.4
  BOTTOM w0.508: PC116.2 78.03,76.87 76.68,78.22 73.62,78.22 73.35,78.49 PR163.2 73.35,81.34 v1(72.37,82.32)
DGPU_EDIDCLK: length 13.2
  BOTTOM w0.102: U43.A9 53.7,126.6 55.31,124.99 55.31,124.19 55.46,124.04
  BOTTOM w0.14: R614.2 57.67,115.49 57.67,117.79 v1(57.62,117.84) 56.97,118.49 56.97,122.53 55.46,124.04
DGPU_EDIDDATA: length 17.7
  BOTTOM w0.102: U43.B9 52.9,126.57 53.74,125.73 53.99,125.73 54.9,124.82 54.9,123.9 55.46,123.35
  BOTTOM w0.14: 55.46,123.35 56.46,122.34 56.46,116.1 55.75,115.39 55.75,113.49 R633.2 56.73,112.51 v1(56.73,111.29)
DGPU_EVENT#: length 153.9
  TOP w0.14: R163.2 34.63,116.7 35.14,116.19 35.14,115.55 34.5,114.92 34.5,113.39 35.01,112.89 35.01,112 36.53,110.47 36.53,108.37 v1(36.1,107.93) 36.1,107.35 36.58,106.87 41.72,106.87 v1(42.05,106.54)
  IN2 w0.076: 142.83,124.95 142.73,124.95 142.56,124.78 140.81,124.78 140.57,124.55
  IN2 w0.114: v1(75.27,103.74) 76.92,102.09 83.16,102.09 83.93,102.85 86.7,102.85 90,106.16 91.65,106.16 95.59,110.09 95.59,111.29 100.24,115.93 101.81,115.93 102.36,116.48 105.84,116.48 106.84,117.48 109.33,117.48 109.81,117.97 110.7,117.97 111.11,117.55 115.32,117.55 115.66,117.89 115.66,118.35 116.28,118.98 131.14,118.98 133.31,121.15 136.38,121.15 137.26,122.03 138.77,122.03 139.06,122.32 139.06,123.04 140.57,124.55 ; v1(151.72,128.63) 150.83,127.75 148.55,127.75 148.29,127.49 145.88,127.49 143.34,124.95 142.83,124.95
  IN3 w0.089: v1(75.27,103.74) 74.76,104.25 74.15,104.25 73.77,103.87 71.69,103.87 69.99,105.57 65.93,105.57 64.96,106.54 60.77,106.54 59.5,107.81 47.99,107.81 47.48,107.3 42.81,107.3 v1(42.05,106.54)
  BOTTOM w0.076: 148.41,128.13 147.5,127.22 147.5,126.7 146.33,125.53 145.81,125.53 145.34,125.05 145.22,125.05 144.97,124.81 143.86,124.81 143.61,125.06 U45.J3
  BOTTOM w0.089: 148.55,128.13 148.41,128.13
  BOTTOM w0.14: v1(151.72,128.63) 151.7,128.61 151.12,128.61 R534.1 150.59,128.13 148.55,128.13
DGPU_HOLD_RST#: length 142.4
  TOP w0.14: v1(38.82,100.52) 39,100.69 39,102.78 38.8,102.98 U22.1
  IN2 w0.076: 140.21,118.89 144.77,118.89
  IN2 w0.114: v1(147.68,120.3) 147.48,120.51 146.41,120.51 146.01,120.1 146.01,119.82 145.55,119.36 145.25,119.36 144.77,118.89 ; 140.21,118.89 138.39,118.89 137.96,118.46 137.31,118.46 136.86,118.91 134.98,118.91 134.58,118.52 133.73,118.52 133.19,117.97 133.19,117.11 132.89,116.8 126.48,116.8 125.78,116.1 113.76,116.1 112.33,114.66 109.86,114.66 109.61,114.41 109,114.41 108.26,113.67 108.26,112.79 104.43,108.95 100.54,108.95 94.95,103.36 92.29,103.36 89.14,100.21 85.02,100.21 82.97,98.15 80.4,98.15 75.62,93.37 71.87,93.37 v1(71.54,93.71)
  IN3 w0.089: v1(38.82,100.52) 39.61,101.31 46.09,101.31 48.36,103.58 53.58,103.58 54.82,102.35 57.36,102.35 57.44,102.27 67.22,102.27 67.35,102.14 68.25,102.14 70.35,100.04 70.35,96.96 71.54,95.77 v1(71.54,93.71)
  BOTTOM w0.076: v1(147.68,120.3) 147.53,120.46 146.24,120.46 146.05,120.27 145.18,120.27 145.07,120.15 143.71,120.15 143.65,120.21 143.23,120.21 U45.U4
  BOTTOM w0.14: v1(147.68,120.3) 148,119.99 149.28,119.99 149.41,119.87 150.23,119.87 150.43,119.67 150.67,119.67 R586.2
DGPU_OPP#: length 225
  TOP w0.14: Q10.3 51.52,115.3 49.36,113.14 46.48,113.14 45.08,111.74 v1(41.23,111.74) ; R362.1 137.43,57.31 137.93,57.31 138.9,58.28 138.9,58.78 139.44,59.33 U32.18 141.05,59.33 v1(141.36,59.01)
  IN1 w0.114: v1(141.36,59.01) 142.6,57.77 143.47,57.77 143.86,57.38 143.86,56.96 140.72,53.83 137.4,53.83 135.21,51.64 131.43,51.64 128.68,48.89 120.09,48.89 118.54,47.34 110.87,47.34 110.08,48.12 107.8,48.12 106.74,49.18 97.09,49.18 96.44,49.83 90.32,49.83 89.45,48.96 81.87,48.96 81.51,49.32 78.08,49.32 77.47,48.71 71.93,48.71 70.46,50.17 67.77,50.17 67.2,50.75 65.43,50.75 64.84,51.35 63.53,51.35 63.27,51.61 61.64,51.61 61.38,51.35 54.52,51.35 52.83,49.65 50.34,49.65 49.9,49.22 38.58,49.22 36.84,47.48 31.77,47.48 29.45,49.8 29.45,65.06 30.07,65.68 30.07,66.26 29.45,66.88 29.45,89.32 31.13,91.01 31.13,94.37 30.36,95.13 30.36,96.71 28.15,98.92 28.15,101.51 27.3,102.36 v1(27.3,104.4)
  BOTTOM w0.14: v1(27.3,104.4) 29.12,104.4 30.79,102.73 35.65,102.73 39.07,106.16 39.07,109.58 v1(41.23,111.74)
DGPU_OTP#: length 192.2
  TOP w0.14: v1(146.9,56.93) 147.3,57.33 148.16,57.33 148.78,56.71 151.18,56.71 151.85,57.38 153.97,57.38 154.41,57.82 154.82,57.82 155.13,58.13 U32.76 157.46,58.13 158.2,57.39 R361.1 ; Q15.3 40.39,108.19 v1(40.27,108.31)
  IN3 w0.089: v1(146.9,56.93) 145.84,55.87 140.55,55.87 139.16,57.25 137.05,57.25 135.71,55.91 135.71,55.72 134.99,54.99 134.24,54.99 131.75,52.51 130.06,52.51 128.44,50.88 119.55,50.88 119.19,50.52 113.43,50.52 111.52,52.42 106.36,52.42 104.94,51 104.4,51 104.17,50.76 91.27,50.76 89.39,48.88 81.97,48.88 81,47.9 70.77,47.9 69.92,48.75 68.06,48.75 67.79,48.48 66.53,48.48 66.23,48.78 64.15,48.78 63.52,49.41 61.91,49.41 60.38,50.94 51.19,50.94 50.21,51.91 49.57,52.55 49.29,52.84 45.17,52.84 44.39,53.62 36.01,53.62 35.21,54.42 35.21,73.9 36.73,75.42 36.73,94.93 35.65,96.01 35.65,99.64 36.15,100.13 36.15,103.79 37.84,105.48 37.84,105.88 v1(40.27,108.31)
DGPU_PGOK-1: length 8
  TOP w0.14: Q7.2 20.56,145.42 21.85,146.72 Q4.3 22.26,148.46 C77.1 R59.1 24.46,149.84 v1(24.47,149.84)
DGPU_POK2: length 4.5
  TOP w0.14: v1(18.37,149.07) 18.38,149.06 Q4.2 19.82,149.58 20.21,149.97 C63.1 R56.1
DGPU_PW_CTRL#: length 12
  BOTTOM w0.076: U45.P3 143.78,121.81 145.05,121.81 145.17,121.93 147.43,121.93 147.62,122.12 148.1,122.12
  BOTTOM w0.14: 148.1,122.12 148.16,122.18 149.36,122.18 149.42,122.12 151.56,122.12 151.72,122.28 151.72,122.54 152.36,123.17 R556.2 153.01,122.77 153.01,121.77 R574.1
DGPU_PWR_EN: length 275.2
  TOP w0.14: v1(29.78,104.76) 29.17,105.37 PR37.1
  IN3 w0.089: v1(29.78,104.76) 30.56,103.98 30.56,100.41 33.28,97.7 33.28,95.02 34.36,93.94 34.36,87.3 30.83,83.77 30.83,78.15 31.32,77.66 31.32,74.29 31.91,73.7 31.91,64.81 31.5,64.39 31.5,58.08 31.08,57.66 31.08,53.05 33.02,51.11 35.37,51.11 36.24,50.23 47.58,50.23 48.86,48.95 48.86,47.95 50.72,46.08 57.83,46.08 58.66,46.92 61.28,46.92 62.91,45.29 65.66,45.29 66.46,46.09 67.47,46.09 68.02,45.53 89.4,45.53 91.4,47.53 95.38,47.53 96.15,48.31 105.07,48.31 105.39,48.62 106.21,48.62 106.89,49.31 109.39,49.31 110.75,47.95 120.08,47.95 120.58,48.45 129.62,48.45 130.58,49.42 132.61,49.42 134.32,51.12 136.71,51.12 137.72,52.13 138.95,52.13 139.49,52.68 141.01,52.68 142.88,54.55 146.71,54.55 147.58,55.42 148.43,55.42 150.33,57.31 150.33,60.23 149.99,60.56 149.99,63.15 150.29,63.46 150.29,66.46 153.09,69.25 154.37,69.25 156.36,71.24 157.72,71.24 162.34,75.86 162.34,76.2 164.36,78.22 164.36,80.36 162.26,82.45 162.26,86.77 160.98,88.05 160.98,88.97 160.16,89.78 160.16,91.22 154.65,96.73 153.6,96.73 152.59,97.74 152.59,99.43 151.63,100.38 151.63,102.68 150.7,103.62 148.55,103.62 146.79,105.37 146.79,106.54 147.41,107.15 147.41,108.24 146.88,108.77 146.88,109.24 147.5,109.87 147.5,111.23 148.8,112.53 148.8,115.73 148.33,116.21 148.33,118.09 v1(147.73,118.69)
  BOTTOM w0.076: R592.1 147.81,118.69 v1(147.73,118.69) 147.73,118.79 147.2,119.31 146.06,119.31 145.56,118.82 143.78,118.82 U45.Y3
  BOTTOM w0.14: R593.2 150.2,118.22 149.68,118.74 148.81,118.74 R592.1
DGPU_PWROK: length 185.7
  TOP w0.14: R118.1 147.91,123.43 145.52,123.43 144.85,122.77 144.85,122.22 143.85,121.22 v1(143.85,120.98) ; v1(24.47,145.53) 23.46,145.53 R65.1 R69.2 22.53,144.14 Q7.3 21.9,143.98 v1(21.8,143.87)
  IN2 w0.114: v1(143.85,120.98) 143.85,120.76 143.09,120 139.69,120 139.19,119.5 136.83,119.5 136.37,119.95 133.64,119.95 131.59,117.9 130.92,117.9 130.27,117.25 126.32,117.25 125.76,116.69 113.74,116.69 112.15,115.1 109.68,115.1 109.55,114.96 108.33,114.96 105.37,112 99.15,112 97.62,110.47 97.62,109.46 92.41,104.25 91.91,104.25 88.35,100.69 84.75,100.69 82.64,98.59 80.22,98.59 75.85,94.22 72.12,94.22 71.75,94.58 71.75,105.79 v1(71.51,106.03)
  IN3 w0.089: v1(21.8,143.87) 22.06,143.62 22.06,138.16 21.01,137.12 21.01,131.71 25.89,126.83 25.89,123.15 28.53,120.51 28.53,119.87 30.69,117.71 31.96,117.71 33.28,116.39 33.28,114.89 38.19,109.99 43.54,109.99 44.15,110.6 52.66,110.6 52.97,110.91 58.33,110.91 60.54,108.7 64.76,108.7 66.38,107.07 70.47,107.07 v1(71.51,106.03)
  BOTTOM w0.102: U45.T3 143.52,121.31 v1(143.85,120.98)
DGPU_SELECT#: length 10.1
  BOTTOM w0.089: U45.L1 144.94,123.72 145.86,123.72 146.59,124.45 147.31,124.45 147.85,124.99 147.85,125.14 148.04,125.33 148.29,125.33
  BOTTOM w0.14: R543.1 153.57,125.64 152.28,125.64 151.98,125.33 148.29,125.33
DIMM1_SA0: length 3.6
  TOP w0.14: v1(156.57,83.52) 157.2,83.52 R284.1 157.58,83.15 v1(157.58,82.26)
  BOTTOM w0.14: v1(157.58,82.26) JDIM1.197
DIMM1_SA1: length 4.2
  TOP w0.14: R288.1 157.56,81.08 v1(157.69,81.21)
  BOTTOM w0.14: v1(157.69,81.21) 158.02,81.21 158.78,81.97 JDIM1.201
DMIC_CLK: length 13.9
  TOP w0.14: R415.2 v1(229.7,30.97) ; v1(230.16,42) 230.56,41.59 230.95,41.59 231.02,41.52 U34.3
  IN1 w0.114: v1(230.16,42) 230.16,41.97 229.57,41.39 229.57,32.24 229.83,31.99 229.83,31.1 v1(229.7,30.97)
DMIC_CLK_R: length 17
  TOP w0.14: R415.1 229.7,28.17 C512.1 D21.1 v1(229.58,26.41)
  BOTTOM w0.14: CN20.3 235.2,17.47 234.15,18.53 234.15,23.61 v1(233.89,23.86) 231.86,25.89 230.1,25.89 v1(229.58,26.41)
DMIC_DATA: length 13.6
  TOP w0.14: v1(230.97,30.97) 230.72,30.72 R416.2 ; U34.2 231.1,41.92 231,42.02 v1(230.77,42.02)
  IN1 w0.114: v1(230.97,30.97) 230.97,32.24 230.46,32.75 230.46,37.7 231.23,38.46 231.23,41.56 v1(230.77,42.02)
DMIC_DATA_R: length 15.4
  TOP w0.14: R416.1 230.72,28.17 C513.1 D22.1 230.58,26.78 v1(230.58,26.41)
  BOTTOM w0.14: v1(230.58,26.41) 232.11,26.41 v1(233.26,25.26) 234.53,23.99 234.53,19.29 235.35,18.47 CN20.4
DNBSWON#: length 55.7
  TOP w0.14: U32.120 145.04,66.96 144.89,66.81 v1(144.89,64.88) ; R236.1 147.75,98.69 v1(148.14,98.69)
  IN2 w0.114: v1(148.14,98.69) 148.29,98.69 150.09,96.89 150.09,89.88 154.52,85.45 154.52,79.57 153.49,78.55 153.49,76.16 154.15,75.51 154.15,69.09 152.05,67 152.05,64.03 150.22,62.2 150.22,61.47 149.87,61.12 145.32,61.12 144.76,61.68 144.76,64.76 v1(144.89,64.88)
DP_UTIL: length 5.8
  BOTTOM w0.203: U45.A43 119.01,130.13 119.01,133.13 v1(118.7,133.44) 118.07,134.07 R503.2 R502.2
DPWROK: length 58.6
  TOP w0.14: v1(150.73,74.18) 150.73,75.14 149.95,75.93 144.74,75.93 144.37,75.56 144.37,73.91 143.87,73.42 143.87,70.62 143.44,70.19 U32.124
  IN1 w0.114: v1(160.75,90.41) 159.86,91.3 158.45,91.3 157.95,91.8 153.37,91.8 151.72,90.15 151.72,87.94 152.43,87.23 152.43,85.2 150.58,83.35 150.58,81.01 149.56,79.99 149.56,75.35 v1(150.73,74.18)
  BOTTOM w0.14: R681.2 152.74,98.78 152.74,96.88 153.15,96.48 154.86,96.48 155.2,96.14 156.79,96.14 160.75,92.17 v1(160.75,90.41)
DPWROK_R: length 16.8
  BOTTOM w0.076: U45.AV5 141.91,108.49 141.91,107.19 142.49,106.6 143.53,106.6 143.9,106.23 144.53,106.23 144.99,105.77
  BOTTOM w0.14: 144.99,105.77 145.83,104.94 147.48,104.94 150.2,102.22 v1(150.2,101.46) 150.2,100.7 R679.1 149.82,100.07 R680.1 R681.1
DSWVREN: length 14.3
  BOTTOM w0.076: U45.AW7 140.99,107.8 140.99,106.38
  BOTTOM w0.089: 140.99,106.38 141.5,105.88 143.34,105.88 143.6,105.62 144,105.62 144.36,105.27
  BOTTOM w0.14: v1(146.14,100.57) 146.58,100.57 146.82,100.32 R677.1 147.02,100.57 146.57,101.03 146.57,101.9 R662.2 147.36,102.69 147.36,103.87 147.15,104.07 145.55,104.07 144.36,105.27
EAPD#: length 4.3
  TOP w0.14: v1(242.66,41.51) 242.39,41.25 R404.2 R407.1 R406.2 R403.2
EC_FB_CLAMP: length 198.7
  TOP w0.14: U32.77 155.13,58.53 154.67,58.06 154.31,58.06 153.87,57.62 151.75,57.62 151.08,56.96 148.88,56.96 148.26,57.57 146.93,57.57 v1(146.29,56.93) ; R201.1 44.99,104.5 45.32,104.84 45.32,106 v1(44.79,106.54) 43.77,106.54 42.93,107.38 40.52,107.38 v1(40.27,107.63) 40.19,107.55 38.57,107.55 37.94,108.18 R184.2
  IN3 w0.089: v1(146.29,56.93) 145.42,56.06 140.63,56.06 139.24,57.45 136.97,57.45 135.52,55.99 135.52,55.8 134.91,55.18 134.16,55.18 131.67,52.7 129.99,52.7 128.36,51.07 119.48,51.07 119.11,50.71 115.58,50.71 114.54,51.76 112.46,51.76 111.6,52.61 106.28,52.61 104.86,51.19 104.32,51.19 104.09,50.96 91.19,50.96 89.31,49.07 81.89,49.07 80.92,48.1 70.85,48.1 69.64,49.3 65.57,49.3 65.24,48.97 64.23,48.97 63.6,49.6 61.99,49.6 60.46,51.13 51.27,51.13 48.59,53.81 36.1,53.81 35.4,54.51 35.4,73.82 36.92,75.34 36.92,95.01 35.84,96.09 35.84,99.56 36.34,100.06 36.34,103.62 38.17,105.46 40.34,107.63 v1(40.27,107.63)
EC_FPBACK#: length 113.9
  TOP w0.14: v1(145.75,68.94) 145.84,68.86 U32.118 ; Q16.2 61.55,106.36 61.55,105.01 62.06,104.5 62.06,103.78 62.55,103.29 66.48,103.29 69.2,100.58 69.2,96.38 68.54,95.72 68.54,84.44 v1(68.67,84.31)
  BOTTOM w0.14: v1(145.75,68.94) 144.5,67.69 136.86,67.69 135.57,68.98 128.32,68.98 126.2,71.1 104.05,71.1 103.29,71.87 95.58,71.87 84.66,82.79 75.56,82.79 74.04,84.31 v1(68.67,84.31)
EC_PECR_R: length 10.5
  TOP w0.14: U32.117 146.24,68.8 146.25,68.8 146.25,69.47 v1(146.14,69.58) 146.14,70.47 145.88,70.72 145.88,70.98 146.01,71.1 146.52,71.1 146.64,71.23 146.64,71.54 146.52,71.66 145.88,71.66 145.1,72.45 144.52,72.45 144.4,72.58 144.4,72.88 144.52,73.01 145.57,73.01 145.69,73.14 145.69,73.39 145.57,73.52 145.25,73.52 145.12,73.64 R298.1
EC_PWROK: length 80.5
  TOP w0.14: U32.33 141.84,52.67 141.66,52.84 141.66,54.04 142.62,54.99 144.5,54.99 145.34,55.83 145.34,57.35 146.34,58.34 148.57,58.34 149.1,57.81 149.86,57.81 150.96,58.91 v1(150.96,59.29)
  IN3 w0.089: v1(150.96,59.29) 150.96,60.56 150.46,61.06 150.46,62.96 150.76,63.26 150.76,66.26 153.26,68.76 156.23,68.76 156.63,69.15 156.63,69.73 156.77,69.87 157.48,70.58 157.99,70.58 162.7,75.29 163.96,75.29 164.4,75.73 164.4,77.32 165.02,77.94 165.02,80.63 164.04,81.61 164.04,84.29 163.41,84.92 163.41,86.57 163.12,86.86 161.66,88.32 161.66,91.01 155.53,97.13 v1(155.53,97.27)
  BOTTOM w0.14: v1(155.53,97.27) 155.53,97.05 155.92,96.66 v3(157.31,96.66) 157.85,96.66 159.39,98.21 159.39,102.3 159.09,102.6 R656.1 R666.2 R674.2 158.84,98.8 158.58,98.54 U47.2
EC_PWROK_R: length 67.4
  TOP w0.14: R352.1 159.98,59.42 160.74,60.18 161.35,60.18 161.86,60.69 161.86,67.83 157.89,71.8 156.84,71.8 155.51,73.13 155.51,74.79 155.1,75.2 153.28,75.2 152.87,74.79 152.87,74.25 v1(152.21,73.59)
  IN1 w0.114: v1(152.21,73.59) 152.09,73.48 150.44,73.48 149.44,74.48 148.21,75.71 148.21,85.75 149.44,86.98 149.44,96.52 148.95,97.01 148.45,97.01 147.3,98.15 147.3,99.4 147.15,99.55 147.15,100.31 146.26,101.2 v1(146.14,101.2)
  BOTTOM w0.076: 144.36,104.89 143.8,105.44 143.47,105.44 143.21,105.7 141.42,105.7 140.7,106.42 U45.AY7
  BOTTOM w0.089: 144.74,104.5 144.36,104.89
  BOTTOM w0.14: v1(146.14,101.2) 146.14,101.7 R661.2 145.55,102.29 145.55,103.57 145.37,103.74 145.37,103.87 144.74,104.5
ECAGND: length 11.1
  TOP w0.203: U32.75 157.1,57.73 157.57,57.26
  TOP w0.508: 157.57,57.26 158.58,56.24 L19.2 158.95,56.01 159.22,55.74 C430.2 159.23,55.1 159.61,54.72 v1(159.77,54.72) ; C469.1 v1(160.61,51.42)
  BOTTOM w0.508: v1(160.61,51.42) 159.72,51.42 159.22,51.93 v1(159.22,53.58) 159.22,54.21 159.72,54.72 v1(159.77,54.72)
EDP_AUXN: length 78.3
  IN1 w0.102: v1(117.95,132.55) 117.95,132.45 117.76,132.27 117.53,132.27 117.33,132.06 117.33,129.04 116.47,128.18 112.91,128.18 111.77,127.03 110.57,127.03 108.31,124.77 103.29,124.77 101.61,123.1 101.61,120.85 98.64,117.87 98.64,116.57 95.41,113.34 88.01,113.34 75.44,100.77 72.01,100.77 71.64,100.4 71.64,99.54 72.01,99.17 73.16,99.17 73.41,98.92 73.41,98.29 73.03,97.9 72.6,97.9 72.46,98.04 v1(72.46,98.19)
  BOTTOM w0.076: U45.A45 117.57,129.97 117.64,129.9 117.77,129.9 117.9,130.04 117.9,130.28 117.23,130.95 117.23,132.02 117.46,132.25 117.79,132.25 117.95,132.41 v1(117.95,132.55)
  BOTTOM w0.14: C681.2 67.4,97.64 67.4,97.55 67.52,97.42 71.41,97.42 71.91,97.91 72.32,97.91 72.46,98.05 v1(72.46,98.19)
EDP_AUXN_C: length 6.8
  BOTTOM w0.14: CN7.10 67.55,103.97 67.43,103.85 67.43,103.37 66.9,102.84 66.9,101.71 R669.1 66.89,100.7 66.89,99.88 67.38,99.39 67.38,99.19 C681.1
EDP_AUXP: length 78.3
  IN1 w0.102: v1(72.44,97.48) 72.65,97.7 73.11,97.7 73.62,98.21 73.62,99 73.25,99.37 72.09,99.37 71.84,99.63 71.84,100.31 72.09,100.57 75.52,100.57 88.1,113.14 95.5,113.14 98.84,116.49 98.84,117.79 101.81,120.76 101.81,123.01 103.37,124.57 108.39,124.57 110.65,126.83 111.85,126.83 113,127.97 116.55,127.97 117.53,128.96 117.53,131.98 117.62,132.06 117.79,132.06 117.95,131.9 v1(117.95,131.9)
  BOTTOM w0.076: v1(117.95,131.9) 117.81,132.03 117.76,132.09 117.53,132.09 117.39,131.95 117.39,131.02 118.07,130.35 118.07,129.97 117.57,129.48 U45.B45
  BOTTOM w0.14: C680.2 67.13,97.65 67.13,97.43 67.41,97.15 71.52,97.15 72.02,97.65 72.27,97.65 v1(72.44,97.48)
EDP_AUXP_C: length 6.8
  BOTTOM w0.14: CN7.11 67.05,103.96 67.16,103.85 67.16,103.48 66.63,102.95 66.63,101.72 R668.1 66.62,100.72 66.62,99.77 67.12,99.28 67.12,99.15 C680.1
EDP_HPD: length 116
  TOP w0.14: v1(141.74,127.8) 141.74,128.3 143.72,130.29 143.72,130.79 145.37,132.44 147.07,132.44 147.51,132.88 147.51,133.56 147.13,133.94 v1(147.13,134.35) 147.13,135.48 147.65,136 R86.2
  IN2 w0.114: v1(75.9,103.74) 77.17,102.47 83,102.47 86.48,105.95 86.48,110.97 88.69,113.18 92.96,113.18 93.47,112.67 96.14,112.67 101.01,117.55 106.09,117.55 107.22,118.68 109.36,118.68 109.7,118.33 111.58,118.33 112.45,119.21 129.42,119.21 131.06,120.85 132.63,120.85 133.16,121.37 135.44,121.37 135.92,121.85 135.92,121.9 136.31,122.28 136.41,122.28 136.98,122.86 136.98,123.92 137.5,124.44 138.13,124.44 138.41,124.72 138.41,128.03 139.28,128.89 140.8,128.89 141.74,127.95 v1(141.74,127.8)
  BOTTOM w0.102: v1(141.74,127.8) 141.45,128.08 U45.D6
  BOTTOM w0.14: v1(75.9,103.74) 75.28,104.37 74.09,104.37 72.87,105.59 71.29,105.59 70.34,106.54 60.43,106.54 60.05,106.16 CN7.25
EDP_RCOMP: length 5
  TOP w0.508: v1(133.82,128.82) 132.02,128.82 v1(131.91,128.71) 131.91,128.72 131.47,128.28 131.47,127.01 R107.1
  BOTTOM w0.254: U45.D20 v1(133.82,128.82)
EDP_TXN0: length 80.2
  IN1 w0.102: v1(116.24,132.17) 116.44,131.97 116.62,131.97 116.85,131.73 116.85,130.13 116.25,129.52 112.86,129.52 111.3,127.96 110.31,127.96 108.31,125.97 103.54,125.97 100.92,123.35 100.92,120.99 96.74,116.81 96.74,115.82 95.64,114.72 92.67,114.72 91.78,113.83 88.01,113.83 87.17,114.66 86.57,114.66 86.32,114.41 86.32,112.53 85.96,112.18 85.46,112.18 85.1,112.53 85.1,113.92 84.86,114.16 84.52,114.16 84.29,113.92 84.29,110.6 78.96,105.27 76.25,105.27 75.15,104.17 72.98,104.17 69.12,100.31 64.94,100.31 64.8,100.18 64.8,100.01 v1(64.98,99.83)
  BOTTOM w0.076: U45.C45 117.57,129 117.28,129.3 117.28,130.47 116.85,130.9 116.85,131.76 116.66,131.95 116.46,131.95 v1(116.24,132.17)
  BOTTOM w0.14: C673.2 64.86,100.18 64.86,99.95 v1(64.98,99.83)
EDP_TXN0_C: length 4.8
  TOP w0.14: v1(64.93,101.84) 65.11,101.66 C285.2
  BOTTOM w0.14: CN7.13 66.05,103.92 65.93,103.8 65.93,103.5 64.73,102.3 64.73,102.04 v1(64.93,101.84) 65.11,101.66 C285.2
EDP_TXN1: length 79.2
  IN1 w0.102: v1(62.95,99.83) 62.77,99.83 62.59,100.01 62.59,100.52 63.13,101.05 66.86,101.05 71.21,105.39 74.72,105.39 84.75,115.43 91.27,115.43 92.54,116.7 95.08,116.7 100.13,121.74 100.13,123.52 103.26,126.65 106.05,126.65 107.62,128.22 108.8,128.22 110.86,130.29 114.64,130.29 115.53,131.18 115.53,133.59 115.91,133.97 116.54,133.97 116.8,133.71 116.8,133.33 116.7,133.23 116.3,133.23 116.21,133.32 v1(116.21,133.46)
  BOTTOM w0.076: v1(116.21,133.46) 116.21,133.26 116.16,133.21 115.83,133.21 115.62,132.99 115.62,131.23 116.21,130.64 116.37,130.64 116.73,130.28 116.73,129.76 116.67,129.7 116.49,129.7 116.45,129.75 U45.A47
  BOTTOM w0.14: v1(62.95,99.83) 62.63,100.16 62.63,100.29 62.76,100.43 C671.2
EDP_TXN1_C: length 5
  TOP w0.14: v1(62.92,101.84) 63.08,101.69 C283.2
  BOTTOM w0.14: C283.2 62.92,101.21 62.8,101.34 62.8,101.71 v1(62.92,101.84) 62.92,102.07 64.42,103.57 64.42,103.82 64.55,103.95 CN7.16
EDP_TXN2: length 80
  IN1 w0.102: v1(114.13,133.97) 114.36,133.74 114.57,133.74 114.84,133.47 114.84,131.6 114.29,131.05 110.06,131.05 107.92,128.91 107.34,128.91 105.77,127.34 102.93,127.34 99.35,123.76 99.35,122.08 98.41,121.14 98.03,121.14 94.4,117.51 91.7,117.51 90.86,116.67 84.95,116.67 76.32,108.04 72.86,108.04 69.91,105.09 67.22,105.09 65.24,103.11 62.19,103.11 61.68,102.6 61.68,101.66 60.64,100.62 60.64,100.09 v1(60.89,99.83)
  BOTTOM w0.076: U45.C47 116.26,128.77 116.21,128.82 116.21,129.24 116.17,129.31 116.15,129.38 116.15,129.51 116.18,129.57 116.21,129.66 116.21,129.88 116.15,130 116.15,130.27 115.3,131.12 115.3,133.05 114.63,133.73 114.37,133.73 v1(114.13,133.97)
  BOTTOM w0.14: v1(60.89,99.83) 60.69,99.83 60.54,99.98 60.54,100.29 60.68,100.43 C669.2
EDP_TXN2_C: length 5.3
  TOP w0.14: C281.2 61.05,101.66 v1(60.87,101.84)
  BOTTOM w0.14: CN7.19 63.05,103.94 61.26,102.16 61.11,102.16 60.87,101.91 v1(60.87,101.84) 60.71,101.69 60.71,101.44 60.94,101.21 C281.2
EDP_TXN3: length 77.1
  IN1 w0.102: v1(114.09,131.89) 114.09,132.03 113.99,132.12 110.16,132.12 107.63,129.6 105.35,129.6 104.31,128.56 101.01,128.56 98.08,125.63 98.08,123.22 93.34,118.47 85.64,118.47 75.89,108.72 72.57,108.72 70.51,106.66 62.95,106.66 59.78,103.49 59.78,101.74 58.51,100.47 58.51,100.01 58.68,99.83 v1(58.86,99.83)
  BOTTOM w0.076: v1(114.09,131.89) 114.09,132.07 114.18,132.16 114.43,132.16 114.64,131.96 114.64,130.94 115.34,130.24 115.34,129.97 115.28,129.9 115.12,129.9 115.07,129.96 U45.A49
  BOTTOM w0.14: C667.2 58.62,100.43 58.53,100.34 58.53,99.98 58.68,99.83 v1(58.86,99.83)
EDP_TXN3_C: length 6
  TOP w0.14: v1(58.84,101.84) 59.01,101.66 C279.2
  BOTTOM w0.14: CN7.22 61.55,103.96 61.42,103.83 61.42,103.69 61.16,103.43 60.43,103.43 v1(58.84,101.84) 58.63,101.63 58.63,101.36 58.78,101.21 C279.2
EDP_TXP0: length 80.2
  IN1 w0.102: v1(64.22,99.83) 64.45,99.83 64.6,99.98 64.6,100.26 64.86,100.52 69.04,100.52 72.9,104.38 75.07,104.38 76.17,105.47 78.87,105.47 84.08,110.69 84.08,114 84.44,114.36 84.95,114.36 85.3,114 85.3,112.62 85.54,112.38 85.88,112.38 86.11,112.62 86.11,114.5 86.49,114.87 87.26,114.87 88.1,114.03 91.69,114.03 92.58,114.92 95.56,114.92 96.54,115.9 96.54,116.9 100.72,121.08 100.72,123.43 103.46,126.17 108.23,126.17 110.22,128.16 111.21,128.16 112.78,129.73 116.16,129.73 116.65,130.21 116.65,131.65 116.53,131.76 116.34,131.76 116.24,131.66 v1(116.24,131.52)
  BOTTOM w0.076: v1(116.24,131.52) 116.24,131.71 116.32,131.79 116.59,131.79 116.68,131.7 116.68,130.83 117.12,130.4 117.12,129.21 U45.B46
  BOTTOM w0.14: C672.2 64.48,100.43 64.59,100.32 64.59,100 64.42,99.83 v1(64.22,99.83)
EDP_TXP0_C: length 4.8
  TOP w0.14: C284.2 64.09,101.63 v1(64.3,101.84)
  BOTTOM w0.14: CN7.14 65.55,103.91 65.66,103.8 65.66,103.61 64.46,102.41 64.46,102 v1(64.3,101.84) 64.09,101.63 C284.2
EDP_TXP1: length 79.2
  IN1 w0.102: v1(62.19,99.83) 62.39,100.03 62.39,100.6 63.04,101.25 66.78,101.25 71.12,105.6 74.63,105.6 84.67,115.63 91.19,115.63 92.46,116.9 95,116.9 99.92,121.83 99.92,123.61 103.18,126.86 105.97,126.86 107.54,128.43 108.72,128.43 110.78,130.49 114.55,130.49 115.33,131.27 115.33,133.68 115.82,134.17 116.63,134.17 117,133.8 117,133.25 116.78,133.03 116.42,133.03 v1(116.21,132.83)
  BOTTOM w0.076: v1(116.21,132.83) 116,133.04 115.9,133.04 115.78,132.92 115.78,131.3 116.28,130.81 116.44,130.81 116.89,130.35 116.89,129.69 116.74,129.54 116.56,129.54 U45.B47
  BOTTOM w0.14: C670.2 62.36,100.13 62.36,100 v1(62.19,99.83)
EDP_TXP1_C: length 5
  TOP w0.14: v1(62.29,101.84) 62.06,101.61 C282.2
  BOTTOM w0.14: CN7.17 64.05,103.96 64.16,103.86 64.16,103.68 62.32,101.84 v1(62.29,101.84) 62.29,101.44 C282.2
EDP_TXP2: length 80
  IN1 w0.102: v1(60.13,99.83) 60.28,99.83 60.44,99.98 60.44,100.7 61.48,101.74 61.48,102.68 62.1,103.31 65.15,103.31 67.13,105.29 69.83,105.29 72.77,108.24 76.23,108.24 84.87,116.87 90.78,116.87 91.62,117.71 94.31,117.71 97.94,121.35 98.32,121.35 99.15,122.17 99.15,123.84 102.85,127.54 105.69,127.54 107.25,129.11 107.83,129.11 109.97,131.25 114.21,131.25 114.64,131.68 114.64,133.38 114.49,133.54 114.21,133.54 114.13,133.46 v1(114.13,133.33)
  BOTTOM w0.076: U45.C46 116.32,128.45 116.05,128.72 116.05,129.2 116.02,129.25 115.99,129.35 115.99,129.54 116,129.57 116.05,129.69 116.05,129.85 115.99,129.97 115.99,130.2 115.13,131.06 115.13,132.99 114.56,133.56 114.26,133.56 114.13,133.44 v1(114.13,133.33)
  BOTTOM w0.14: v1(60.13,99.83) 60.27,99.97 60.27,100.19 C668.2
EDP_TXP2_C: length 5.3
  TOP w0.14: v1(60.23,101.84) 60.03,101.63 C280.2
  BOTTOM w0.14: C280.2 60.03,101.63 v1(60.23,101.84) 60.66,102.27 60.85,102.27 61,102.42 61.15,102.42 62.55,103.82 CN7.20
EDP_TXP3: length 77.1
  IN1 w0.102: v1(58.1,99.83) 58.3,100.03 58.3,100.55 59.57,101.82 59.57,103.57 62.87,106.87 70.43,106.87 72.49,108.92 75.8,108.92 85.56,118.68 93.25,118.68 97.88,123.3 97.88,125.71 100.92,128.76 104.23,128.76 105.26,129.8 107.55,129.8 110.08,132.33 113.86,132.33 v1(114.08,132.55)
  BOTTOM w0.076: v1(114.08,132.55) 114.3,132.33 114.5,132.33 114.8,132.03 114.8,131.01 115.51,130.31 115.51,129.9 115.07,129.45 U45.B49
  BOTTOM w0.14: C666.2 58.26,100.17 58.26,100 v1(58.1,99.83)
EDP_TXP3_C: length 6
  TOP w0.14: C278.2 58,101.63 v1(58.2,101.84)
  BOTTOM w0.14: CN7.23 61.05,103.99 61.15,103.89 61.15,103.8 61.05,103.7 60.32,103.7 58.92,102.3 58.66,102.3 v1(58.2,101.84) 58.2,101.42 C278.2
ENSWREG: length 2.5
  TOP w0.305: v1(217.89,79.74) 217.89,80.43 217.98,80.52 U24.45
  TOP w0.508: v1(217.89,79.74) 217.64,79.49 R291.1
EVDD10: length 5.1
  TOP w0.305: U24.29 209.65,83.71 v1(209.64,83.73)
  TOP w0.508: v1(209.64,83.73) 209.21,83.3 C324.1 C323.2 206.24,83.3 R286.2
FAN1_PWM: length 79.2
  TOP w0.14: v1(138.52,51.52) 140.14,51.52 140.52,51.9 140.52,52.61 140.19,52.94 U32.32
  IN1 w0.114: v1(157.55,63.24) 156.68,64.12 156.68,65.39 157.44,66.15 157.44,67.55 158.58,68.69 158.58,71.29 161.63,74.34 161.63,75.8 165.44,79.61 165.44,82.91 168.23,85.71 168.23,87.23 168.39,87.39 172.65,87.39 177.12,82.92 179.07,82.92 179.57,82.42 179.57,81.86 v1(179.79,81.64)
  BOTTOM w0.14: v1(138.52,51.52) 138.52,51.55 140.29,49.77 148.71,49.77 150.86,51.91 153.38,51.91 156.73,55.27 156.73,61.13 157.46,61.86 157.46,63.15 v1(157.55,63.24) ; Q40.1 180.68,80.76 v1(179.79,81.64)
FAN2_PWM: length 235.6
  TOP w0.14: v1(139.05,52.82) 139.05,53.76 139.42,54.13 U32.31
  IN3 w0.089: v1(12.18,150.86) 13.14,149.89 13.14,143.64 16.58,140.21 16.58,138.94 18.75,136.76 18.75,128.31 21.52,125.54 21.52,120.86 31.07,111.31 31.07,102.6 30.75,102.28 30.75,100.49 33.47,97.78 33.47,95.1 34.55,94.02 34.55,87.22 31.02,83.69 31.02,78.23 31.51,77.74 31.51,74.37 32.1,73.78 32.1,64.73 31.69,64.31 31.69,58 31.27,57.58 31.27,53.13 33.1,51.3 35.45,51.3 36.32,50.42 47.66,50.42 49.05,49.03 49.05,48.03 50.8,46.28 57.75,46.28 58.58,47.11 61.36,47.11 62.97,45.5 65.6,45.5 66.38,46.28 67.54,46.28 68.1,45.72 89.32,45.72 91.32,47.72 95.3,47.72 96.07,48.5 104.99,48.5 105.31,48.82 106.13,48.82 106.81,49.5 109.47,49.5 110.83,48.14 120,48.14 120.5,48.64 129.54,48.64 130.5,49.61 132.53,49.61 134.24,51.31 136.57,51.31 137.59,52.33 138.66,52.33 139.05,52.71 v1(139.05,52.82)
  BOTTOM w0.14: Q35.1 10.63,155.81 10.68,155.76 10.68,152.36 v1(12.18,150.86)
FAN2SIG: length 259.1
  TOP w0.14: v1(147.79,53.27) 147.84,53.22 U32.48
  IN1 w0.114: v1(21.29,117.51) 21.55,117.26 21.55,114.41 26.27,109.69 26.27,104.36 27.06,103.57 27.06,102.3 27.9,101.46 27.9,98.79 30.13,96.55 30.13,95.06 30.91,94.28 30.91,91.1 29.23,89.41 29.23,49.71 30.95,47.99 30.95,47.99 31.68,47.26 37.04,47.26 38.78,49 49.99,49 50.43,49.44 53.02,49.44 54.71,51.13 60.99,51.13 60.99,51.13 61.55,51.13 62.13,50.55 63.61,50.55 63.72,50.66 64.91,50.66 65.25,50.32 67.02,50.32 67.61,49.72 70.3,49.72 72.1,47.92 81.67,47.92 82.28,48.53 89.63,48.53 90.5,49.4 96.26,49.4 96.91,48.75 106.56,48.75 107.62,47.69 109.9,47.69 110.69,46.9 118.72,46.9 120.27,48.46 128.89,48.46 131.64,51.21 137.26,51.21 138.01,51.96 138.86,51.96 139.61,51.21 144.38,51.21 145.57,52.4 146.92,52.4 v1(147.79,53.27)
  IN3 w0.089: v1(21.29,117.51) 21.29,125.46 18.55,128.2 18.55,136.59 16.34,138.79 16.34,140.06 12.95,143.46 12.95,149.5 10.75,151.7 10.75,156.7 12.4,158.35 17.36,158.35 v1(17.48,158.23)
  BOTTOM w0.14: v1(17.48,158.23) 17.25,158.46 CN4.2 14.65,158.46 14.31,158.8 v1(14.31,159.24) 14.31,160.77 13.41,161.66 R447.2
FAN_PWM_CN1: length 6.3
  BOTTOM w0.14: Q40.3 181.87,82.79 181.15,83.52 R697.2 181.15,84.63 v1(181.57,85.05) 182.17,85.05 182.58,84.63 CN10.1
FAN_PWM_CN2: length 11.1
  BOTTOM w0.14: Q35.3 10.37,160.51 R445.2 10.74,160.88 11.52,161.65 11.52,162.04 11.77,162.29 14.31,162.29 v1(14.82,161.78) 14.82,159.88 15.23,159.46 CN4.1
FANSIG: length 71.3
  TOP w0.14: v1(147.79,54.54) 147.35,54.11 147.35,52.97 147.44,52.88 U32.47
  IN2 w0.114: v1(185.02,86.88) 185.02,87.13 184.06,88.1 167.78,88.1 165.07,85.39 165.07,75.84 163.44,74.21 161.23,74.21 158.56,71.54 158.56,69.07 156.8,67.31 156.8,66.39 156.01,65.6 156.01,63.35 155.08,62.42 155.08,60.99 153.88,59.8 153.88,58.63 152.64,57.39 151.83,57.39 151.52,57.08 151.52,55.48 150.53,54.5 149.13,54.5 148.6,55.02 148.26,55.02 147.79,54.54 v1(147.79,54.54)
  BOTTOM w0.14: R699.2 184.99,83.41 185.37,83.8 CN10.2 185.37,86.53 v1(185.02,86.88)
FB_CAL_PD_VDDQ: length 25.8
  TOP w0.102: v1(50.89,136.96) 50.97,136.96 51.39,136.55 51.87,136.55 52.26,136.16
  TOP w0.381: 52.26,136.16 52.26,134.12 53.04,133.33 53.04,131.81 53.86,131 53.86,129.19 53.55,128.89 53.55,126.6 55.84,124.32 55.84,118.73 v1(56.09,118.47) 56.09,117.84 55.84,117.59 55.84,116.71 R172.2
  BOTTOM w0.102: U43.D22 50.89,136.95 v1(50.89,136.96)
FB_CAL_PU_GND: length 27.2
  TOP w0.254: v1(52.5,139.43) 53.01,138.92 53.93,138.92 54.7,138.16 54.7,137.52 53.81,136.64 53.81,133.97 53.96,133.81 53.96,132.16 55.46,130.67 55.46,129.02 54.47,128.03 54.47,126.98 56.75,124.7 56.75,120.1 v1(57.11,119.74) 57.13,119.72 57.13,117.55 R161.2
  BOTTOM w0.102: v1(52.5,139.43) 52.5,139.42 52.51,139.42 52.51,139.42 52.52,139.42 52.52,139.41 52.48,139.41 52.13,139.06 U43.C24
FB_CAL_TERM_GND: length 28.7
  TOP w0.254: R149.2 57.61,120.77 v1(57.36,121.01) 57.11,121.27 57.11,124.84 54.82,127.13 54.82,127.57 55.38,128.13 55.97,128.13 56.47,128.63 56.47,130.67 55.84,131.3 55.33,131.3 54.32,132.31 54.32,133.96 54.16,134.12 54.16,136.36 55.33,137.52 55.33,139.94 54.64,140.62 53.66,140.62 v1(53.3,140.27)
  BOTTOM w0.102: v1(53.3,140.27) 52.9,139.87 U43.B25
FB_CLAMP_MON: length 36.4
  TOP w0.14: 39.33,111.11 40.85,111.11 41.03,111.29 44.97,111.29 46.44,112.76 49.36,112.76 49.87,113.27 51.55,113.27 v1(52.82,114.54) ; 39.33,111.11 39.33,112.12 v1(38.57,112.89) 38.31,113.14 35.65,113.14 35.26,113.52 Q14.1 ; 39.33,111.11 39.33,110.47 38.82,109.97 38.45,109.97 R181.1
  BOTTOM w0.102: U43.C6 52.41,124.16 52.81,124.56 52.98,124.56 53.3,124.25 53.3,123.35 54.95,121.7 54.95,119.49
  BOTTOM w0.14: v1(52.82,114.54) 52.82,115.96 53.18,116.32 53.18,117.02 54.95,118.79 54.95,119.49
FB_CLAMP_REQ#: length 204.2
  TOP w0.14: v1(30.82,113.27) 30.82,113.9 31.96,115.05 32.21,115.05 R167.2 ; R380.1 157.69,53.57 157.69,54.72 156.68,55.73 U32.70 155.02,55.73 154.38,55.09 151.99,55.09 150.86,56.22 148.4,56.22 v1(148.04,55.86)
  IN3 w0.089: v1(148.04,55.86) 147.62,55.86 146.5,54.74 141.82,54.74 140.67,53.6 138.73,53.6 138.01,52.87 137.36,52.87 136.35,51.86 133.47,51.86 132.47,50.85 130.76,50.85 129.11,49.2 120.28,49.2 119.77,48.69 112.93,48.69 111.57,50.05 106.53,50.05 105.85,49.36 105.08,49.36 104.77,49.04 95.85,49.04 95.07,48.27 91.09,48.27 89.09,46.27 68.33,46.27 67.76,46.84 65.85,46.84 65.55,47.15 63.47,47.15 62.84,47.77 60.37,47.77 58.89,49.25 50.51,49.25 48.73,51.03 36.49,51.03 35.67,51.84 33.82,51.84 32.6,53.07 32.6,58.28 32.23,58.64 32.23,64.09 32.69,64.54 32.69,77.34 31.56,78.46 31.56,83.46 35.09,86.99 35.09,94.25 34.01,95.33 34.01,98 32.87,99.15 32.87,102.32 31.84,103.36 31.84,111.36 30.82,112.38 v1(30.82,113.27)
FBA_CMD0: length 71.4
  TOP w0.102: v1(67.21,129.58) 66.81,129.58 66.15,128.92 66.15,128.53 66.3,128.38 66.3,126.63 66.16,126.48 U16.K1 ; v1(67.24,141.09) 67.05,141.28 66.61,141.28 66.38,141.06 66.38,140.85 66.63,140.6 66.63,140.4 66.38,140.14 66.38,139 66.09,138.71 65.93,138.56 U13.K1
  IN1 w0.14: v1(68.09,135.27) 68.09,136.14 67.58,136.65 67.58,140.08 67.81,140.31 67.81,140.83 67.55,141.09 v1(67.24,141.09)
  IN3 w0.102: v1(64.17,146.71) 64.68,146.71 65.32,146.57 65.74,146.36 66.11,145.86 66.43,145.46 66.73,145.05 66.85,144.93 66.93,144.85 67.1,144.5 67.11,144.5 67.22,144.11 67.15,143.99 66.88,143.91 66.81,143.79 66.85,143.64 66.97,143.57 67.37,143.68 67.47,143.62 67.51,143.47 67.42,143.32 67.06,143.23 66.99,143.1 67.03,142.96 67.16,142.88 67.42,142.96 67.55,142.88 67.65,142.48 67.65,136.91 68.09,136.48 v1(68.09,135.27) 68.09,134.98 67.7,133.59 67.7,130.91 68.1,130.52 68.1,129.97 67.71,129.58 v1(67.21,129.58)
  BOTTOM w0.102: U44.K1 66.3,132.17 66.3,131.08 66.1,130.88 66.1,130.37 66.28,130.19 66.6,130.19 v1(67.21,129.58) ; v1(67.24,141.09) 66.75,141.58 66.75,141.64 66.3,142.1 66.3,144.06 U41.K1
  BOTTOM w0.178: U43.C27 52.49,141.85 55.12,141.85 59.54,146.26 60.03,146.26 60.86,147.09 61.15,147.09 61.27,146.96 61.27,145.78 61.4,145.65 62.06,145.65 62.19,145.78 62.19,147.53 62.32,147.66 62.72,147.66 62.85,147.53 62.85,146.24 62.98,146.11 63.36,146.11 63.48,146.24 63.48,147.91 63.61,148.04 64.04,148.04 64.17,147.91 v1(64.17,146.71) 64.98,147.52 66.22,147.52 66.63,147.94 v1(66.63,148.35) 66.63,148.98 R487.2
FBA_CMD1: length 73.4
  TOP w0.102: U13.L2 66.33,138.34 66.33,137.96 67.69,136.59 70.61,136.59 72.48,134.73 72.48,134.1 72.6,133.97 72.98,133.97 73.11,134.1 73.11,134.86 73.24,134.98 73.62,134.98 73.75,134.86 73.75,134.43 73.87,134.31 v1(74.84,134.31) ; v1(67.95,126.89) 67.13,126.89 U16.L2
  IN1 w0.102: v1(52.49,141.06) 52.5,141.08
  IN1 w0.14: 52.5,141.08 53.53,142.97 53.73,143.68 53.78,143.88 55.05,145.07 55.74,145.71 57.85,146 58.23,146.05 59.65,146.24 60.63,146.05 61.83,145.81 63.49,146.08 64.6,146.08 64.96,146.44 68.48,146.44 68.62,146.58 68.62,147.3 68.76,147.44 69.01,147.44 69.15,147.3 69.15,146.58 69.28,146.44 69.53,146.44 69.67,146.58 69.67,147.3 69.81,147.44 70.05,147.44 70.19,147.3 70.19,146.58 70.33,146.44 71.83,146.44 71.96,146.57 71.96,147.47 72.1,147.61 72.34,147.61 72.48,147.47 72.48,146.57 72.61,146.44 72.87,146.44 73,146.57 73,147.47 73.14,147.61 73.38,147.61 73.52,147.47 73.52,146.57 73.65,146.44 73.91,146.44 74.04,146.57 74.04,147.47 74.18,147.61 74.42,147.61 74.56,147.47 74.56,146.57 74.69,146.44 75.29,146.44 76.18,145.55 76.18,137.66 75.73,137.2 75.47,136.43 75.47,136.16 75.56,135.89 75.48,135.35 75.45,135.09 v1(74.84,134.31) 72.35,131.96 71.96,131.54 69.22,128.64 68.79,128.27 68.47,128.09 68.27,127.77 v1(67.95,126.89)
  BOTTOM w0.102: U43.C26 52.1,140.68 v1(52.49,141.06)
FBA_CMD2: length 78.3
  TOP w0.178: v1(71.99,140.05) 71.59,139.68 71.46,139.3 71.59,139.05 74.3,137.23 74.63,137 74.76,136.91 75.05,136.62 v1(75.05,135.99)
  IN1 w0.102: v1(50.86,139.47) 52.04,140.66 52.73,140.66 52.98,140.9
  IN1 w0.14: v1(75.05,135.99) 75.05,136.11 75.26,137.1 75.43,137.52 75.84,137.94 75.84,145.41 75.15,146.1 74.79,146.1 74.65,145.96 74.65,144.5 74.51,144.36 74.27,144.36 74.13,144.5 74.13,145.96 73.99,146.1 73.75,146.1 73.61,145.96 73.61,144.5 73.47,144.36 73.23,144.36 73.09,144.5 73.09,145.96 72.95,146.1 72.71,146.1 72.57,145.96 72.57,144.5 72.43,144.36 72.19,144.36 72.05,144.5 72.05,145.96 71.91,146.1 65.82,146.1 65.69,145.97 65.69,144.99 65.57,144.87 65.27,144.87 65.13,145.01 65.13,145.26 64.99,145.4 64.75,145.4 64.61,145.26 64.61,145.01 64.47,144.87 64.23,144.87 64.09,145.01 64.09,145.54 63.95,145.68 63.71,145.68 63.57,145.54 63.57,145.01 63.43,144.87 62.69,144.87 62.01,145.41 61.55,145.49 59.74,145.84 59.57,145.86 58.6,145.71 56.22,145.35 55.95,145.31 55.05,144.41 54.59,143.94 54.31,143.68 54.01,143.4 53.94,142.97 53.81,142.24 52.98,140.9
  BOTTOM w0.102: v1(50.86,139.47) U43.E24 ; v1(71.99,140.05) 71.76,140.68 71.38,141.06 71.36,141.08 70.23,141.34 69.83,141.54 69.54,141.84 68.01,142.96 67.91,143.35 67.91,144.05 67.65,144.31 67.45,144.31 U41.L2 ; U44.L2 66.73,132.27 66.4,132.6 66.4,134.68 66.61,134.89 67.57,134.89 67.78,134.68 67.78,134.12 67.95,133.95 68.32,133.95 68.79,134.43 69.07,134.43 69.55,133.95 71.64,133.95 73.87,135.29 v1(75.05,135.99)
FBA_CMD3: length 69.6
  TOP w0.102: U13.K9 65.93,144.65 66.32,144.26 66.32,143.02 65.88,142.59 65.88,141.89 v1(66.1,141.67) ; v1(66.4,129.76) 66,130.16 66,130.67 66.29,130.97 66.29,132.24 U16.K9
  TOP w0.178: R61.1 66.51,149.26 66.51,148.45 66,147.94 v1(65.11,147.94) 64.2,147.94 64.06,148.09 63.54,148.09 v1(61.73,146.27)
  IN1 w0.14: v1(50.02,139.46) 49.74,139.74 49.74,141.72 54.87,146.85 54.87,148.37 55.08,148.57 55.48,148.57 55.69,148.37 55.69,146.92 55.81,146.8 61.2,146.8 v1(61.73,146.27) ; v1(66.4,129.76) 66.51,129.87 66.51,130.84 66.79,131.12 66.79,135.83 v1(66.8,135.84) 66.8,139.81 66.32,140.29 66.32,140.65 66.4,140.73 66.4,141.52 66.25,141.67 v1(66.1,141.67)
  IN3 w0.102: v1(66.8,135.84) 66.8,135.97 66.3,136.47 66.3,137.75 65.72,138.34 65.39,138.34 65.08,138.64 65.08,140.8 65.66,141.37 65.66,141.8 65.87,142.02 65.87,142.45 65.69,142.63 64.65,142.63 64.55,142.73 64.55,142.99 64.65,143.09 65.03,143.09 65.16,143.21 65.16,144.56 64.88,144.84 64.11,144.84 63.2,145.75 62.25,145.75 61.73,146.28 v1(61.73,146.27)
  BOTTOM w0.102: v1(50.02,139.46) 50,139.46 U43.F24 ; U44.K9 65.93,126.71 66.33,127.1 66.33,128.99 66.46,129.12 66.46,129.7 v1(66.4,129.76) ; U41.K9 66.38,139.27 66.38,141.21 66.38,141.31 v1(66.1,141.67)
FBA_CMD4: length 119
  TOP w0.102: U16.R7 70.64,130.57 71.35,130.57 v1(72.35,130.69) ; v1(72.35,142.56) 71.35,142.44 70.64,142.44 U13.R7 ; v1(49.06,160.62) 49.18,159.62 49.18,158.91 U12.R7 ; U11.R7 37.31,158.91 37.31,159.62 v1(37.19,160.62)
  IN1 w0.14: v1(72.68,136.29) 72.68,136.44 73.14,137.58 73.14,140.7 72.87,141.28 72.79,141.47 v1(72.35,142.56) ; v1(43.44,161.24) 44,161.24 44.03,161.27 45.21,161.27 45.41,161.07 47.16,161.07 47.76,160.47 48.43,160.47 48.63,160.67 48.63,160.85 48.73,160.95 48.96,160.95 49.06,160.85 v1(49.06,160.62)
  IN3 w0.102: v1(37.19,160.62) 37.39,160.82 38.49,160.82 38.69,161.03 41.91,161.03 41.91,161.03 43.23,161.03 v1(43.44,161.24) 43.87,161.24 44.71,161.51 45.42,161.51 45.98,162.07 46.81,162.07 47.95,163.21 49.08,163.64 49.4,163.64 51.36,162.85 55.63,160.79 56.57,159.93 57.71,158.71 58.03,157.82 58.03,157.82 59.41,156.44 59.83,155.37 61.7,152.47 61.95,151.89 62.21,151.63 v1(62.95,151.48) 63.38,151.48 63.64,151.22 63.84,151.22 63.92,151.29 63.92,151.4 64.04,151.52 64.22,151.52 64.34,151.4 64.34,151.07 64.45,150.96 64.59,150.96 64.7,151.07 64.7,151.37 64.8,151.48 64.95,151.48 65.05,151.37 65.05,150.89 65.16,150.78 65.31,150.78 65.41,150.89 65.41,151.44 65.5,151.53 65.71,151.53 65.97,151.27 67.19,151.27 67.32,151.14 67.32,150.97 67.19,150.84 67.07,150.84 66.94,150.71 66.94,150.48 67.07,150.35 67.95,150.35 68.31,149.99 68.34,149.97 68.62,149.89 69.82,149.38 70.01,149.3 70.31,149.1 71.4,148.15 72.33,146.61 72.48,146.38 72.58,146.23 72.58,146.23 72.63,146.13 73.19,144.78 73.19,144.64 73.11,144.56 72.96,144.56 72.88,144.48 72.88,144.26 72.96,144.18 73.21,144.18 73.29,144.1 73.29,143.93 73.11,143.75 73.11,142.53 73.24,141.84 73.24,141.39 73.33,140.59 73.33,140.32 73.33,140.32 73.33,140.08 73.33,139.96 73.33,139.11 73.3,138.63 73.12,137.73 73.1,137.63 73.09,137.58 72.83,136.74 v1(72.68,136.29) 72.7,135.87 72.7,135.07 72.6,134.97 72.6,132.78 71.64,131.82 71.64,131.1 72.04,130.69 v1(72.35,130.69)
  BOTTOM w0.102: v1(37.19,160.62) 37.31,159.62 37.31,158.91 U11.R7 ; U13.R7 70.64,142.44 71.35,142.44 v1(72.35,142.56) ; v1(49.06,160.62) 49.18,159.62 49.18,158.91 U12.R7 ; v1(72.35,130.69) 71.35,130.57 70.64,130.57 U16.R7
  BOTTOM w0.178: U43.D27 51.3,142 51.95,142.66 54.85,142.66 59.25,147.05 59.7,147.05 62.9,150.25 v1(62.95,151.48) 63.21,151.73 R480.2 64.01,151.84 64.79,152.62 R473.1
FBA_CMD5: length 101.3
  TOP w0.102: U12.R2 v1(52.08,158.59) ; U16.R2 v1(70.32,127.67) ; U11.R2 v1(40.2,158.6) ; U13.R2 69.93,139.13 v1(69.54,138.74)
  IN1 w0.14: v1(44.71,158.62) 45.28,158.62 45.68,158.23 49.77,158.23 50.43,158.15 50.63,158.1 51.59,158.1 v1(52.08,158.59) ; v1(69.54,138.74) 69.67,138.61 69.83,138.61 69.99,138.76 69.99,139.46 70.1,139.57 70.25,139.57 70.36,139.46 70.36,138.77 70.49,138.64 70.67,138.64 70.77,138.54 70.77,138.39 70.67,138.29 70.09,138.29 69.97,138.16 69.97,137.56 70.09,137.44 70.42,137.44 70.54,137.31 70.54,137.16 70.19,136.81 70.19,135.04 v1(70.11,134.97)
  IN3 w0.102: v1(40.2,158.6) 40.2,158.28 40.27,158.21 40.7,158.21 40.78,158.28 40.78,158.56 40.88,158.66 41.06,158.66 41.16,158.56 41.16,158.26 41.21,158.21 41.44,158.21 41.51,158.28 41.51,158.56 41.62,158.66 41.77,158.66 41.87,158.56 41.87,158.28 41.95,158.21 42.18,158.21 42.25,158.28 42.25,158.56 42.33,158.64 42.5,158.64 42.61,158.54 42.61,157.97 42.76,157.82 43.29,157.82 43.63,158.16 44.47,158.16 44.66,158.35 44.66,158.57 v1(44.71,158.62) 45.25,158.62 45.86,158.85 49.87,159.86 50.88,160.04 51.08,160.12 51.3,160.19 52.31,160.19 52.54,160 53.6,158.64 53.74,158.59 54.94,158.59 55.56,157.97 56.59,155.89 56.95,155.3 58.14,153.15 58.28,152.27 60.17,149.58 60.31,149.41 v1(62.16,148.62) 62.54,148.5 63.27,148.48 63.37,148.57 63.38,148.75 63.48,148.85 63.63,148.84 63.73,148.73 63.73,148.56 63.83,148.46 64.87,148.43 66.23,147.92 66.32,147.88 67.13,147.45 69.71,145.94 69.76,145.69 69.78,145.58 69.37,144.73 69.43,144.54 69.56,144.48 70.24,144.7 70.38,144.63 70.42,144.48 70.36,144.36 69.67,144.14 69.61,144.01 69.65,143.87 69.78,143.8 70.28,143.96 70.4,143.9 70.45,143.76 70.38,143.62 69.89,143.46 69.83,143.33 69.87,143.19 70,143.12 70.29,143.22 70.41,143.15 70.45,143.03 70.37,142.87 70.11,142.79 70.05,142.66 70.42,141.51 70.42,140.22 70.5,139.99 70.74,139.44 71.01,138.88 71.07,138.61 71.08,138.59 71.1,138.47 71.15,138.24 71.15,138.03 71.1,137.63 71.06,137.52 70.88,137.21 70.71,136.83 70.26,135.75 70.26,135.63 v1(70.11,134.97) 70.11,134.33 69.78,134 69.78,129.73 69.71,129.17 69.59,128.73 69.63,128.36 v1(70.32,127.67)
  BOTTOM w0.102: v1(69.54,138.74) 69.93,139.13 U13.R2 ; v1(52.08,158.59) U12.R2 ; U16.R2 69.93,127.28 v1(70.32,127.67) ; U11.R2 v1(40.2,158.6)
  BOTTOM w0.178: U43.D26 51.71,141.07 51.71,141.64 52.32,142.25 54.99,142.25 59.4,146.67 59.89,146.67 61.85,148.62 v1(62.16,148.62) 62.48,148.3 62.99,148.3 R490.1 R485.2
FBA_CMD6: length 155.6
  TOP w0.102: U16.N8 69.05,131.68 69.26,131.68 69.56,131.38 69.56,131.19 70.48,130.27 72.6,130.27 v1(73.6,130.47) ; v1(37.42,161.86) 37.61,160.87 37.61,158.75 36.69,157.82 36.5,157.82 36.2,157.53 36.2,157.32 U11.N8 ; U13.N8 69.05,143.55 69.26,143.55 69.56,143.25 69.56,143.06 70.48,142.14 72.6,142.14 v1(73.6,142.34) ; v1(49.29,161.86) 49.48,160.87 49.48,158.75 48.56,157.82 48.37,157.82 48.07,157.53 48.07,157.32 U12.N8
  IN1 w0.14: v1(63.13,161.64) 63.51,161.26 63.51,155.64 62.97,155.09 v1(62.97,153.97) ; v1(73.6,142.34) 73.6,142.3 74.07,141.83 74.07,141.47 73.82,141.22 73.82,136.76 73.92,136.67 73.92,136.48 73.8,136.37 v1(73.54,136.37) ; v1(43.82,162.3) 44.33,162.09 44.76,162.09 46.07,162.49 47.31,162.49 47.61,162.18 47.61,161.68 47.88,161.41 48.83,161.41 v1(49.29,161.86)
  IN3 w0.102: v1(73.6,130.47) 73.13,130.47 73.03,130.57 73.03,130.82 73.14,130.93 73.14,132.45 73.21,132.53 73.21,132.94 73.54,133.26 v1(73.54,136.37) 73.54,136.71 73.75,137.42 73.93,138.04 74.05,138.61 74.18,140.19 74.18,140.23 74.36,141.46 74.36,141.94 74.31,142.17 74.31,142.84 74.31,143.54 74.25,143.79 74.23,143.89 73.15,146.5 72.21,148.06 72,148.4 71.96,148.47 71.96,148.47 71.93,148.52 71.79,148.64 70.72,149.68 67.27,152.19 66.26,152.61 63.59,153.92 v1(62.97,153.97) 61.08,156.66 60.38,157.5 60.19,157.68 56.21,161.26 51.91,163.3 49.52,164.25 48.82,164.25 47.6,163.72 46.81,162.93 46.26,162.68 45.68,162.68 45.68,162.67 44.9,162.39 v1(43.82,162.3) 43.8,162.32 37.87,162.32 v1(37.42,161.86)
  BOTTOM w0.102: 50.89,141.68 50.63,141.42 50.63,141.37 50,140.73 50,140.26 U43.F25 ; U16.N8 69.05,131.68 69.26,131.68 69.56,131.38 69.56,131.19 70.48,130.27 72.6,130.27 v1(73.6,130.47) ; v1(73.6,142.34) 72.6,142.14 70.48,142.14 69.56,143.06 69.56,143.25 69.26,143.55 69.05,143.55 U13.N8 ; U11.N8 36.2,157.32 36.2,157.53 36.5,157.82 36.69,157.82 37.61,158.75 37.61,160.87 v1(37.42,161.86) ; v1(49.29,161.86) 49.48,160.87 49.48,158.75 48.56,157.82 48.37,157.82 48.07,157.53 48.07,157.32 U12.N8
  BOTTOM w0.178: R435.1 R436.2 62.51,163.93 63.4,163.05 63.4,161.9 v1(63.13,161.64) ; v1(62.97,153.97) 62.84,152.57 62.78,151.95 62.49,151.66 62.49,151.53 62.49,150.38 59.62,147.51 59.16,147.51 54.69,143.04 51.7,143.04 50.89,142.22 50.89,141.68
FBA_CMD7: length 141.8
  TOP w0.102: v1(50.76,160.44) 50.3,159.1 49.96,158.42 U12.N7 ; v1(38.89,160.44) 38.36,159.6 38.2,158.64 38.09,158.42 U11.N7 ; U16.N7 70.15,129.79 70.83,129.45 v1(72.17,128.99) ; U13.N7 70.15,141.66 70.37,141.55 71.33,141.39 71.46,141.39 v1(72.17,140.94) ; 51.77,141.52 v1(50.2,141.52)
  TOP w0.178: v1(62.04,150.67) 62.04,150.45 61.17,149.59 61.17,149.01 57.95,145.78 57.95,145.14 54.78,141.97 52.23,141.97 51.77,141.52
  IN1 w0.14: v1(63,161) 63,159.99 62.71,159.69 62.71,155.52 61.82,154.63 61.82,150.88 v1(62.04,150.67) ; v1(72.17,140.94) 72.04,140.81 72.04,140.62 72.45,140.22 72.45,139.21 72.2,138.95 72.2,137.22 71.85,136.38 71.85,136.15 71.66,135.96 71.66,135.54 71.99,135.2 71.99,134.9 v1(71.85,134.76) ; v1(50.76,160.44) 50.35,160.04 49.69,159.76 46.3,159.76 45.91,159.98 45.75,160.13 45.73,160.13 45.18,160.39 44.36,160.39 v1(44.33,160.42)
  IN3 w0.102: v1(38.89,160.44) 39.17,160.72 41.46,160.72 41.79,160.38 41.79,159.86 41.92,159.73 43.57,159.73 43.67,159.83 43.67,160.32 43.77,160.42 v1(44.33,160.42) 44.82,160.42 44.99,160.47 45.49,160.75 46.12,161.15 46.79,161.46 47.06,161.46 47.84,162.24 49.66,162.45 52.93,161.37 55.14,160.27 56.68,158.84 57.05,158.4 58.03,156 58.52,155.85 58.84,155.53 59.98,152.84 v1(62.04,150.67) 62.68,150.75 66.15,149.9 66.56,149.8 66.96,149.69 67.94,149.45 68.06,149.42 68.15,149.35 68.4,149.18 68.74,148.84 68.91,148.68 69.42,148.17 70.38,148.17 70.49,148.06 70.49,147.91 70.37,147.79 70.24,147.79 70.11,147.67 70.11,147.58 70.3,147.4 71.56,146.48 71.76,146.29 71.99,145.93 72.14,144.94 72.06,144.2 71.94,143.65 71.92,143.25 71.92,142.34 72.63,141.64 72.63,141.11 72.72,140.33 72.72,140.09 72.72,140.09 72.72,139.95 72.72,139.19 72.37,137.58 72.29,137.21 72.04,136.72 72.01,136.6 71.98,136.53 71.94,136.43 71.91,136.35 71.82,135.49 71.82,135.48 v1(71.85,134.76) 71.85,134.08 71,133.23 71,130.4 71.63,129.77 71.63,129.13 71.76,128.99 v1(72.17,128.99)
  BOTTOM w0.102: U12.N7 49.93,158.39 50.3,159.1 v1(50.76,160.44) ; U11.N7 38.06,158.39 38.21,158.67 38.36,159.6 v1(38.89,160.44) ; U43.F26 49.96,141.19 v1(50.2,141.52) ; U16.N7 70.12,129.82 70.83,129.45 v1(72.17,128.99) ; v1(72.17,140.94) 71.46,141.39 71.33,141.39 70.4,141.54 70.12,141.69 U13.N7
  BOTTOM w0.178: R443.1 R444.2 62.99,160.99 v1(63,161)
FBA_CMD8: length 157.3
  TOP w0.102: v1(74.28,130.55) 74.19,130.93 73.97,131.87 73.97,132.32 73.36,132.93 72.4,132.93 71.66,132.19 70.84,132.19 U16.T8 ; v1(73.65,141.65) 74.1,142.31 74.1,143.61 73.97,143.74 73.83,143.94 73,144.12 U13.T8 ; v1(50.02,138.65) 50.23,138.65 50.64,139.06 51.14,139.06 51.27,139.18 51.27,139.81 51.39,139.94 51.39,140.6 51.77,140.98 ; U11.T8 35.62,159.64 35.62,160.38 36.08,161.61 36.3,162.01 36.66,162.27 37.75,162.27 v1(38.1,161.92) ; U12.T8 47.51,160.57 47.51,161.36 47.58,162.04 47.84,162.3 49.41,162.3 v1(49.97,161.92)
  TOP w0.178: v1(76.81,136.52) 76.81,136.17 76.11,135.47 76.11,133.61 75.42,132.93 75.09,132.93 74.48,132.32 74.48,130.75 v1(74.28,130.55) ; 51.77,140.98 52.38,141.59 54.94,141.59 58.33,144.98 58.33,145.62 61.65,148.94 61.65,149.37 63.25,150.97 63.48,151.24 64.26,152.59 v1(65.96,156.8) 66.45,156.3 67.07,156.3 67.32,156.56 69.95,156.56 v1(70.19,156.32) 70.57,155.94 70.57,154.79 R39.1 69.99,154.1 R54.2
  IN3 w0.102: v1(44.76,165.24) 48.23,166.14 50.25,166.14 52.75,165.49 52.98,165.43 54.09,165.13 54.11,165.12 54.23,165.07 54.5,164.95 54.52,164.94 54.59,164.92 56.78,163.96 61.13,161.63 61.25,161.57 62.38,160.67 62.7,160.38 v1(65.96,156.8) 68.54,154.54 70.5,153.31 71.42,152.47 73.34,150.08 74.79,147.79 75.44,146.73 75.69,146.05 75.98,145.29 76.72,143.35 76.79,142.89 76.81,142.25 76.84,138.01 76.83,137.52 v1(76.81,136.52)
  BOTTOM w0.102: v1(50.02,138.65) 49.99,138.65 U43.F23 ; v1(73.65,141.65) 73.65,139.53 72.7,138.59 71.29,138.59 U41.T8 ; U39.T8 52.82,159.35 52.82,159.72 52.61,159.93 52.23,159.93 50.81,161.35 50.55,161.35 50.17,160.97 49.95,160.97 49.79,161.12 49.79,161.74 v1(49.97,161.92) ; v1(38.1,161.92) 38.51,161.5 40.32,161.5 40.81,161.01 40.81,160.29 40.75,160.01 40.7,159.95 40.62,159.77 U38.T8 ; U44.T8 71.42,127.28 71.66,127.52 71.66,128.04 72.02,128.41 72.59,128.41 72.9,128.72 72.9,129.06 73.75,129.9 74.04,129.9 74.28,130.15 v1(74.28,130.55)
  BOTTOM w0.178: v1(38.1,161.92) 39.55,162.71 41.17,163.59 42.47,164.77 v1(44.76,165.24) 46.07,164.83 49.19,163.84 49.55,163.48 v1(49.97,161.92) ; v1(73.65,141.65) 74.29,141.65 74.68,141.26 74.68,140.65 74.46,140.42 74.46,139.67 76.24,137.89 76.46,137.89 76.83,137.52 76.83,136.54 v1(76.81,136.52)
FBA_CMD9: length 101.1
  TOP w0.102: v1(68.69,140.41) 68.82,140.28 68.82,140.15 68.62,139.95 U13.N3 ; U12.N3 51.26,156.6 51.09,156.78 v1(50.82,156.78) ; 50.28,142.6 49.19,141.52 49.19,140.36 49.62,139.94 49.62,139.3 49.37,139.06 48.99,139.06 48.79,138.86 48.79,138.25 v1(48.38,137.84) ; U16.N3 68.51,128.08 68.68,128.25 68.68,128.53 v1(68.53,128.68) ; v1(39.3,156.96) 39.3,156.68 39.51,156.47 39.67,156.47 U11.N3
  TOP w0.178: v1(62.85,148.91) 63.26,149.32 R63.1 R58.2 ; 50.28,142.6 50.48,142.81 54.54,142.81 57.19,145.45 57.19,146.26 v1(59.37,148.45)
  IN1 w0.14: v1(50.82,156.78) 49.54,156.78 49.18,157.13 47.64,157.13 47.38,156.88 46.82,156.88 46.57,157.13 45.18,157.13 45.06,157.25 v1(44.48,157.25) ; v1(62.85,148.91) 62.7,149.06 61.6,149.06 60.99,148.45 v1(59.37,148.45) ; v1(68.69,140.41) 68.69,140.19 68.26,139.77 68.26,139.35 68.34,139.28 68.34,139.07 68.26,139 68.26,138.57 68.37,138.46 68.37,138.26 68.26,138.16 68.26,136.93 68.36,136.84 68.84,136.84 68.96,136.72 68.96,135.68 69.34,135.3 69.34,135.15 69.25,135.06 v1(68.95,135.06)
  IN3 w0.102: v1(68.53,128.68) 68.62,129.18 68.64,129.33 68.64,129.58 68.01,132.35 68.01,133.54 68.16,133.84 v1(68.95,135.06) 68.95,135.99 68.7,136.24 68.7,136.74 68.26,137.17 68.26,141.3 68.42,141.45 68.73,141.45 68.86,141.58 68.86,142.61 68.16,143.3 67.91,144.8 67.82,145.04 67.82,145.58 67.61,145.79 66.5,146.52 66.06,146.92 65.28,147.28 64.63,147.49 64.14,147.49 63.58,147.48 63.34,147.49 63.34,147.49 63.18,147.5 61.17,147.63 60.91,147.64 60.23,147.95 v1(59.37,148.45) 59.29,148.45 58.96,148.78 57.23,151.49 56.88,151.83 56.66,152.58 56.66,153.39 56.02,154.95 54.26,156.64 52.95,156.64 52.78,156.81 52.78,157.64 52.23,158.18 51.65,158.18 51.6,158.13 48.68,158.13 46,157.7 45.74,157.45 45.3,157.45 45.11,157.25 v1(44.48,157.25) 42.85,157.25 42.77,157.17 42.77,157.05 42.86,156.96 43.05,156.96 43.14,156.87 43.14,156.76 43.03,156.65 42.86,156.65 42.5,156.29 39.97,156.29 v1(39.3,156.96)
  BOTTOM w0.102: U43.G22 48.7,137.52 v1(48.38,137.84) ; v1(68.69,140.41) 68.82,140.28 68.82,140.15 68.62,139.95 U13.N3 ; v1(68.53,128.68) 68.68,128.53 68.68,128.25 68.51,128.08 U16.N3 ; U11.N3 39.67,156.47 39.5,156.47 39.3,156.68 v1(39.3,156.96) ; v1(50.82,156.78) 51.09,156.78 51.26,156.6 U12.N3
