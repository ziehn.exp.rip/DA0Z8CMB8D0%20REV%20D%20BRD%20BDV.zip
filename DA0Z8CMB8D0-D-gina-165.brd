# Allegro board DA0Z8CMB8D0-D-gina-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_A4: length 49.7
  IN2 w0.076: v1(117.48,110.31) 118.56,109.23 118.56,106.94 118.6,106.89 118.6,105.27 118.17,104.84 118.17,104.05 117.15,103.03 117.15,101.1 117.38,100.87 117.38,100.57
  IN2 w0.178: 117.38,100.57 117.38,97.8 117.47,97.71 117.47,96.62 117.64,96.45 117.64,96.27 117.49,96.13 117.49,95.9 117.65,95.74 117.88,95.74 118.04,95.89 118.37,95.89 118.5,95.76 118.5,95.22 118.63,95.09 118.92,95.09 119.53,94.48 119.53,94.12 120.36,93.28 120.73,93.28 122.87,91.14 122.87,89.77 124.06,88.58 124.82,88.58 125.18,88.22 125.18,84.83 126.09,83.92 126.09,81.35 126.38,81.06 126.65,81.06 126.98,80.73 126.98,79.71 126.6,79.33 126.32,79.33 125.98,79.68 125.75,79.68 125.6,79.52 125.6,79.3 126.09,78.8 126.09,76.03 126.22,75.9 127.95,75.9 128.08,76.03 128.08,76.21 127.9,76.39 126.86,76.39 126.68,76.56 v1(126.68,77.19)
  BOTTOM w0.102: v1(117.48,110.31) 117.73,110.56 U45.AR45
  BOTTOM w0.216: JDIM1.92 126.08,76.59 v1(126.68,77.19)
M_B_A5: length 47.8
  IN2 w0.076: 117.01,98.56 117.03,98.58 117.03,100.85 116.99,100.89 116.99,103.3 117.76,104.07 117.76,106.97 117.46,107.27 117.46,109.48 117.03,109.92 117.03,110.65 117.33,110.96 v1(117.48,110.96)
  IN2 w0.178: v1(126.47,80.52) 126.39,80.6 126.2,80.6 126.07,80.48 126.07,80.27 125.94,80.15 125.71,80.15 125.59,80.27 125.59,83.73 124.14,85.18 124.14,86.32 124.27,86.45 124.6,86.45 124.72,86.57 124.72,86.83 124.6,86.95 124.27,86.95 124.14,87.08 124.14,87.41 124.27,87.54 124.6,87.54 124.72,87.66 124.72,87.98 124.6,88.1 123.89,88.1 122.39,89.61 122.39,89.92 122.01,90.31 122.01,90.51 122.33,90.84 122.33,91.02 122.11,91.25 121.88,91.25 121.57,90.94 121.39,90.94 121.13,91.21 121.13,91.39 121.37,91.63 121.37,91.81 121.13,92.05 120.95,92.05 120.7,91.79 120.52,91.79 120.36,91.95 120.36,92.13 120.69,92.46 120.69,92.64 120.5,92.83 120.32,92.83 119.98,92.49 119.83,92.49 119.5,92.83 119.5,93.01 119.65,93.16 119.65,93.34 119.47,93.53 119.29,93.53 119.12,93.37 118.94,93.37 118.7,93.61 118.7,93.79 118.92,94 118.92,94.18 118.69,94.41 118.51,94.41 118.3,94.19 118.12,94.19 117.94,94.37 117.94,94.55 118.14,94.75 118.14,94.93 117.99,95.08 117.22,95.08 117.01,95.29 117.01,98.56
  BOTTOM w0.102: v1(117.48,110.96) 117.73,111.21 U45.AP45
  BOTTOM w0.216: JDIM1.91 125.78,81.21 v1(126.47,80.52)
M_B_A6: length 52.5
  IN2 w0.076: 116.65,99.6 116.8,99.76 116.8,103.62 117.48,104.3 117.48,106.84 v1(116.53,107.8)
  IN2 w0.178: 116.65,99.6 116.04,98.99 116.04,98.33 116.55,97.81 116.55,95.1 121.93,89.72 121.93,89.42 123.68,87.66 123.68,84.99 125.08,83.6 125.08,79.13 125.59,78.62 125.59,75.5 125.92,75.17 127.16,75.17 127.31,75.01 127.31,74.79 127.16,74.64 126.09,74.64 125.94,74.48 125.94,73.8 125.76,73.62 125.51,73.62 125.33,73.8 125.33,74.53 125.21,74.66 124.62,74.66 124.49,74.79 124.49,75.09 124.62,75.22 124.95,75.22 125.08,75.35 125.08,78.27 v1(124.63,78.72)
  BOTTOM w0.102: U45.AW46 116.83,108.1 v1(116.53,107.8)
  BOTTOM w0.216: JDIM1.90 125.48,77.86 v1(124.63,78.72)
M_B_A7: length 52.2
  IN2 w0.076: v1(116.53,106.45) 117.13,105.85 117.13,104.78 116.44,104.1 116.44,102.73 116.32,102.6 116.32,100.51 116.14,100.33
  IN2 w0.178: 116.14,100.33 115.15,99.34 115.15,98.05 115.64,97.56 115.64,93.14 119.78,89 119.78,88.75 120.76,87.77 120.76,87.37 122.13,86 122.13,84.93 123.49,83.58 123.49,80.16 123.96,79.69 123.96,76.51 122.21,74.76 122.21,73.92 121.9,73.62 119.69,73.62 119.57,73.49 119.57,73.06 119.69,72.93 122.36,72.93 122.89,73.47 122.89,74.46 124.57,76.13 124.57,77.13 v1(124.63,77.19)
  BOTTOM w0.102: U45.AY46 116.95,107.42 116.95,106.87 v1(116.53,106.45)
  BOTTOM w0.216: v1(124.63,77.19) 124.52,77.19 124.28,76.95 JDIM1.86
M_B_A8: length 51.1
  IN2 w0.076: 116.44,99.96 116.56,100.07 116.56,101.46 116.62,101.52 116.62,103.69 117.31,104.38 117.31,106.31 v1(116.52,107.1)
  IN2 w0.178: 116.44,99.96 115.6,99.12 115.6,98.26 116.1,97.76 116.1,94.91 116.22,94.78 116.22,94.51 116.15,94.43 116.15,94.26 116.35,94.06 116.53,94.06 116.68,94.21 116.79,94.21 121.35,89.65 121.35,89.48 121.14,89.26 120.96,89.26 116.69,93.52 116.51,93.52 116.3,93.31 116.3,93.13 120.82,88.6 121.57,88.6 121.73,88.45 121.73,87.66 121.83,87.56 123.1,87.56 123.22,87.44 123.22,87.11 123.1,86.98 122.39,86.98 122.26,86.85 122.26,86.6 122.39,86.47 122.54,86.47 122.67,86.34 122.67,85.91 122.79,85.79 123.1,85.79 123.22,85.66 123.22,84.69 124.57,83.35 124.57,83.09 124.39,82.91 124.11,82.91 123.95,82.75 123.95,81.37 124.07,81.24 124.45,81.24 124.58,81.37 v1(124.58,81.51)
  BOTTOM w0.102: v1(116.52,107.1) 116.17,107.45 U45.AY47
  BOTTOM w0.216: JDIM1.89 125.18,82.11 v1(124.58,81.51)
M_B_A9: length 53.5
  IN2 w0.076: v1(116.53,109.1) 116.42,109.2 116.11,109.2 115.91,109 115.91,103.16 115.55,102.8 115.55,102.02 115.33,101.8
  IN2 w0.178: v1(122.53,80.74) 122.53,80.58 122.4,80.45 121.87,80.45 121.43,80.89 121.43,81.01 121.55,81.14 121.93,81.14 122.06,81.26 122.06,81.49 121.93,81.62 121.42,81.62 121.29,81.75 121.29,82.05 121.42,82.18 121.93,82.18 122.06,82.31 122.06,82.48 121.88,82.66 121.88,83.19 121.75,83.32 121.42,83.32 121.29,83.19 121.29,83.12 121.17,82.99 120.96,82.99 120.76,83.19 120.76,84.33 119.85,85.24 119.85,85.4 120.2,85.76 120.2,85.94 120.02,86.11 119.85,86.11 119.38,85.65 119.2,85.65 119.01,85.83 119.01,86.01 119.32,86.33 119.32,86.51 119.11,86.72 118.93,86.72 118.6,86.39 118.45,86.39 118.25,86.6 118.25,86.78 118.5,87.03 118.5,87.21 118.29,87.42 118.11,87.42 117.87,87.18 117.69,87.18 117.32,87.55 117.32,87.73 117.5,87.91 117.5,88.08 117.31,88.27 117.13,88.27 116.95,88.1 116.77,88.1 116.58,88.29 116.58,88.47 116.99,88.87 116.99,89 116.74,89.25 116.56,89.25 116.15,88.85 116,88.85 115.7,89.14 115.7,89.32 116.13,89.75 116.13,89.93 115.94,90.13 115.76,90.13 115.34,89.71 115.13,89.71 114.88,89.96 114.88,90.14 115.13,90.39 115.13,90.57 114.92,90.79 114.74,90.79 114,90.05 113.66,90.05 113.41,90.3 113.41,90.48 113.54,90.61 113.75,90.61 113.9,90.76 113.9,90.99 113.78,91.12 113.17,91.12 113.04,91.25 113.04,91.58 113.17,91.7 113.65,91.7 113.88,91.93 113.88,92.16 113.75,92.29 113.17,92.29 113.04,92.41 113.04,99.5 115.33,101.8
  BOTTOM w0.102: v1(116.53,109.1) 116.68,109.1 U45.AU46
  BOTTOM w0.216: v1(122.53,80.74) 122.75,80.74 123.98,81.98 JDIM1.85
M_B_A10: length 56.9
  IN2 w0.076: v1(122.73,113.64) 122.26,113.17 122.26,109.58 122.41,109.43 122.41,102.83 121.93,102.35 121.93,102.19 121.81,102.07
  IN2 w0.178: v1(131.14,85.89) 131.35,86.1 131.35,88.99 129.98,90.36 129.98,92.47 122.27,100.17 122.09,100.17 121.93,100.01 121.93,99.83 128.66,93.1 128.66,92.92 128.48,92.74 128.3,92.74 123.08,97.96 121.37,99.67 121.37,100.52 121.52,100.67 121.67,100.67 121.83,100.83 121.83,101.05 121.67,101.2 121.52,101.2 121.37,101.36 121.37,101.63 121.81,102.07
  BOTTOM w0.102: v1(122.73,113.64) 122.9,113.81 U45.AK36
  BOTTOM w0.216: JDIM1.107 130.58,85.65 130.82,85.89 v1(131.14,85.89)
M_B_A11: length 53.4
  IN2 w0.076: 115.91,100.82 116.01,100.92 116.01,102.75 116.26,103.01 116.26,104.45 116.77,104.96 116.77,105.55 v1(116.53,105.8)
  IN2 w0.178: v1(122.58,78.97) 122.96,78.6 122.96,76.96 121.6,75.6 119.09,75.6 118.93,75.44 118.93,75.22 119.09,75.07 121.75,75.07 123.5,76.82 123.5,79.49 123.01,79.98 123.01,83.41 121.67,84.74 121.67,85.81 120.46,87.03 120.33,87.03 119.22,88.14 119.22,88.92 115.18,92.95 115.18,97.33 114.66,97.85 114.66,99.58 115.91,100.82
  BOTTOM w0.076: U45.AV47 115.81,108.45 115.81,106.52 v1(116.53,105.8)
  BOTTOM w0.216: v1(122.58,78.97) 122.91,78.97 123.68,78.2 JDIM1.84
M_B_A12: length 49.9
  IN2 w0.076: 115.66,101.41 115.78,101.53 115.78,102.78 116.09,103.08 116.09,104.86 v1(116.38,105.14)
  IN2 w0.178: v1(122.53,82.27) 122.53,83.2 121.75,83.98 121.34,83.98 121.22,84.11 121.22,84.54 120.91,84.85 120.91,85.05 121.22,85.35 121.22,85.61 120.27,86.55 120.16,86.55 118.53,88.18 118.53,88.35 118.73,88.55 118.73,88.73 118.51,88.95 118.33,88.95 117.97,88.58 117.79,88.58 117.52,88.84 117.52,89.02 117.86,89.36 117.86,89.55 117.62,89.78 117.44,89.78 117.24,89.58 117.06,89.58 116.83,89.81 116.83,89.99 117.07,90.23 117.07,90.41 116.88,90.61 116.7,90.61 116.49,90.41 116.31,90.41 115.91,90.81 115.91,90.99 116.09,91.17 116.09,91.35 115.82,91.61 115.64,91.61 115.27,91.25 114.44,91.25 114.33,91.35 114.33,91.88 114.41,91.96 114.89,91.96 115.02,92.08 115.02,92.41 114.89,92.54 114.7,92.54 114.58,92.67 114.58,97.22 114.45,97.34 114.18,97.34 114.05,97.22 114.05,92.97 113.93,92.85 113.62,92.85 113.5,92.97 113.5,99.25 115.66,101.41
  BOTTOM w0.076: U45.AU47 115.91,109.25 115.91,109.19 115.64,108.92 115.64,105.88 v1(116.38,105.14)
  BOTTOM w0.216: v1(122.53,82.27) 123.15,82.27 123.38,82.5 JDIM1.83
M_B_A13: length 58.4
  IN2 w0.076: 126.3,109.59 126.3,109 126.83,108.47
  IN2 w0.089: v1(124.63,113.55) 125.05,113.97 125.05,114.27 125.33,114.54 125.82,114.54 126.3,114.06 126.3,109.59
  IN2 w0.178: 126.83,108.47 128.23,107.07 128.23,106.59 128.76,106.06 128.76,100.44 130.06,99.15 131.93,99.15 139.28,91.8 139.28,87.36 139.15,87.23 138.85,87.23 138.72,87.36 138.72,89.69 138.55,89.85 138.32,89.85 138.16,89.69 138.16,87 138.52,86.65 138.52,84.46 137.37,83.32 137.37,79.82 136.13,78.57 135.76,78.57 135.59,78.74 135.59,80.69 v1(135.55,80.74)
  BOTTOM w0.102: U45.AK33 124.9,113.81 v1(124.63,113.55)
  BOTTOM w0.216: v1(135.55,80.74) 134.18,82.11 JDIM1.119
M_B_A14: length 54.9
  IN2 w0.076: 115.02,102.27 115.1,102.35 115.1,102.6 115.73,103.23 115.73,109.28 116.53,110.08 v1(116.53,110.36)
  IN2 w0.178: 115.02,102.27 112.58,99.83 112.58,90.49 113.47,89.6 114.6,89.6 119.63,84.57 119.87,84.57 120.3,84.13 120.3,82.99 120.84,82.46 120.84,80.83 121.93,79.74 121.93,77.68 121.57,77.33 121.57,77 121.32,76.74 120.2,76.74 120.07,76.87 120.07,77.15 119.92,77.3 119.64,77.3 119.49,77.15 119.49,76.91 119.33,76.74 119.1,76.74 118.93,76.91 118.93,78.19 118.78,78.34 118.53,78.34 118.37,78.19 118.37,76.82 118.2,76.65 118.2,76.35 118.42,76.13 121.47,76.13 122.44,77.1 v1(122.44,77.5)
  BOTTOM w0.102: U45.AR46 116.83,110.36 v1(116.53,110.36)
  BOTTOM w0.216: JDIM1.80 122.48,77.46 v1(122.44,77.5)
M_B_A15: length 53.7
  IN2 w0.076: 114.13,108.7 114.36,108.93 114.36,109.25 114.7,109.58 115.5,109.58 116.04,110.12 116.04,110.52 v1(116.53,111.01)
  IN2 w0.178: 114.13,108.7 113.61,108.18 113.61,104.64 109.64,100.66 109.64,93.91 108.57,92.85 108.57,89.47 108.7,89.34 109.05,89.34 109.18,89.47 109.18,92.47 109.31,92.59 109.64,92.59 109.76,92.47 109.76,88.5 115.63,82.64 115.96,82.64 116.19,82.41 116.19,79.99 116.82,79.36 118.51,79.36 v1(120.68,77.19)
  BOTTOM w0.102: U45.AP46 116.83,111.01 v1(116.53,111.01)
  BOTTOM w0.216: v1(120.68,77.19) 121.38,77.19 121.88,76.69 JDIM1.78
M_B_BS#0: length 57.3
  IN2 w0.076: v1(123.7,112.83) 123.31,112.44 123.31,109.93 123.55,109.69 123.55,106.36 123.15,105.95 123.15,101.33 123.35,101.13 123.35,100.64
  IN2 w0.178: 123.35,100.64 123.35,100.39 126.36,97.38 126.64,97.38 126.89,97.63 127.07,97.63 127.22,97.48 127.22,97.3 126.92,97 126.92,96.82 127.1,96.64 127.28,96.64 127.62,96.99 127.8,96.99 128,96.78 128,96.6 127.66,96.26 127.66,96.08 127.95,95.79 128.13,95.79 128.56,96.22 128.74,96.22 128.95,96.01 128.95,95.83 128.52,95.4 128.52,95.22 128.79,94.96 128.97,94.96 129.4,95.39 129.58,95.39 129.76,95.2 129.76,95.02 129.33,94.59 129.33,94.41 129.6,94.14 129.78,94.14 130.21,94.57 130.39,94.57 130.59,94.37 130.59,94.19 130.16,93.76 130.16,93.58 130.41,93.33 130.59,93.33 131.02,93.76 131.2,93.76 131.4,93.56 131.4,93.38 130.98,92.97 130.98,92.43 131.2,92.21 131.2,91.88 132.81,90.27 132.81,90.09 132.61,89.89 132.43,89.89 131.38,90.94 131.2,90.94 131.03,90.78 131.03,90.6 132.37,89.26 132.37,89.06 132.75,88.68 133.69,88.68 133.82,88.55 133.82,88.3 133.69,88.17 132.77,88.17 132.65,88.05 132.65,87.72 132.77,87.59 133.79,87.59 133.92,87.46 133.92,87.21 133.79,87.08 132.8,87.08 132.67,86.95 132.67,86.62 132.8,86.5 133.71,86.5 133.87,86.34 133.87,86.12 133.71,85.96 132.75,85.96 132.57,85.79 132.57,85.43 132.73,85.28 133,85.28 133.18,85.1 133.18,84.69 132.79,84.3 132.56,84.3 132.34,84.51 132.11,84.51 131.95,84.35 131.95,84.12 132.16,83.9 132.16,83.67 131.78,83.29 v1(131.78,82.27)
  BOTTOM w0.102: U45.AL35 124.03,113.16 v1(123.7,112.83)
  BOTTOM w0.216: JDIM1.109 131.18,82.66 131.57,82.27 v1(131.78,82.27)
M_B_BS#1: length 57.1
  IN2 w0.076: 122.84,100.77 122.84,106.46 123.25,106.87 123.25,109.61 123.15,109.71 123.15,111.94 v1(122.75,112.34)
  IN2 w0.178: 122.84,100.77 122.84,100.25 130.49,92.6 130.49,90.5 131.83,89.16 131.83,88.89 132.08,88.64 132.08,87.93 131.81,87.66 131.81,84.97 131.31,84.48 131.31,81.16 130.67,80.51 130.67,79.74 130.84,79.56 131.45,79.56 131.58,79.44 131.58,79.16 131.45,79.03 130.84,79.03 130.67,78.85 130.67,76.72 130.41,76.46 129.6,76.46 129.45,76.31 129.45,76.06 129.63,75.88 130.39,75.88 130.56,75.7 130.56,75.45 130.34,75.22 129.57,75.22 129.45,75.09 129.45,74.84 129.63,74.66 131,74.66 131.17,74.84 131.17,78.24 131.35,78.42 131.93,78.42 132.11,78.6 v1(132.11,78.69)
  BOTTOM w0.102: v1(122.75,112.34) 122.92,112.51 U45.AM36
  BOTTOM w0.216: JDIM1.108 130.88,77.46 v1(132.11,78.69)
M_B_BS#2: length 53.4
  IN2 w0.076: 114.88,103.6 115.11,103.6 115.39,103.88 115.39,105.43 114.18,106.64 114.18,108.32 v1(114.95,109.1)
  IN2 w0.178: 114.88,103.6 114.47,103.6 111.41,100.54 111.41,90 114.51,86.9 114.51,86.72 114.33,86.55 114.16,86.55 111.88,88.82 111.7,88.82 111.53,88.65 111.53,88.47 114.09,85.91 114.44,85.91 114.87,86.34 115.1,86.34 115.32,86.12 115.32,85.89 114.84,85.4 114.84,85.2 115.05,85 115.2,85 115.76,85.56 115.96,85.56 116.14,85.38 116.14,85.18 115.58,84.62 115.58,84.41 115.81,84.18 116.09,84.18 116.52,84.62 116.75,84.62 116.9,84.46 116.9,83.45 117.03,83.32 117.33,83.32 117.46,83.45 117.46,84.03 117.59,84.16 117.86,84.16 117.99,84.03 117.99,83.12 119.68,81.43 119.68,81.07 120.07,80.68 120.32,80.68 v1(120.38,80.74)
  BOTTOM w0.102: U45.AU49 115.1,109.1 v1(114.95,109.1)
  BOTTOM w0.216: JDIM1.79 122.18,82.78 121.5,82.1 121.5,81.86 v1(120.38,80.74)
M_B_CAS#: length 57.4
  IN2 w0.076: v1(124.66,112.25) 125.05,111.85 125.05,109.64 125.08,109.61 125.08,102.8
  IN2 w0.178: v1(133.38,82.27) 133.69,82.27 133.87,82.09 133.87,80.1 134.02,79.94 134.24,79.94 134.4,80.1 134.4,83.02 135.77,84.39 135.77,85.86 135.67,85.96 135.44,85.96 135.31,86.09 135.31,86.78 135.44,86.9 135.72,86.9 135.85,87.03 135.85,87.31 135.72,87.44 135.52,87.44 135.39,87.56 135.39,87.83 135.52,87.96 135.86,87.96 136.43,88.53 136.43,88.71 136.26,88.88 136.08,88.88 135.72,88.53 135.44,88.53 135.31,88.66 135.31,88.81 136.3,89.8 136.3,89.98 136.13,90.15 135.95,90.15 135.39,89.6 135.21,89.6 135.01,89.8 135.01,89.98 136.42,91.38 136.42,91.56 136.19,91.79 136.01,91.79 134.67,90.45 134.49,90.45 134.2,90.74 134.2,90.92 134.78,91.5 134.78,91.7 134.65,91.83 134.65,92.03 135.54,92.92 135.54,93.1 135.37,93.28 135.16,93.28 134.3,92.42 134.15,92.42 133.86,92.71 133.86,92.89 134.6,93.63 134.6,93.88 130.99,97.49 129.41,97.49 129.21,97.69 129.03,97.69 127.72,99.01 126.8,99.01 125.1,100.7 125.1,102.78 125.08,102.8
  BOTTOM w0.102: U45.AM33 124.92,112.51 v1(124.66,112.25)
  BOTTOM w0.216: JDIM1.115 132.98,82.44 133.15,82.27 v1(133.38,82.27)
M_B_CKE0: length 38.5
  IN2 w0.076: v1(114.95,107.1) 115.55,106.49 115.55,103.51 115.15,103.11 115.07,103.11
  IN2 w0.178: v1(120.38,82.27) 120.14,82.03 119.95,82.03 119.68,82.29 119.68,83.82 119.52,83.98 119.29,83.98 119.13,83.83 119.13,83.55 119.01,83.42 118.73,83.42 118.58,83.58 118.58,84.59 117.99,85.18 117.18,85.18 116.14,86.22 116.14,86.39 116.42,86.67 116.42,86.9 116.16,87.16 115.99,87.16 115.73,86.9 115.3,86.9 115.06,87.14 115.06,87.28 115.48,87.69 115.48,87.87 115.2,88.15 115.02,88.15 114.64,87.77 114.47,87.77 114.28,87.96 114.28,88.17 114.63,88.51 114.63,88.69 114.34,88.98 114.16,88.98 113.78,88.6 113.64,88.6 112,90.24 112,100.3 114.8,103.11 115.07,103.11
  BOTTOM w0.102: U45.AY49 115.3,107.45 v1(114.95,107.1)
  BOTTOM w0.216: v1(120.38,82.27) JDIM1.73
M_B_CKE1: length 40.4
  IN2 w0.178: v1(120.68,78.72) 119.85,79.55 119.85,80.05 117.16,82.74 116.75,82.74 116.21,83.27 115.88,83.27 110.83,88.33 110.83,101.03 114.32,104.52 v1(114.32,105.12)
  BOTTOM w0.089: U45.AU50 114.17,109.14 114.17,107.68 114.15,107.67 114.15,106.64 114.45,106.34 114.45,105.26 v1(114.32,105.12)
  BOTTOM w0.216: v1(120.68,78.72) 120.22,78.25 120.22,76.96 120.68,76.49 JDIM1.74
M_B_CLK0: length 47.2
  IN2 w0.076: v1(121.8,111.53) 121.57,111.76 121.46,111.76 121.38,111.67 121.38,109.99 122.07,109.31 122.07,102.92 120.87,101.73 120.87,99.38 122.66,97.59 122.68,97.59 122.7,97.58
  IN2 w0.102: v1(129.96,80.65) 130.36,81.06 130.44,81.06 130.77,81.39 130.77,83.87 130.48,84.16 129.91,84.16 129.78,84.29 129.78,84.57 129.88,84.67 130.18,84.67 130.52,85.01 130.52,85.93 130.29,86.17 129.91,86.17 129.8,86.28 129.8,86.47 130.01,86.67 130.54,86.67 130.79,86.93 130.79,87.33 130.54,87.59 129.89,87.59 129.75,87.72 129.75,87.97 129.9,88.12 130.34,88.12 130.69,88.48 130.69,88.87 130.45,89.11 129.84,89.11 129.75,89.2 129.75,89.78 128.84,90.7 128.84,90.84 129.42,91.42 129.42,91.84 129.07,92.19 128.64,92.19 128.23,91.78 128,91.78 127.49,92.29 127.49,92.78 122.7,97.58
  BOTTOM w0.102: U45.AN38 122.12,111.86 v1(121.8,111.53)
  BOTTOM w0.14: JDIM1.101 128.78,82.7 128.94,82.54 128.94,81.19 129.4,80.73 129.88,80.73 v1(129.96,80.65)
M_B_CLK0#: length 47.4
  IN2 w0.076: 122.55,97.43 122.54,97.44 122.54,97.48 120.71,99.31 120.71,101.8 121.9,102.99 121.9,109.24 121.21,109.93 121.21,111.74 121.4,111.92 121.54,111.92 v1(121.8,112.18)
  IN2 w0.102: 122.55,97.43 127.29,92.69 127.29,92.2 127.92,91.58 128.31,91.58 128.72,91.99 128.99,91.99 129.22,91.75 129.22,91.51 128.63,90.92 128.63,90.61 129.55,89.7 129.55,89.11 129.75,88.91 130.36,88.91 130.49,88.78 130.49,88.56 130.25,88.33 129.82,88.33 129.55,88.05 129.55,87.64 129.8,87.39 130.46,87.39 130.59,87.25 130.59,87.01 130.46,86.88 129.92,86.88 129.6,86.56 129.6,86.19 129.83,85.96 130.2,85.96 130.32,85.84 130.32,85.09 130.1,84.87 129.79,84.87 129.57,84.65 129.57,84.21 129.83,83.96 130.39,83.96 130.56,83.78 130.56,81.48 130.38,81.29 129.92,81.29 129.75,81.46 v1(129.75,81.57)
  BOTTOM w0.102: v1(121.8,112.18) 122.12,112.51 U45.AM38
  BOTTOM w0.14: v1(129.75,81.57) 129.85,81.57 129.96,81.47 129.96,81.26 129.73,81.04 129.47,81.04 129.21,81.3 129.21,82.55 129.38,82.72 JDIM1.103
M_B_CLK1: length 47.1
  IN2 w0.076: 122.08,97.17 122.07,97.18 122.04,97.18 121.79,97.42 121.1,97.42 120.39,98.13 120.39,102.51 120.66,102.78 120.66,109.31 120.92,109.57 120.92,112.37 120.63,112.66 120.63,112.9 120.96,113.23 121.51,113.23 121.8,112.94 v1(121.8,112.83)
  IN2 w0.102: v1(129.96,78.48) 129.96,78.29 129.65,77.99 129.49,77.99 129.15,77.65 128.96,77.65 128.74,77.87 128.74,78.06 129.37,78.69 129.37,79.49 129.14,79.71 129.14,83.78 128.89,84.03 128.89,85.53 129.04,85.68 129.04,89.22 127.54,90.72 127.54,91.2 126.78,91.97 126.78,92.47 122.08,97.17
  BOTTOM w0.102: U45.AL38 121.86,112.83 v1(121.8,112.83)
  BOTTOM w0.14: v1(129.96,78.48) 129.79,78.32 129.45,78.32 129.14,78.01 129.14,76.83 129.08,76.76 JDIM1.102
M_B_CLK1#: length 47.3
  IN2 w0.076: 121.95,97.01 121.93,97.04 121.93,97.05 121.73,97.25 121.03,97.25 120.23,98.06 120.23,102.58 120.49,102.85 120.49,109.38 120.76,109.64 120.76,112.3 120.47,112.59 120.47,112.97 120.89,113.39 121.71,113.39 v1(121.8,113.48)
  IN2 w0.102: v1(129.96,77.71) 129.88,77.78 129.57,77.78 129.23,77.44 128.87,77.44 128.53,77.78 128.53,78.14 129.17,78.77 129.17,79.4 128.94,79.63 128.94,83.69 128.69,83.95 128.69,85.62 128.84,85.77 128.84,89.14 127.34,90.64 127.34,91.12 126.57,91.88 126.57,92.39 121.95,97.01
  BOTTOM w0.102: U45.AK38 122.22,113.57 122.13,113.48 v1(121.8,113.48)
  BOTTOM w0.14: v1(129.96,77.71) 129.96,77.95 129.85,78.05 129.56,78.05 129.38,77.88 129.38,77.06 129.68,76.76 JDIM1.104
M_B_CS#0: length 45.7
  IN2 w0.076: 125.48,102.87 125.48,109.75 125.22,110.02 125.22,111.79 v1(125.61,112.18)
  IN2 w0.178: v1(133.28,77.19) 134.02,77.93 134.02,78.65 134.55,79.18 134.78,79.18 134.98,79.38 134.98,82.76 136.43,84.21 136.43,87.69 137.02,88.27 137.02,92.59 131.52,98.08 129.65,98.08 129.44,98.29 129.26,98.29 127.96,99.59 127.17,99.59 125.48,101.28 125.48,102.87
  BOTTOM w0.102: v1(125.61,112.18) 125.93,112.51 U45.AM32
  BOTTOM w0.216: v1(133.28,77.19) 132.68,76.59 JDIM1.114
M_B_CS#1: length 45.4
  IN2 w0.076: 126.83,107.55 125.87,108.52 125.87,109.75 126.03,109.91 126.03,113.04 v1(125.59,113.48)
  IN2 w0.178: 126.83,107.55 127.24,107.15 127.24,106.28 127.14,106.18 127.14,100.45 127.54,100.05 128.33,100.05 129.84,98.54 131.71,98.54 138.64,91.61 138.64,90.62 138.48,90.46 138.25,90.46 138.13,90.57 138.13,91.45 137.96,91.63 137.7,91.63 137.52,91.45 137.52,86.8 137.91,86.42 137.91,84.79 135.55,82.43 v1(135.55,82.26)
  BOTTOM w0.102: v1(125.59,113.48) 125.91,113.81 U45.AK32
  BOTTOM w0.216: v1(135.55,82.26) 135.03,82.26 134.78,82.51 JDIM1.121
M_B_DQ0: length 41.5
  IN3 w0.076: 127.06,98.03 127.06,99.58 125.89,100.75 125.89,103.48 v1(126.53,104.12)
  IN3 w0.089: v1(136.63,82.25) 136.28,82.25 136.15,82.12 136.15,80.71 135.85,80.4 135.85,79.06 135.74,78.95 135.58,78.95 135.47,79.06 135.47,79.41 135.31,79.56 134.97,79.56 134.86,79.67 134.86,79.83 134.97,79.94 135.36,79.94 135.47,80.05 135.47,80.21 135.36,80.32 135.14,80.32 135.01,80.45 135.01,82.53 135.09,82.61 135.2,82.61 135.31,82.72 135.31,82.88 135.2,82.99 135.09,82.99 135.01,83.07 135.01,83.31 133.1,85.21 133.1,85.43 133.37,85.69 133.37,85.85 133.26,85.96 133.1,85.96 132.77,85.63 132.69,85.63 132.59,85.73 132.59,86.77 127.71,91.65 127.71,97.37 127.06,98.03
  BOTTOM w0.076: v1(126.53,104.12) 125.74,104.91 125.74,107.09 126.05,107.41 U45.AY31
  BOTTOM w0.14: v1(136.63,82.25) 137.18,82.79 JDIM1.129
M_B_DQ1: length 42.8
  IN3 w0.076: v1(126.53,102.25) 127.03,101.74 127.03,100.44 127.64,99.83 127.64,98.28
  IN3 w0.089: 127.64,98.28 128.63,97.3 128.63,92.04 134.78,85.89 134.78,85.28 135.16,84.9 135.77,84.9 137.75,82.92 137.75,80.6 137.87,80.48 138.17,80.48 138.29,80.37 138.29,80.21 138.17,80.1 137.86,80.1 137.75,79.98 137.75,79.83 137.86,79.71 138.16,79.71 138.29,79.59 138.29,79.29 138.4,79.18 138.56,79.18 138.67,79.29 138.67,80.28 138.79,80.4 138.96,80.4 139.08,80.28 139.08,77.77 138.68,77.37 v1(138.68,77.19)
  BOTTOM w0.076: U45.AW31 126.05,107.89 125.85,107.69 125.57,107.16 125.57,103.21 v1(126.53,102.25)
  BOTTOM w0.14: v1(138.68,77.19) 138.25,77.19 138.08,77.02 JDIM1.132
M_B_DQ2: length 42.3
  IN3 w0.089: v1(127.76,101.71) 127.95,101.71 128.46,101.2 128.46,98.97 130.13,97.29 130.13,93.38 136.71,86.8 137.6,86.8 138.13,86.27 138.13,84.73 139.72,83.14 140.27,83.14 140.67,82.74 140.67,81.11 139.73,80.17 139.73,79.29 139.85,79.18 140,79.18 140.12,79.29 140.12,80.06 140.23,80.17 140.38,80.17 140.5,80.06 140.5,79.67 140.61,79.56 140.75,79.56 140.88,79.69 140.88,80.33 141,80.46 v1(141.08,80.46)
  BOTTOM w0.076: v1(127.76,101.71) 127.17,102.3 127.17,103.67 127.28,103.78 127.28,106.32 127.4,106.44 U45.AY29
  BOTTOM w0.14: v1(141.08,80.46) 141.08,80.46 141.55,80.93 141.55,82.41 141.38,82.58 JDIM1.143
M_B_DQ3: length 43.2
  IN3 w0.089: v1(141.09,82) 141.09,82.78 140.19,83.68 140.07,83.68 139.96,83.57 139.84,83.57 139.68,83.73 139.68,83.85 139.79,83.96 139.79,84.08 139.63,84.24 139.51,84.24 139.4,84.13 139.28,84.13 139.13,84.29 139.13,84.41 139.23,84.51 139.23,84.64 139.08,84.79 138.95,84.79 138.85,84.69 138.72,84.69 138.57,84.84 138.57,84.97 138.67,85.07 138.67,85.2 138.44,85.43 138.44,86.39 137.73,87.11 136.84,87.11 136.62,87.32 136.62,87.45 136.84,87.67 136.84,87.79 136.69,87.94 136.56,87.94 136.34,87.73 136.22,87.73 136.06,87.88 136.06,88 136.28,88.22 136.28,88.35 136.13,88.5 136,88.5 135.79,88.28 135.66,88.28 135.51,88.44 135.51,88.56 135.73,88.78 135.73,88.91 135.57,89.06 135.45,89.06 135.23,88.84 135.1,88.84 134.95,88.99 134.95,89.12 135.17,89.34 135.17,89.46 135.01,89.62 134.89,89.62 134.67,89.4 134.55,89.4 134.39,89.55 134.39,89.68 134.61,89.89 134.61,90.02 134.46,90.17 134.33,90.17 134.11,89.96 133.99,89.96 133.84,90.11 133.84,90.23 134.05,90.45 134.05,90.58 133.9,90.73 133.77,90.73 133.56,90.51 133.43,90.51 133.28,90.67 133.28,90.79 133.5,91.01 133.5,91.13 133.34,91.29 133.22,91.29 133,91.07 132.87,91.07 132.72,91.22 132.72,91.35 132.94,91.57 132.94,91.69 132.79,91.84 132.66,91.84 132.44,91.63 132.32,91.63 132.16,91.78 132.16,91.91 132.38,92.12 132.38,92.25 132.23,92.4 132.1,92.4 131.89,92.18 131.76,92.18 131.61,92.34 131.61,92.46 131.7,92.56 131.7,92.72 131.59,92.84 131.43,92.84 131.33,92.74 131.2,92.74 130.44,93.51 130.44,97.29 128.66,99.07 128.66,101.47 v1(127.76,102.36)
  BOTTOM w0.076: v1(127.76,102.36) 127.34,102.79 127.34,103.6 127.45,103.72 127.45,106.23 127.57,106.34 127.57,107.2 127.69,107.32 127.69,107.57 127.4,107.86 U45.AW29
  BOTTOM w0.14: v1(141.09,82) 140.78,82.3 JDIM1.141
M_B_DQ4: length 43.6
  IN3 w0.076: 127.47,98.18 127.47,99.73 126.87,100.33 126.87,101.28 v1(126.53,101.62)
  IN3 w0.089: v1(138.68,78.72) 138.08,78.11 137.68,78.11 137.45,77.89 136.8,77.89 136.69,78 136.69,78.16 136.8,78.27 137.11,78.27 137.22,78.38 137.22,78.54 137.11,78.65 136.72,78.65 136.61,78.76 136.61,78.92 136.72,79.03 136.91,79.03 137.44,79.55 137.44,82.77 135.62,84.59 135.01,84.59 134.44,85.16 134.44,85.8 128.32,91.91 128.32,97.32 127.47,98.18
  BOTTOM w0.076: U45.AV31 125.67,108.36 125.67,107.7 ; 125.67,107.7 125.59,107.56 125.58,107.56 125.41,107.21 125.41,102.75 v1(126.53,101.62) ; 125.67,107.7 125.66,107.7 125.67,107.7
  BOTTOM w0.14: JDIM1.130 137.48,77.52 v1(138.68,78.72)
M_B_DQ5: length 44.3
  IN3 w0.076: 127.26,98.1 127.26,99.65 126.07,100.85 126.07,103.04 v1(126.53,103.51)
  IN3 w0.089: 127.26,98.1 128.02,97.35 128.02,91.78 134.13,85.66 134.13,84.62 134.91,83.84 135.03,83.84 135.31,84.12 135.48,84.12 135.59,84.01 135.59,83.85 135.31,83.56 135.31,83.44 135.46,83.28 135.59,83.28 135.95,83.64 136.11,83.64 136.23,83.53 136.23,83.36 135.89,83.03 135.89,82.87 136,82.76 136.15,82.76 136.38,82.99 136.61,82.99 137.14,82.47 137.14,79.86 136.76,79.49 136.41,79.49 136.15,79.74 136.15,80.25 v1(136.62,80.72)
  BOTTOM w0.076: U45.AU31 126.81,109.4 127.02,109.19 127.02,108.95 127,108.94 127,108.56 127.02,108.54 127.02,108.35 127.01,108.34 126.94,108.2 126.94,107.99 127.02,107.84 127.02,107.71 126.97,107.6 126.94,107.55 126.94,107.11 127.05,107.01 127.05,106.6 126.93,106.48 126.93,103.91 v1(126.53,103.51)
  BOTTOM w0.14: JDIM1.131 137.78,81.88 v1(136.62,80.72)
M_B_DQ6: length 43.5
  IN3 w0.089: v1(127.76,101.08) 128.25,100.58 128.25,98.87 129.83,97.29 129.83,93.25 136.58,86.5 137.37,86.5 137.83,86.04 137.83,84.61 139.6,82.84 139.89,82.84 140.37,82.36 140.37,81.26 139.39,80.28 139.39,77.61 139.28,77.5 139.28,76.82 139.12,76.67 138.79,76.67 138.67,76.54 138.67,76.41 138.79,76.29 139.58,76.29 139.73,76.44 139.73,76.89 v1(139.89,77.05)
  BOTTOM w0.076: U45.AV29 127.29,108.4 127.16,108.27 127.11,108.16 127.11,108.03 127.12,108.01 127.16,107.93 127.16,107.93 127.18,107.87 127.18,107.67 127.11,107.51 127.11,107.18 127.21,107.08 127.21,106.49 127.11,106.38 127.11,103.84 127.01,103.74 127.01,101.83 v1(127.76,101.08)
  BOTTOM w0.14: v1(139.89,77.05) 139.96,77.12 140.35,77.12 140.48,77 JDIM1.140
M_B_DQ7: length 44.4
  IN3 w0.089: v1(139.88,78.33) 140.17,78.33 140.29,78.21 140.29,77.63 140.42,77.5 140.6,77.5 140.72,77.63 140.72,79.03 141.59,79.89 141.59,82.05 141.49,82.15 141.49,82.84 138.74,85.58 138.74,86.52 137.85,87.41 137.65,87.41 131.49,93.57 131.36,93.57 131.15,93.35 131.02,93.35 130.87,93.51 130.87,93.63 131.09,93.85 131.09,93.98 130.74,94.32 130.74,97.29 128.86,99.17 128.86,101.91 v1(127.76,103.01)
  BOTTOM w0.076: U45.AU29 127.29,109.16 127.59,108.87 127.59,108.63 127.57,108.61 127.57,108.34 127.86,108.05 127.86,107.26 127.73,107.13 127.73,106.26 127.62,106.15 127.62,103.15 v1(127.76,103.01)
  BOTTOM w0.14: JDIM1.142 141.08,77.38 140.95,77.5 140.5,77.5 140.34,77.66 140.34,78.21 140.22,78.33 v1(139.88,78.33)
M_B_DQ8: length 55.7
  IN1 w0.114: v1(128.13,104.19) 127.29,103.35 127.29,100.64 126.7,100.06 126.37,100.06 126.26,99.95 126.26,99.72 126.15,99.6 125.88,99.6 125.76,99.72 125.76,99.95 125.65,100.06 125.38,100.06 125.27,99.95 125.27,99.72 125.15,99.6 124.89,99.6 124.77,99.72 124.77,99.95 124.66,100.06 124.39,100.06 124.28,99.95 124.28,99.72 124.16,99.6 123.82,99.6 123.71,99.72 123.71,99.95 123.59,100.06 123.4,100.06 123.28,99.93 123.28,99.7 123.17,99.6 123.07,99.6 122.79,99.88 122.79,99.95 122.68,100.06 122.41,100.06 122.3,99.95 122.3,99.73 122.17,99.6 121.85,99.6 121.73,99.73 121.73,99.95 121.61,100.06 121.29,100.06 119.41,98.17 117.58,98.17 116.9,97.49 113.83,97.49 109.05,92.72 107.33,92.72 97.57,82.96 97.57,80.5 97.75,80.32 97.75,79.64 v1(97.29,79.18)
  BOTTOM w0.076: v1(128.13,104.19) 128.69,104.75 128.69,105.73 128.24,106.18 128.24,106.94 128.35,107.05 128.35,107.32 U45.AY27
  BOTTOM w0.14: v1(97.29,79.18) 97.88,78.59 JDIM1.6
M_B_DQ9: length 55.9
  IN1 w0.114: v1(128.13,104.84) 126.96,103.67 126.96,100.85 126.55,100.44 126.06,100.44 125.95,100.56 125.95,101.07 125.82,101.2 125.56,101.2 125.45,101.1 125.45,100.56 125.34,100.44 125.07,100.44 124.96,100.56 124.96,100.94 124.84,101.05 124.58,101.05 124.46,100.94 124.46,100.56 124.35,100.44 124.08,100.44 123.97,100.56 123.97,100.75 123.84,100.87 123.6,100.87 123.47,100.75 123.47,100.61 123.31,100.44 121.07,100.44 119.19,98.56 117.31,98.56 116.57,97.82 113.69,97.82 108.91,93.05 107.2,93.05 97.24,83.09 97.24,79.99 96.86,79.61 96.86,77.49 v1(97.28,77.06)
  BOTTOM w0.076: v1(128.13,104.84) 128.52,105.23 128.52,105.66 128.07,106.11 128.07,107 128.19,107.12 128.19,107.57 128.48,107.86 U45.AW27
  BOTTOM w0.14: v1(97.28,77.06) JDIM1.4
M_B_DQ10: length 55.6
  IN1 w0.114: v1(130.08,101.09) 130.33,101.09 130.51,100.9 130.51,99.55 129.55,98.59 129.55,98.46 129.65,98.36 129.65,97.98 129.48,97.81 129.3,97.81 129.11,97.99 128.95,97.99 128.76,97.8 128.76,97.64 128.95,97.46 128.95,97.28 128.78,97.11 128.6,97.11 128.41,97.29 128.25,97.29 128.06,97.1 128.06,96.94 128.25,96.76 128.25,96.58 128.08,96.41 127.9,96.41 127.71,96.59 127.55,96.59 127.36,96.4 127.36,96.24 127.55,96.06 127.55,95.88 127.36,95.69 127.16,95.69 126.98,95.87 126.83,95.87 126.66,95.7 126.66,95.54 126.85,95.36 126.85,95.18 126.67,95.01 126.47,95.01 126.29,95.19 126.15,95.19 125.87,94.9 122.49,94.9 122.38,95.02 122.38,95.31 122.25,95.44 122.01,95.44 121.88,95.31 121.88,95.02 121.77,94.9 121.5,94.9 121.39,95.02 121.39,95.24 121.19,95.44 121.02,95.44 120.89,95.31 120.89,95.02 120.78,94.9 120.51,94.9 120.4,95.02 120.4,95.31 120.27,95.44 120.03,95.44 119.9,95.31 119.9,95.02 119.79,94.9 119.52,94.9 119.41,95.02 119.41,95.31 119.28,95.44 119.04,95.44 118.91,95.31 118.91,95.02 118.8,94.9 114.96,94.9 110,89.94 108.22,89.94 101.03,82.75 101.03,81.7 100.86,81.53 v1(100.73,81.53)
  BOTTOM w0.076: U45.AY25 129.7,107.32 129.7,105.92 130.48,105.14 130.48,101.49 v1(130.08,101.09)
  BOTTOM w0.14: v1(100.73,81.53) 100.58,81.68 JDIM1.15
M_B_DQ11: length 56.8
  IN1 w0.114: v1(101.07,78.72) 101.07,78.83 100.94,78.95 100.62,78.95 100.49,78.83 100.49,78.55 100.36,78.42 100.07,78.42 99.95,78.55 99.95,81.8 100.37,82.23 100.37,83.02 107.94,90.6 109.72,90.6 114.69,95.56 117.99,95.56 118.54,96.12 120.22,96.12 120.53,96.43 120.82,96.43 120.93,96.31 120.93,96.21 121.05,96.1 121.54,96.1 121.66,96.21 121.66,96.31 121.77,96.43 122.04,96.43 122.15,96.31 122.15,96.21 122.26,96.1 122.53,96.1 122.65,96.21 122.65,96.31 122.76,96.43 123.03,96.43 123.14,96.31 123.14,96.28 123.33,96.1 123.52,96.1 123.64,96.21 123.64,96.31 123.75,96.43 124.02,96.43 124.35,96.1 124.51,96.1 124.63,96.21 124.63,96.31 124.74,96.43 125.01,96.43 125.12,96.31 125.12,96.21 125.24,96.1 125.5,96.1 125.62,96.21 125.62,96.31 125.73,96.43 126.07,96.43 v1(130.08,100.44)
  BOTTOM w0.076: v1(130.08,100.44) 130.67,101.03 130.67,105.19 129.87,105.99 129.87,107.07 130.12,107.32 130.12,107.51 130.08,107.61 130.07,107.62 130.05,107.67 130.05,107.88 U45.AW25
  BOTTOM w0.14: v1(101.07,78.72) 101.07,77.7 100.88,77.52 JDIM1.16
M_B_DQ12: length 57
  IN1 w0.114: v1(98.65,79.98) 97.9,80.74 97.9,82.82 107.47,92.39 109.19,92.39 113.96,97.16 117.26,97.16 117.86,97.77 119.54,97.77 120.99,99.22 121.51,99.22 121.63,99.11 121.63,98.87 121.76,98.74 122,98.74 122.12,98.87 122.12,99.07 122.25,99.2 122.36,99.2 122.62,98.94 122.62,98.84 122.75,98.71 122.99,98.71 123.12,98.84 123.12,99.11 123.23,99.22 123.5,99.22 123.88,98.84 123.95,98.84 124.08,98.97 124.08,99.09 124.21,99.22 124.42,99.22 124.55,99.09 124.55,98.92 124.67,98.79 124.97,98.79 125.1,98.92 125.1,99.11 125.21,99.22 125.48,99.22 125.59,99.11 125.59,98.96 125.71,98.84 125.97,98.84 126.09,98.96 126.09,99.11 126.2,99.22 126.58,99.22 128.19,100.83 128.19,102.88 128.99,103.69 128.99,104.63 v1(128.13,105.49)
  BOTTOM w0.076: U45.AV27 128.59,108.62 128.19,108.22 128.19,107.81 128.02,107.64 128.02,107.19 127.9,107.06 127.9,105.85 128.13,105.62 v1(128.13,105.49)
  BOTTOM w0.14: JDIM1.5 97.58,82.13 97.95,81.76 97.95,80.58 98.49,80.04 98.6,80.04 v1(98.65,79.98)
M_B_DQ13: length 57.5
  IN1 w0.114: v1(100.73,80.01) 101.01,80.01 101.36,80.35 101.36,82.61 108.35,89.61 110.13,89.61 115.1,94.57 121.62,94.57 121.74,94.46 121.74,94.31 121.85,94.19 122.12,94.19 122.23,94.31 122.23,94.46 122.35,94.57 122.61,94.57 122.73,94.46 122.73,94.36 122.89,94.19 123.11,94.19 123.22,94.31 123.22,94.46 123.34,94.57 123.6,94.57 123.72,94.46 123.72,94.31 123.83,94.19 124.05,94.19 124.16,94.31 124.16,94.46 124.28,94.57 124.55,94.57 124.93,94.19 125.09,94.19 125.2,94.31 125.2,94.46 125.32,94.57 125.54,94.57 125.92,94.19 126.08,94.19 126.19,94.31 126.19,94.46 126.31,94.57 126.71,94.57 129.98,97.85 129.98,98.38 130.77,99.17 130.77,103.65 v1(130.08,104.34)
  BOTTOM w0.076: v1(130.08,104.34) 129.37,105.04 129.37,107.55 129.45,107.71 129.45,107.84 129.37,107.99 129.37,108.2 129.4,108.25 129.44,108.34 129.45,108.35 129.45,109.19 129.24,109.4 U45.AU27
  BOTTOM w0.14: v1(100.73,80.01) 101.18,80.46 JDIM1.17
M_B_DQ14: length 56.9
  IN1 w0.114: v1(98.65,81.51) 98.65,81.23 98.59,81.16 98.33,81.16 98.23,81.26 98.23,82.68 107.61,92.06 109.32,92.06 114.1,96.83 117.46,96.83 118.02,97.39 119.69,97.39 120.66,98.36 120.84,98.36 120.96,98.24 120.96,97.82 121.09,97.7 121.29,97.7 121.42,97.82 121.42,98.24 121.55,98.36 121.78,98.36 121.9,98.24 121.9,97.82 122.03,97.7 122.26,97.7 122.39,97.82 122.39,97.93 122.51,98.05 122.77,98.05 122.89,97.93 122.89,97.82 123.02,97.7 123.22,97.7 123.35,97.82 123.35,98.24 123.48,98.36 123.75,98.36 124.16,97.95 124.16,97.82 124.29,97.7 124.42,97.7 124.55,97.82 124.55,98.24 124.67,98.36 124.95,98.36 125.05,98.26 125.05,97.8 125.15,97.7 125.36,97.7 125.48,97.82 125.48,98.24 125.61,98.36 126.19,98.36 128.52,100.69 128.52,102.75 129.37,103.6 129.37,105.27 129.52,105.42 129.77,105.42 130.08,105.11 v1(130.08,104.99)
  BOTTOM w0.076: U45.AV25 129.83,108.51 129.59,108.27 129.54,108.16 129.54,108.03 129.55,108.01 129.59,107.93 129.61,107.87 129.61,107.67 129.54,107.51 129.54,105.53 v1(130.08,104.99)
  BOTTOM w0.14: JDIM1.7 98.18,82.1 98.65,81.62 v1(98.65,81.51)
M_B_DQ15: length 58.3
  IN1 w0.114: v1(102.08,77.93) 101.82,77.93 101.53,78.22 101.53,79.05 101.1,79.49 100.49,79.49 100.28,79.7 100.28,81.67 100.7,82.09 100.7,82.89 108.08,90.27 109.86,90.27 114.82,95.23 118.12,95.23 118.66,95.77 122.68,95.77 122.8,95.65 122.8,95.35 122.91,95.23 123.18,95.23 123.29,95.35 123.29,95.65 123.41,95.77 123.67,95.77 123.79,95.65 123.79,95.35 123.9,95.23 124.17,95.23 124.28,95.35 124.28,95.65 124.4,95.77 124.66,95.77 124.78,95.65 124.78,95.35 124.89,95.23 125.16,95.23 125.27,95.35 125.27,95.65 125.39,95.77 125.92,95.77 129.94,99.79 v1(130.08,99.79)
  BOTTOM w0.076: v1(130.08,99.79) 130.08,99.79 130.84,100.54 130.84,105.25 130.04,106.05 130.04,107 130.15,107.11 130.29,107.25 130.29,107.55 130.27,107.6 130.21,107.71 130.21,109.01 U45.AU25
  BOTTOM w0.14: JDIM1.18 101.48,77.45 101.7,77.66 101.72,77.66 101.98,77.93 v1(102.08,77.93)
M_B_DQ16: length 47.9
  IN3 w0.076: 126.45,108.09 126.45,111.56 v1(127.07,112.18)
  IN3 w0.089: 126.45,108.09 129.26,105.27 129.26,99.38 131.54,97.1 131.54,95.35 131.78,95.11 131.78,94.98 131.63,94.84 131.63,94.67 131.75,94.56 131.91,94.56 132.06,94.71 132.18,94.71 132.34,94.55 132.34,94.43 132.14,94.23 132.14,94.07 132.26,93.95 132.42,93.95 132.62,94.15 132.74,94.15 138.17,88.72 138.17,88.29 138.28,88.18 138.4,88.18 138.49,88.27 138.62,88.27 138.76,88.13 138.76,88.01 138.67,87.92 138.67,87.79 138.8,87.66 138.93,87.66 139.02,87.75 139.14,87.75 139.28,87.61 139.28,87.49 139.19,87.4 139.19,87.27 139.32,87.14 139.45,87.14 139.54,87.23 139.66,87.23 139.8,87.09 139.8,86.97 139.71,86.88 139.71,86.75 139.84,86.62 139.97,86.62 140.06,86.71 140.18,86.71 140.32,86.57 140.32,86.45 140.23,86.36 140.23,86.23 140.36,86.1 140.49,86.1 140.58,86.19 140.7,86.19 140.84,86.05 140.84,85.92 140.75,85.83 140.75,85.71 140.97,85.49 140.97,84.76 142.64,83.08 142.64,80.06 142.53,79.94 142.36,79.94 142.25,80.06 142.25,80.58 142.12,80.7 v1(142.09,80.7)
  BOTTOM w0.102: U45.AM29 127.4,112.51 v1(127.07,112.18)
  BOTTOM w0.14: v1(142.09,80.7) 142.4,80.7 143.18,81.48 JDIM1.149
M_B_DQ17: length 49.3
  IN3 w0.076: 126.2,107.99 126.2,112.61 v1(127.07,113.48)
  IN3 w0.089: v1(142.09,82.23) 142.09,82.94 140.58,84.45 140.58,85.4 140.17,85.81 140.05,85.81 139.71,85.48 139.55,85.48 139.43,85.59 139.43,85.76 139.77,86.09 139.77,86.22 138.08,87.91 137.86,87.91 137.64,88.12 137.64,88.25 137.86,88.47 137.86,88.6 137.71,88.75 137.58,88.75 137.36,88.53 137.24,88.53 137.08,88.68 137.08,88.81 137.31,89.03 137.31,89.15 137.15,89.31 137.03,89.31 136.8,89.08 136.68,89.08 136.52,89.24 136.52,89.36 136.75,89.59 136.75,89.71 136.59,89.86 136.47,89.86 136.25,89.64 136.12,89.64 135.97,89.79 135.97,89.92 136.19,90.14 136.19,90.27 136.04,90.42 135.91,90.42 135.69,90.2 135.56,90.2 135.41,90.35 135.41,90.48 135.63,90.7 135.63,90.83 135.48,90.98 135.35,90.98 135.13,90.76 135.01,90.76 134.85,90.91 134.85,91.03 135.08,91.26 135.08,91.38 134.92,91.54 134.8,91.54 134.57,91.31 134.45,91.31 134.3,91.47 134.3,91.59 134.52,91.82 134.52,91.94 134.37,92.09 134.24,92.09 134.02,91.87 133.89,91.87 133.74,92.02 133.74,92.15 133.96,92.37 133.96,92.5 133.81,92.65 133.68,92.65 133.46,92.43 133.33,92.43 133.18,92.58 133.18,92.71 133.4,92.93 133.4,93.06 133.25,93.21 133.13,93.21 132.9,92.99 132.78,92.99 132.62,93.14 132.62,93.26 132.73,93.37 132.73,93.53 132.62,93.65 132.45,93.65 132.35,93.54 132.22,93.54 131.24,94.52 131.24,97.1 129.06,99.28 129.06,105.13 126.2,107.99
  BOTTOM w0.102: U45.AK29 127.4,113.81 v1(127.07,113.48)
  BOTTOM w0.14: v1(142.09,82.23) 142.58,82.72 JDIM1.147
M_B_DQ18: length 48.3
  IN3 w0.076: 128.71,109.84 128.58,109.97 128.58,110.98 128.48,111.08 128.48,112.36 v1(128.01,112.83)
  IN3 w0.089: 128.71,109.84 131.23,107.32 131.23,106.05 131.48,105.8 131.48,99.66 133.87,97.27 133.87,96.42 138.84,91.45 139.38,91.45 143.68,87.15 144.1,87.15 144.23,87.02 144.23,86.06 144.34,85.94 144.5,85.94 144.61,86.06 144.61,86.3 144.73,86.42 144.89,86.42 144.99,86.32 144.99,86.14 145.09,86.04 145.25,86.04 145.98,85.3 145.98,79.75 145.87,79.64 145.71,79.64 145.6,79.75 145.6,80.55 145.46,80.69 v1(145.19,80.69)
  BOTTOM w0.102: v1(128.01,112.83) 128.34,113.16 U45.AL28
  BOTTOM w0.14: JDIM1.159 146.18,82.57 146.23,82.51 146.23,81.57 145.36,80.69 v1(145.19,80.69)
M_B_DQ19: length 48.5
  IN3 w0.076: 129.37,109.48 129.37,113.04 v1(128.93,113.48)
  IN3 w0.089: 129.37,109.48 131.53,107.32 131.53,106.03 131.68,105.88 131.68,99.71 134.17,97.22 134.17,96.55 138.96,91.75 139.5,91.75 143.8,87.45 144.23,87.45 144.9,86.78 144.98,86.78 146.29,85.48 146.29,79.56 146.59,79.26 147.05,79.26 147.34,78.97 147.34,76.97 147.18,76.82 146.97,76.82 146.82,76.97 146.82,77.12 v1(146.94,77.23)
  BOTTOM w0.089: U45.AK28 128.61,113.81 128.93,113.49 v1(128.93,113.48)
  BOTTOM w0.14: v1(146.94,77.23) 146.8,77.23 146.48,76.91 JDIM1.160
M_B_DQ20: length 45.9
  IN3 w0.089: v1(141.68,78.72) 141.68,78.61 142.02,78.27 142.43,78.27 142.55,78.14 142.55,77.99 142.66,77.89 142.81,77.89 142.92,77.99 142.92,78.43 143.06,78.57 143.59,78.57 143.7,78.68 143.7,78.84 143.59,78.95 143.38,78.95 143.25,79.08 143.25,83.33 141.58,85.01 141.58,86.18 132.15,95.6 132.15,97.05 129.67,99.53 129.67,105.6 129.37,105.9 129.37,106.79 128.48,107.68 128.23,107.68 127.06,108.85 v1(127.06,110.23)
  BOTTOM w0.102: v1(127.06,110.23) 127.38,110.56 U45.AR29
  BOTTOM w0.14: v1(141.68,78.72) 142.88,77.52 JDIM1.148
M_B_DQ21: length 47.3
  IN3 w0.076: v1(127.06,111.53) 126.65,111.13 126.65,108.24
  IN3 w0.089: 126.65,108.24 129.47,105.43 129.47,99.46 131.85,97.08 131.85,95.47 141.27,86.05 141.27,84.88 142.95,83.2 142.95,79.5 142.63,79.18 141.58,79.18 141.28,78.88 141.28,76.8 141.49,76.59 141.97,76.59 142.1,76.72 142.1,77.07 141.97,77.2 141.69,77.2 v1(141.68,77.19)
  BOTTOM w0.102: v1(127.06,111.53) 127.38,111.86 U45.AN29
  BOTTOM w0.14: JDIM1.146 142.28,76.99 142.08,77.19 v1(141.68,77.19)
M_B_DQ22: length 45.7
  IN3 w0.089: v1(128.01,110.23) 128.01,109.93 130.87,107.07 130.87,105.8 131.02,105.65 131.02,99.3 133.33,96.99 133.33,96.09 138.79,90.63 138.91,90.63 139.06,90.78 139.18,90.78 139.34,90.63 139.34,90.5 139.19,90.36 139.19,90.23 139.35,90.08 139.47,90.08 139.62,90.22 139.74,90.22 139.9,90.07 139.9,89.94 139.75,89.8 139.75,89.67 139.9,89.52 140.03,89.52 140.17,89.67 140.3,89.67 140.45,89.51 140.45,89.39 140.31,89.24 140.31,89.12 140.46,88.96 140.59,88.96 140.73,89.11 140.86,89.11 141.01,88.95 141.01,88.83 140.86,88.68 140.86,88.56 141.02,88.41 141.14,88.41 141.29,88.55 141.41,88.55 141.57,88.4 141.57,88.27 141.42,88.13 141.42,88 141.58,87.85 141.7,87.85 141.85,87.99 141.97,87.99 142.12,87.84 142.12,87.71 141.98,87.57 141.98,87.44 142.13,87.29 142.26,87.29 142.4,87.44 142.53,87.44 142.68,87.28 142.68,87.16 142.54,87.01 142.54,86.89 143.38,86.04 143.38,85.15 143.77,84.76 143.77,84.55 143.88,84.44 144.04,84.44 144.15,84.55 144.15,84.86 144.27,84.97 144.42,84.97 144.53,84.86 144.53,84.25 144.65,84.13 144.8,84.13 144.92,84.25 144.92,84.78 145.03,84.9 145.19,84.9 145.3,84.78 145.3,83.94 145.19,83.83 144.8,83.83 144.69,83.72 144.69,83.56 144.8,83.45 145.19,83.45 145.3,83.34 145.3,83.18 145.19,83.07 144.95,83.07 144.84,82.96 144.84,82.76 144.92,82.69 145.07,82.69 145.17,82.58 v1(145.17,82.34)
  BOTTOM w0.102: U45.AR28 128.34,110.56 v1(128.01,110.23)
  BOTTOM w0.14: v1(145.17,82.34) 145.31,82.34 145.58,82.61 JDIM1.157
M_B_DQ23: length 46.7
  IN3 w0.076: 128.48,109.76 128.41,109.84 128.41,110.49 v1(128.01,110.88)
  IN3 w0.089: 128.48,109.76 131.05,107.2 131.05,105.93 131.28,105.7 131.28,99.37 133.64,97.01 133.64,96.22 138.71,91.14 139.25,91.14 143.11,87.28 143.11,86.74 144.27,85.58 144.61,85.58 144.76,85.73 145.11,85.73 145.62,85.23 145.62,81.32 145.4,81.11 145.01,81.11 144.79,80.89 144.79,79.76 145.79,78.76 v1(146.94,78.76)
  BOTTOM w0.102: U45.AP28 128.34,111.21 v1(128.01,110.88)
  BOTTOM w0.14: JDIM1.158 145.88,77.7 v1(146.94,78.76)
M_B_DQ24: length 59.7
  IN1 w0.076: 128.74,109.08 128.58,109.23 128.58,111.14 v1(128.98,111.53)
  IN1 w0.114: 128.74,109.08 129.78,108.04 129.78,106.56 131.48,104.87 131.48,98.71 130.74,97.98 130.74,96.94 126.82,93.01 115.21,93.01 110.62,88.43 108.84,88.43 102.88,82.46 102.88,78.55 103,78.42 103.26,78.42 103.39,78.55 103.39,78.83 103.51,78.95 103.75,78.95 103.88,78.83 v1(103.88,78.72)
  BOTTOM w0.102: U45.AN26 129.3,111.86 v1(128.98,111.53)
  BOTTOM w0.14: JDIM1.22 102.68,77.52 v1(103.88,78.72)
M_B_DQ25: length 58.5
  IN1 w0.114: v1(128.98,110.21) 128.98,109.34 130.01,108.31 130.01,106.69 131.71,104.99 131.71,98.58 131.04,97.91 131.04,96.7 127.01,92.67 115.33,92.67 110.76,88.1 108.98,88.1 103.23,82.35 103.23,79.95 103.85,79.33 104.71,79.33 104.83,79.21 104.83,78.93 104.71,78.8 104.5,78.8 104.38,78.67 104.38,78.39 104.5,78.26 104.69,78.26 104.83,78.11 104.83,77.88 104.15,77.19 v1(103.88,77.19)
  BOTTOM w0.102: U45.AR26 129.33,110.56 v1(128.98,110.21)
  BOTTOM w0.14: JDIM1.24 103.28,76.59 v1(103.88,77.19)
M_B_DQ26: length 58.1
  IN1 w0.114: v1(105.7,80.93) 105.83,80.81 105.95,80.81 106.08,80.93 106.08,81.34 105.95,81.47 105.85,81.47 105.72,81.59 105.72,81.75 105.85,81.87 105.95,81.87 106.08,82 106.08,83.38 109.53,86.83 111.31,86.83 115.88,91.4 119.08,91.4 119.47,91.02 119.59,91.02 119.7,91.13 119.7,91.28 119.82,91.4 120.03,91.4 120.15,91.28 120.15,91.13 120.26,91.02 120.48,91.02 120.59,91.13 120.59,91.28 120.7,91.4 120.87,91.4 120.98,91.28 120.98,91.13 121.1,91.02 121.36,91.02 121.48,91.13 121.48,91.27 121.61,91.4 122.34,91.4 122.48,91.26 122.48,91.15 122.61,91.02 122.91,91.02 123.03,91.13 123.03,91.28 123.14,91.4 123.33,91.4 123.45,91.28 123.45,91.13 123.56,91.02 123.88,91.02 123.99,91.13 123.99,91.28 124.11,91.4 124.32,91.4 124.44,91.28 124.44,91.13 124.55,91.02 124.76,91.02 124.88,91.14 124.88,91.28 125,91.4 125.21,91.4 125.33,91.28 125.33,91.17 125.45,91.04 125.66,91.04 125.77,91.15 125.77,91.31 125.86,91.4 126.05,91.4 126.16,91.28 126.16,91.22 126.29,91.09 126.86,91.09 126.99,91.22 126.99,91.28 127.1,91.4 127.54,91.4 132.32,96.18 132.32,98.05 132.97,98.7 132.97,105.28 132.42,105.83 131.84,105.83 131.44,106.23 131.44,108.7 v1(129.93,110.21)
  BOTTOM w0.102: v1(129.93,110.21) 129.97,110.21 U45.AR25
  BOTTOM w0.14: v1(105.7,80.93) 106.15,81.38 106.15,82.5 105.98,82.66 JDIM1.33
M_B_DQ27: length 59
  IN1 w0.114: v1(129.93,110.88) 130.39,110.42 130.39,110.09 131.67,108.81 131.67,107.19 133.18,105.67 133.18,98.59 132.71,98.12 132.71,96.11 127.21,90.6 119.16,90.6 119.05,90.72 119.05,90.92 118.92,91.04 118.73,91.04 118.63,90.94 118.63,90.74 118.5,90.61 118.4,90.61 118.2,90.81 118.2,90.94 118.07,91.07 117.67,91.07 117.56,90.95 117.56,90.72 117.45,90.6 117.18,90.6 117.06,90.72 117.06,90.85 116.85,91.07 116.68,91.07 116.57,90.95 116.57,90.72 116.46,90.6 115.56,90.6 111.45,86.5 109.66,86.5 106.41,83.24 106.41,80.63 105.67,79.89 v1(105.62,79.89)
  BOTTOM w0.102: v1(129.93,110.88) 130.25,111.21 U45.AP25
  BOTTOM w0.14: JDIM1.35 106.58,79.86 106.43,79.71 105.8,79.71 v1(105.62,79.89)
M_B_DQ28: length 61.1
  IN1 w0.114: v1(101.78,81.51) 102.21,81.94 102.21,82.28 102.22,82.29 102.22,82.74 108.57,89.09 110.35,89.09 115.3,94.04 116.11,94.04 116.22,93.93 116.22,93.79 116.34,93.67 116.56,93.67 116.72,93.83 116.72,93.91 116.84,94.04 117.24,94.04 117.37,93.91 117.37,93.86 117.49,93.74 117.61,93.74 117.73,93.86 117.73,93.94 117.83,94.04 118.03,94.04 118.13,93.94 118.13,93.79 118.24,93.67 118.41,93.67 118.55,93.81 118.55,93.95 118.64,94.04 119.08,94.04 119.19,93.93 119.19,93.79 119.31,93.67 119.57,93.67 119.69,93.79 119.69,93.93 119.8,94.04 120.07,94.04 120.18,93.93 120.18,93.79 120.3,93.67 120.57,93.67 120.68,93.79 120.68,93.93 120.79,94.04 121.06,94.04 121.18,93.93 121.18,93.79 121.29,93.67 126.54,93.67 130.29,97.41 130.29,98.23 131,98.94 131,104.66 129.63,106.03 128.86,106.03 127.51,107.38 127.51,113.03 v1(127.97,113.49)
  BOTTOM w0.089: U45.AK26 129.27,113.91 128.86,113.91 128.63,114.13 128.29,114.13 127.97,113.81 v1(127.97,113.49)
  BOTTOM w0.14: v1(101.78,81.51) 102.38,82.11 JDIM1.21
M_B_DQ29: length 60.7
  IN1 w0.076: 128.4,109.08 128.42,109.1 128.42,111.65 v1(128.95,112.18)
  IN1 w0.114: v1(101.78,79.98) 101.78,79.54 101.91,79.42 102.33,79.42 102.55,79.64 102.55,80.43 102.42,80.55 102.37,80.55 102.24,80.68 102.24,80.96 102.37,81.09 102.42,81.09 102.55,81.21 102.55,82.6 108.71,88.76 110.49,88.76 115.07,93.34 115.34,93.34 115.43,93.43 115.43,93.58 115.55,93.71 115.83,93.71 115.96,93.58 115.96,93.47 116.09,93.34 126.68,93.34 130.51,97.17 130.51,98.08 131.25,98.82 131.25,104.78 129.55,106.49 129.55,107.76 128.4,108.91 128.4,109.08
  BOTTOM w0.102: U45.AM26 129.28,112.51 v1(128.95,112.18)
  BOTTOM w0.14: JDIM1.23 102.98,82.14 102.66,81.83 102.66,80.87 v1(101.78,79.98)
M_B_DQ30: length 61.2
  IN1 w0.114: v1(129.83,113.43) 131.15,112.11 131.15,110.09 132.17,109.08 132.17,107.38 133.61,105.93 133.61,98.33 133.37,98.09 133.37,95.83 127.48,89.94 115.83,89.94 111.72,85.84 109.97,85.84 107.07,82.94 107.07,80.27 106.94,80.14 106.94,78.77 106.81,78.65 106.56,78.65 106.43,78.77 106.43,79.05 106.31,79.18 106.15,79.18 v1(105.68,78.72)
  BOTTOM w0.102: v1(129.83,113.43) 130.2,113.81 U45.AK25
  BOTTOM w0.14: v1(105.68,78.72) 106.88,77.52 JDIM1.36
M_B_DQ31: length 61.2
  IN1 w0.114: v1(105.68,77.19) 105.75,77.12 105.75,76.72 105.62,76.59 105.27,76.59 105.14,76.72 105.14,77.58 105.22,77.66 105.22,79.1 105.51,79.4 105.72,79.4 106.74,80.43 106.74,83.09 109.81,86.17 111.58,86.17 115.69,90.27 127.35,90.27 133.04,95.97 133.04,98.09 133.4,98.45 133.4,105.81 131.91,107.3 131.91,108.95 130.82,110.04 130.82,111.88 129.9,112.81 v1(129.83,112.81)
  BOTTOM w0.102: v1(129.83,112.81) 130.18,113.16 U45.AL25
  BOTTOM w0.14: JDIM1.34 106.28,77.05 106.14,77.19 v1(105.68,77.19)
M_B_DQ32: length 42.7
  IN3 w0.089: v1(132.12,102.21) 132.9,101.43 132.9,99.24 134.96,97.19 135.14,97.19 135.82,96.5 136.74,96.5 138.8,94.44 138.8,94.02 144.26,88.56 144.82,88.56 146.95,86.42 147.19,86.42 147.89,85.72 147.89,80.86 148.25,80.49 148.25,79.85 147.89,79.49 147.89,78.23 148,78.11 148.16,78.11 148.27,78.23 148.27,78.57 148.42,78.72 v1(148.95,78.72)
  BOTTOM w0.076: U45.AY23 131.18,107.19 131.19,107.18 131.19,105.7 131.38,105.52 131.38,102.95 v1(132.12,102.21)
  BOTTOM w0.14: v1(148.95,78.72) 148.88,78.65 148.88,78.57 148.34,78.04 148.34,77.66 147.89,77.2 147.89,76.9 147.68,76.69 JDIM1.164
M_B_DQ33: length 43.5
  IN3 w0.089: v1(146.78,80.74) 146.9,80.63 146.9,80.48 147.2,80.17 147.2,79.83 147.31,79.71 147.47,79.71 147.58,79.83 147.58,80.02 147.66,80.1 147.67,80.1 147.79,80.21 147.79,80.37 147.67,80.48 147.39,80.48 147.28,80.59 147.28,80.75 147.39,80.86 147.47,80.86 147.58,80.97 147.58,81.13 147.47,81.24 147.31,81.24 147.2,81.35 147.2,81.51 147.31,81.62 147.43,81.62 147.55,81.74 147.55,85.63 147.06,86.12 146.83,86.12 144.69,88.25 144.14,88.25 139.84,92.55 139.3,92.55 138.5,93.35 138.5,94.32 136.54,96.28 135.62,96.28 132.72,99.17 132.72,100.82 132.57,100.97 132.17,100.97 v1(132.12,100.93)
  BOTTOM w0.076: v1(132.12,100.93) 131.21,101.83 131.21,105.45 131.03,105.63 131.03,107.11 130.89,107.25 130.89,107.52 130.98,107.69 131.18,107.89 U45.AW23
  BOTTOM w0.14: JDIM1.165 147.98,82.46 147.81,82.29 147.81,81.31 147.24,80.74 v1(146.78,80.74)
M_B_DQ34: length 42.6
  IN3 w0.089: v1(152.18,82.27) 152.09,82.36 152.09,84.63 151.97,84.74 151.81,84.74 151.7,84.63 151.7,83.96 151.56,83.83 151.37,83.83 151.24,83.96 151.24,85.86 148.24,88.86 147.91,88.86 144.5,92.27 143.98,92.27 141.23,95.02 141.23,95.42 137.8,98.84 137.65,98.84 137.55,98.94 137.42,98.94 137.16,98.68 137,98.68 136.88,98.8 136.88,98.96 137.14,99.22 137.14,99.34 136.99,99.5 136.86,99.5 136.3,98.93 136.14,98.93 136.02,99.05 136.02,99.21 136.58,99.78 136.58,99.9 136.15,100.33 136.15,100.72 135.72,101.15 135.21,101.15 135.09,101.03 135.09,100.55 134.97,100.44 134.82,100.44 134.71,100.55 134.71,101.03 134.58,101.15 v1(134.25,101.15)
  BOTTOM w0.076: v1(134.25,101.15) 132.93,102.48 132.93,105.7 132.76,105.87 132.76,106.66 132.53,106.89 U45.AY21
  BOTTOM w0.14: JDIM1.177 151.58,82.55 151.86,82.27 v1(152.18,82.27)
