# Allegro board DA0Z8CMB8D0-D-gina-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_SUSACK#: length 76.8
  TOP w0.14: U32.2 141.99,65.73 142.53,65.19 142.53,64.35 143.27,63.6 143.89,63.6 145.18,62.32 v1(145.37,62.32)
  IN2 w0.114: v1(145.37,62.32) 146.29,63.23 149.79,63.23 150.54,63.98 150.54,64.88 150.81,65.15 150.81,66.45 152.92,68.56 152.92,70.91 153.63,71.63 153.63,72.79 153.29,73.13 153.29,75.57 152.99,75.87 152.99,79.49 153.26,79.75 153.26,85.85 149.6,89.51 149.6,95.96 147.82,97.74 146.15,97.74 145.62,98.26 143.74,98.26 143.47,98.54 143.47,99.3 143.72,99.55 143.72,101.2 144.35,101.83 144.35,104.68 145.25,105.57 145.25,110.47 145.75,110.98 146.52,110.98 146.9,111.36 147.03,111.36 148.93,113.26 148.93,113.52 149.44,114.03 150.45,114.03 150.94,113.55 v1(151.7,113.55)
  BOTTOM w0.14: R620.2 v1(151.7,113.55)
PCH_SUSCLK: length 25.6
  IN3 w0.089: v1(141.72,116.59) 141.72,116.54 142.07,116.19 142.71,116.19 143.09,115.81 143.84,115.81 144.41,115.23 144.41,114.63 144.81,114.24 144.81,111.6 144.4,111.19 144.4,110.24 143.98,109.83 143.98,105.25 144.17,105.06 144.17,103.55 145.69,102.03 145.69,101.01 145.9,100.8 146.56,100.8 147.38,99.98 147.93,99.98 148.75,99.16 148.75,97.62 v1(148.95,97.42)
  BOTTOM w0.102: v1(141.72,116.59) 141.54,116.42 U45.AE6
  BOTTOM w0.14: v1(148.95,97.42) 149.1,97.27 R689.1
PCH_SUSPWARN#: length 84.9
  TOP w0.14: R323.1 140.94,69.32 141.84,68.41 U32.128 141.84,67.02 142.46,66.4 142.66,66.4 143.63,65.44 143.63,64.55 145.19,62.99 145.65,62.99 146.41,62.23 147.58,62.23 149.06,63.71 150.59,63.71 v1(151.26,64.37)
  IN3 w0.089: v1(152.13,114.39) 152.99,114.39 155.23,112.15 155.23,110.08 155.95,109.36 155.95,107.85 155.53,107.43 155.3,107.43 153.07,105.19 153.07,102.51 153.49,102.09 153.49,101.35 153.96,100.88 153.96,100.11 154.39,99.68 154.39,99.42 156.04,97.77 156.24,97.77 156.65,97.37 156.65,96.68 162.13,91.2 162.13,88.51 163.23,87.42 163.94,86.7 163.94,85.05 165.85,83.15 165.85,77.81 165.43,77.39 165.43,75.49 160.05,70.11 157.67,70.11 157.1,69.54 157.1,68.86 156.53,68.29 153.46,68.29 151.64,66.47 151.64,64.75 v1(151.26,64.37)
  BOTTOM w0.14: v1(152.13,114.39) 151.98,114.54 151.47,114.54 151.44,114.56 R616.2
PCH_SUSPWRACK: length 26.3
  IN2 w0.114: v1(152.33,113.32) 152.33,112.86 153.88,111.31 153.88,108.7 151.98,106.79 149.31,106.79 148.4,105.88 v1(147.47,105.88)
  BOTTOM w0.076: 145.5,106.41 145.04,106.87 144.06,106.87 143.82,107.11 143.43,107.11 143.23,107.31 143.23,107.58 143.15,107.66 143.15,108.23 142.85,108.53 U45.AV4
  BOTTOM w0.127: 145.5,106.41 146.03,105.88 v1(147.47,105.88)
  BOTTOM w0.14: v1(152.33,113.32) 152.33,113.52 151.8,114.06 150.66,114.06 150.32,114.39 R616.1 150.22,114.66 R615.1 ; R650.1 148.87,104.63 147.62,105.88 v1(147.47,105.88)
PCH_VCC_1_1_21: length 8.3
  TOP w0.381: v1(134.96,118.98) 134.96,119.06 v1(135.44,119.54) 135.31,119.67 133.9,119.67 R145.2
  BOTTOM w0.229: 137.27,116.72 137.27,116.36 137.55,116.08 U45.AG13
  BOTTOM w0.381: 137.27,116.72 137.27,116.93 136.34,117.85 136.34,118.41 135.44,119.31 v1(135.44,119.54)
PCH_VDDEN: length 134.2
  TOP w0.14: v1(44.03,101.71) 43.65,102.09 R217.2
  IN2 w0.114: v1(142.53,130.57) 138.85,130.57 135.54,127.26 135.54,126.3 135.47,126.22 135.47,124.95 134.84,124.32 131.92,124.32 130.64,123.05 130.64,120.74 129.33,119.42 112.18,119.42 111.97,119.21 109.71,119.21 109.39,118.89 106.98,118.89 105.97,117.88 100.96,117.88 95.97,112.89 93.56,112.89 93.05,113.39 88.6,113.39 86.22,111.01 86.22,106 83.07,102.85 77.56,102.85 76.16,104.25 72.96,104.25 72.02,103.32 72.02,95.73 v1(72.17,95.59)
  IN3 w0.089: v1(44.03,101.71) 46.14,101.71 48.29,103.87 53.93,103.87 55.08,102.73 57.36,102.73 57.54,102.55 67.21,102.55 67.43,102.33 68.33,102.33 70.54,100.11 70.54,97.42 72.17,95.8 v1(72.17,95.59)
  BOTTOM w0.076: v1(142.53,130.57) 142.22,130.57 141.82,130.16 141.82,129.98 141.05,129.21 U45.C6
PCH_WIFI_SUSCLK#: length 111.6
  IN2 w0.114: v1(213.7,76.87) 213.57,77 213.57,77.68 212.81,78.44 212.81,81.64 207.13,87.32 203.16,87.32 199.37,91.11 194.54,91.11 193.89,90.46 167.6,90.46 163.32,86.18 163.32,85.24 162.89,84.81 162.89,82.11 163.32,81.68 163.32,78.64 163.03,78.34 160.16,78.34 v1(159.14,79.36)
  IN3 w0.089: v1(159.14,79.36) 159.03,79.47 159.03,82.34 158.78,82.58 158.78,85.95 156.33,88.4 156.33,90.07 154.16,92.25 153.02,92.25 151.73,93.54 150.48,93.54 148.53,95.49 v1(148.4,95.49)
  BOTTOM w0.14: CN12.50 221,84.96 221.24,84.72 221.24,80.17 221.09,80.02 218.3,80.02 216.56,78.28 215.65,78.28 214.62,77.25 214.08,77.25 v1(213.7,76.87) ; v1(148.4,95.49) 148.8,95.49 149.56,96.25 R689.2
PCI_PIRQA#: length 12.9
  TOP w0.14: R115.1 150.33,125.08 150.07,125.33 147.79,125.33 147.6,125.52 146.7,125.52 146.52,125.33 144.85,125.33 144.36,124.84 144.36,123.6 v1(144.53,123.43) 144.36,123.26 144.36,122.42 143.8,121.85 142.23,121.85 v1(141.73,121.36)
  BOTTOM w0.102: U45.U6 141.54,121.16 v1(141.73,121.36)
PCI_PIRQB#: length 8.8
  BOTTOM w0.076: U45.P4 143.19,121.75 143.59,121.75 143.69,121.65 145.12,121.65 145.24,121.76 147.52,121.76 147.67,121.92 150.11,121.92 150.11,121.91 150.88,121.91 R570.1
PCI_PIRQC#: length 20.9
  IN1 w0.114: v1(156.83,123.4) 156.14,123.4 154.48,125.07 153.06,125.07 152.78,124.78 150.41,124.78 149.99,124.36 148.97,124.36 148.08,123.47 147.29,123.47 147,123.17 143.87,123.17 v1(143.17,122.48)
  BOTTOM w0.102: v1(143.17,122.48) 142.87,122.78 U45.N4
  BOTTOM w0.14: R538.1 154.76,127.25 156.5,125.5 156.5,123.85 156.83,123.53 v1(156.83,123.4)
PCI_PIRQD#: length 6.8
  BOTTOM w0.076: U45.N2 144.47,122.56 145.04,122.56 145.39,122.91 146.96,122.91 147.27,123.21
  BOTTOM w0.14: 147.27,123.21 148.4,123.21 148.56,123.37 149.37,123.37 149.44,123.45 149.96,123.45 R551.1
PCI_PLTRST#: length 115.7
  TOP w0.14: v1(160.66,110.85) 160.69,110.83 U20.1 160.69,108.52 160.61,108.44 160.1,108.44 160.04,108.5 U20.2 160.04,109.78 159.85,109.97 159.06,109.97 v1(157.84,108.75) ; U27.1 132.05,63.47 131.76,63.18 131.43,63.18 131.24,63.37 R335.1 130.79,63.76 131.83,64.8 133.93,64.8 134.76,65.64 135.47,65.64 136.09,66.26 137.64,66.26 138.67,67.29 140.29,67.29 v1(140.42,67.17)
  IN1 w0.114: v1(157.84,108.75) 156.08,110.51 156.08,110.94 154.77,112.25 154.52,112.25 152.87,113.9 151.98,113.9 151.89,113.99 151.47,113.99 151.26,113.78 150.2,113.78 149.99,113.99 149.01,113.99 148.78,113.75 146.16,113.75 145.98,113.93 145.98,114.26 145.45,114.79 144.99,114.79 144.36,115.43 142.96,115.43 142.68,115.15 141.71,115.15 v1(141.22,115.64)
  IN3 w0.089: v1(156.17,66.65) 158.32,66.65 158.78,67.12 160.9,67.12 164.77,70.98 166.1,70.98 168.41,73.29 168.41,84.04 166.48,85.96 166.48,90.18 161.96,94.7 161.96,94.98 161.39,95.55 161.39,96.16 157.87,99.69 157.87,105.6 157.44,106.03 157.44,108.34 v1(157.84,108.75)
  BOTTOM w0.102: U45.AG7 140.89,115.31 v1(141.22,115.64)
  BOTTOM w0.14: v1(156.17,66.65) 156.17,67.45 153.91,69.71 153.02,69.71 152.62,70.11 147.54,70.11 144.6,67.17 v1(140.42,67.17)
PCI_PME#: length 2.5
  TOP w0.14: v1(143.17,116.48) 143.17,116.36 143.49,116.04 144.33,116.04 TP61.1
  BOTTOM w0.089: U45.AD4 142.87,116.78 v1(143.17,116.48)
PCIE_CLKREQ_WIGIG#: length 71.1
  TOP w0.14: v1(176.98,93.7) 180.18,93.7 181.06,92.82 190.56,92.82 193.1,95.36 199.22,95.36 199.6,94.98 202.52,94.98 202.78,94.73 206.36,94.73 206.6,94.48 Q22.4 206.97,93.71 207.22,93.46 R252.2
  IN1 w0.114: v1(158.56,121.07) 158.71,120.91 159.24,120.91 161.22,118.93 161.22,118.04 161.72,117.54 163.96,117.54 167.47,114.03 167.47,103.21 v1(176.98,93.7)
  BOTTOM w0.14: R572.1 158.32,121.66 158.56,121.42 v1(158.56,121.07)
PCIE_CLKREQ_WLAN#: length 76
  TOP w0.14: R250.2 201.76,93.84 Q21.4 200.76,94.5 200.52,94.74 199.48,94.74 199.09,95.12 193.2,95.12 190.39,92.31 v1(188.43,92.31) 180.73,92.31 179.92,93.13 v1(177.5,93.13)
  IN1 w0.114: v1(177.5,93.13) 177.5,94.22 167.73,104 167.73,114.08 164.05,117.76 161.84,117.76 161.45,118.14 161.45,119.03 158.7,121.78 156.98,121.78 155.79,122.97 155.79,123.45 154.39,124.85 153.15,124.85 152.87,124.57 150.53,124.57 149.84,123.89 v1(149.69,123.89)
  BOTTOM w0.14: v1(149.69,123.89) 149.14,123.89 R550.1
PCIE_IREF: length 5.2
  BOTTOM w0.203: R509.2 126.83,133.56 128.64,131.76 128.64,130.49 128.63,130.48 128.63,129.93 128.71,129.84 128.71,129.69 U45.B27
PCIE_LAN_WAKE#: length 123.4
  TOP w0.14: v1(141.73,114.69) 142.15,114.26 143.65,114.26 144.28,113.63 144.28,112.76 144.51,112.53 144.51,108.53 145.87,107.16 146.37,107.16 146.77,106.77 146.77,105.95 147.85,104.87 149.7,104.87 150.35,104.23 150.35,102.38 R228.1 150.68,101.75 150.68,101.15 v1(150.96,100.87) 150.96,100.69 150.46,100.2 R238.1 ; v1(203.06,88.4) 203.06,88.78 204.17,89.9 R267.2 203.17,89.9 198.58,89.9 R258.2 ; R309.1 213.32,70.85 213.06,70.6 208.86,70.6 206.21,73.25 206.21,76.56 v1(205.32,77.45)
  IN1 w0.114: v1(203.06,88.4) 200.64,88.4 198.64,86.39 191.17,86.39 190.54,85.77 184.54,85.77 181.3,89.01 177.38,89.01 171.92,94.47 156.93,94.47 154.34,97.06 154.34,97.38 152.87,98.85 152.87,99.48 151.47,100.87 v1(150.96,100.87)
  BOTTOM w0.102: v1(141.73,114.69) 142.19,114.23 U45.AJ5
  BOTTOM w0.14: v1(203.06,88.4) 206.33,88.4 208.35,86.38 208.35,83.99 204.91,80.55 204.91,77.86 v1(205.32,77.45)
PCIE_RCOMP: length 4.1
  BOTTOM w0.254: U45.A27 128.98,132.38 127.85,133.51 R510.1
PCIE_REQ_LAN#: length 13.5
  TOP w0.14: R306.2 209.47,71.35 210.25,72.13 R307.1 209.38,73.14 Q26.3 209.38,76.68 209.51,76.81 210.47,76.81 v1(211.74,78.08) 212.18,78.51 212.18,79.46 213.48,80.77 U24.36
PCIE_RX3+_LAN: length 102.4
  TOP w0.14: C330.2 207.59,80.98 207.45,80.83 204.89,80.83 202.19,83.52 v1(202.19,84.26) 201.51,84.26 197.39,88.38 196.3,88.38 195.6,89.07 195.6,89.48 195.77,89.65 v1(195.92,89.65)
  IN1 w0.102: v1(137.91,126.48) 137.75,126.48 137.68,126.55 137.68,127.42 137.47,127.62 137.47,127.97 137.83,128.33 140.85,128.33 140.98,128.2 141.89,128.2 142.53,128.84 143.11,128.84 145.86,126.09 146.68,126.09 147.9,127.31 150.07,127.31 151.11,126.27 152.15,126.27 152.43,126.55 156.13,126.55 169.05,113.64 169.05,106 179.64,95.4 179.64,94.08 184.91,88.81 195.27,88.81 195.58,89.11 195.58,89.49 195.73,89.65 v1(195.92,89.65)
  BOTTOM w0.076: U45.F11 138.54,126.68 138.54,126.58 138.44,126.48 v1(137.91,126.48)
PCIE_RX3-_LAN: length 102.4
  TOP w0.14: v1(195.16,89.65) 195.33,89.47 195.33,88.96 196.19,88.11 197.28,88.11 201.3,84.09 v1(201.3,83.35) 201.99,83.35 204.77,80.57 207.4,80.57 C332.2
  IN1 w0.102: v1(195.16,89.65) 195.33,89.47 195.33,89.19 195.16,89.01 185,89.01 179.84,94.17 179.84,95.49 169.25,106.08 169.25,113.73 156.22,126.76 152.35,126.76 152.07,126.48 151.2,126.48 150.16,127.52 147.81,127.52 146.59,126.3 145.94,126.3 143.2,129.04 142.44,129.04 141.81,128.41 141.06,128.41 140.94,128.53 137.74,128.53 137.27,128.06 137.27,127.53 137.47,127.33 137.47,126.27 v1(137.91,125.84)
  BOTTOM w0.076: U45.G11 138.25,126.16 137.93,125.84 v1(137.91,125.84)
PCIE_RX4+_WLAN: length 124.6
  IN1 w0.102: v1(225.33,86.14) 225.13,85.94 224.09,85.94 221.52,88.5 221.52,89.57 219.77,91.32 210.31,91.32 209.65,90.66 205.86,90.66 205.25,91.27 199.8,91.27 199.06,90.53 194.67,90.53 193.96,89.82 185.17,89.82 180.83,94.17 180.83,95.49 169.96,106.36 169.96,114 156.37,127.59 151.15,127.59 150.41,128.33 147.35,128.33 146.77,127.75 145.48,127.75 143.37,129.85 141.68,129.85 141.05,129.22 137.41,129.22 136.41,128.21 136.41,127.06 v1(136.99,126.48)
  BOTTOM w0.076: v1(136.99,126.48) 137.31,126.16 U45.G13
  BOTTOM w0.14: CN12.41 226.88,82.71 226.75,82.84 226.4,82.84 224.48,84.76 224.48,85.62 224.8,85.94 225.13,85.94 v1(225.33,86.14)
PCIE_RX4-_WLAN: length 124.6
  IN1 w0.102: v1(136.99,127.11) 136.86,126.98 136.77,126.98 136.61,127.14 136.61,128.13 137.5,129.02 141.13,129.02 141.77,129.65 143.29,129.65 145.4,127.54 146.85,127.54 147.44,128.13 150.33,128.13 151.06,127.39 156.29,127.39 169.76,113.92 169.76,106.27 180.63,95.4 180.63,94.08 185.09,89.62 194.05,89.62 194.76,90.33 199.14,90.33 199.88,91.07 205.16,91.07 205.77,90.46 209.74,90.46 210.4,91.12 219.69,91.12 221.32,89.49 221.32,88.42 224,85.73 225.23,85.73 225.33,85.63 v1(225.33,85.38)
  BOTTOM w0.076: U45.F13 137.69,126.81 137.98,127.1 137.98,127.24 137.89,127.33 137.75,127.33 137.58,127.16 137.04,127.16 v1(136.99,127.11)
  BOTTOM w0.14: CN12.43 226.85,83.21 226.74,83.11 226.51,83.11 224.75,84.87 224.75,85.51 224.91,85.67 225.22,85.67 225.33,85.56 v1(225.33,85.38)
PCIE_RXN3_C: length 4.6
  TOP w0.14: C332.1 208.75,80.75 209.48,80.75 209.98,81.25 209.98,82.67 210.12,82.81 210.27,82.81 210.37,82.71 U24.31
PCIE_RXP3_C: length 4.7
  TOP w0.14: U24.30 210.4,83.21 210.27,83.08 210.01,83.08 209.71,82.78 209.71,81.36 209.37,81.02 208.75,81.02 C330.1
PCIE_TX3+: length 6.9
  BOTTOM w0.076: U45.B30 127.12,129.18 127.12,131.17 124.77,133.53 124.77,134.31 124.6,134.47 C626.1
PCIE_TX3+_LAN: length 117.5
  TOP w0.14: v1(193.63,93.99) 193.47,93.82 193.47,93.6 194.93,92.14 v1(195.64,92.14) 195.64,91.43 201.5,85.57 206.12,85.57 206.59,86.04 208.31,86.04 208.77,85.58 210.4,85.58 210.53,85.71 U24.25
  IN1 w0.102: v1(193.63,93.99) 193.46,93.81 193.46,93.48 193.16,93.19 191.33,93.19 190.79,92.65 186.72,92.65 183.87,95.5 183.87,96.82 183.86,96.83 183.86,96.88 178.34,102.4 178.34,104.8 173.06,110.08 173.06,115.39 156.94,131.51 147.43,131.51 146.08,132.85 144.68,132.85 143.8,133.73 136.53,133.73 135.58,132.78 126.65,132.78 124.55,134.88 124.55,135.67 v1(124.34,135.87)
  BOTTOM w0.076: v1(124.34,135.87) 124.16,135.7 C626.2
PCIE_TX3-: length 6.9
  BOTTOM w0.076: U45.C29 127.34,129.04 127.34,129.3 127.29,129.35 127.29,131.24 124.93,133.59 124.93,134.22 C627.1
PCIE_TX3-_LAN: length 117.5
  TOP w0.14: U24.26 210.5,85.21 210.4,85.32 208.66,85.32 208.2,85.77 206.7,85.77 206.23,85.3 201.39,85.3 195.4,91.3 v1(194.67,91.3) 194.67,92.02 193.2,93.49 193.2,93.79 v1(193,93.99)
  IN1 w0.102: v1(124.98,135.87) 124.85,135.87 124.75,135.77 124.75,134.96 126.73,132.98 135.49,132.98 136.44,133.93 143.89,133.93 144.76,133.05 146.17,133.05 147.51,131.71 157.03,131.71 173.26,115.47 173.26,110.17 178.55,104.89 178.55,102.48 183.93,97.09 183.94,97.09 184.06,96.97 184.06,96.91 184.07,96.9 184.07,95.59 186.81,92.85 190.71,92.85 191.25,93.39 193.07,93.39 193.25,93.57 193.25,93.84 193.1,93.99 v1(193,93.99)
  BOTTOM w0.076: v1(124.98,135.87) 125.18,135.67 C627.2
PCIE_TX4+: length 10.7
  BOTTOM w0.076: U45.A29 127.75,129.93 127.82,129.93 127.9,130.01 127.9,130.18 127.55,130.52 127.55,131.42 125.65,133.33 125.65,136.19 125.26,136.57 123.99,136.57 123.76,136.8 123.76,137.19 123.56,137.39 C612.1
PCIE_TX4+_WLAN: length 156.4
  IN3 w0.089: v1(123.28,138.79) 123.45,138.62 123.45,137.98 124.62,136.81 126.62,136.81 127.91,135.52 127.91,135.17 128.86,134.22 131.71,134.22 134.3,136.81 137.63,136.81 137.98,137.17 137.98,138.79 139.38,140.19 140.3,140.19 140.99,140.88 145.25,140.88 147.18,138.95 147.18,137.65 149.82,135.01 149.82,133.76 150,133.58 150,130.94 152.41,128.53 152.41,127.97 154.06,126.32 154.06,125.16 155.96,123.25 155.96,122.58 157.02,121.52 158.71,121.52 159.9,120.33 159.9,117.63 163.97,113.56 163.97,109.44 164.79,108.61 164.79,104.74 179.48,90.05 180.29,90.05 184.2,86.14 191.27,86.14 191.6,86.47 195.94,86.47 199.96,82.46 201.69,82.46 203.37,80.78 206.74,80.78 208.07,79.45 208.07,78.83 209.59,77.31 211.62,77.31 212.36,78.05 220.68,78.05 221.61,78.98 225.26,78.98 227.97,81.7 229.5,81.7 229.76,81.96 229.76,82.25 v1(229.91,82.41)
  BOTTOM w0.14: v1(123.28,138.79) 123.39,138.68 123.39,138.41 C612.2 ; v1(229.91,82.41) 229.75,82.24 229.75,81.97 228.99,81.21 CN12.35
PCIE_TX4-: length 10.7
  BOTTOM w0.076: U45.B29 127.6,129.48 127.88,129.76 128.06,129.94 128.06,130.25 127.72,130.59 127.72,131.49 125.82,133.4 125.82,136.25 125.33,136.74 124.05,136.74 123.92,136.87 123.92,137.15 C613.1
PCIE_TX4-_WLAN: length 156.4
  IN3 w0.089: v1(229.2,82.41) 229.37,82.41 229.56,82.22 229.56,82.04 229.41,81.9 227.89,81.9 225.17,79.18 221.52,79.18 220.6,78.25 212.28,78.25 211.54,77.52 209.67,77.52 208.27,78.92 208.27,79.54 206.82,80.98 203.45,80.98 201.78,82.66 200.04,82.66 196.03,86.67 191.52,86.67 191.19,86.34 184.29,86.34 180.37,90.26 179.56,90.26 164.99,104.82 164.99,108.7 164.17,109.52 164.17,113.65 160.11,117.71 160.11,120.41 158.79,121.73 157.11,121.73 156.17,122.67 156.17,123.33 154.26,125.24 154.26,126.4 152.61,128.05 152.61,128.61 150.2,131.02 150.2,133.66 150.02,133.84 150.02,135.09 147.38,137.74 147.38,139.03 145.33,141.08 140.91,141.08 140.22,140.4 139.29,140.4 137.78,138.88 137.78,137.25 137.54,137.02 134.21,137.02 131.62,134.43 128.95,134.43 128.12,135.26 128.12,135.6 126.7,137.02 124.71,137.02 123.66,138.07 123.66,138.62 123.83,138.79 v1(124.04,138.79)
  BOTTOM w0.14: C613.2 123.77,138.17 123.66,138.29 123.66,138.54 123.91,138.79 v1(124.04,138.79) ; CN12.37 228.47,81.71 228.7,81.48 228.88,81.48 229.48,82.08 229.48,82.25 229.32,82.41 v1(229.2,82.41)
PCIE_WAKE#_R: length 44.1
  TOP w0.14: v1(195.54,94.22) 196.05,94.73 196.56,94.73 R245.1 R246.1 198.33,94.48 198.58,94.73 199.05,94.73 199.46,94.32 Q21.6
  IN3 w0.089: v1(222.97,94.22) 222.54,94.65 220.23,94.65 219.6,94.03 212.13,94.03 211.43,94.73 196.05,94.73 v1(195.54,94.22)
  BOTTOM w0.14: v1(222.97,94.22) 222.97,93.71 225.97,90.71 225.97,86.63 226.39,86.21 CN12.55
PCIERST#: length 121.8
  TOP w0.14: v1(153.63,63) 153.63,62.98 153.14,63.46 149.16,63.46 147.68,61.99 146.31,61.99 145.56,62.74 145.1,62.74 143.8,64.04 143.47,64.04 v1(143.39,64.13) 143.39,65.34 142.57,66.15 142.37,66.15 140.47,68.06 v1(139.66,68.06) 138.79,68.06 137.44,66.71 135.91,66.71 135.29,66.09 134.3,66.09 134.27,66.12 133.92,66.12 133.89,66.15 133.51,66.15 133.35,65.99 U27.4
  IN2 w0.114: v1(211.57,78.98) 211.57,80.15 209.94,81.77 209.94,82.05 206.74,85.25 202.35,85.25 197.06,90.53 194.73,90.53 193.94,89.75 167.52,89.75 163.95,86.18 163.95,78.61 157.44,72.1 157.44,70.4 156.63,69.6 156.63,69.31 156.09,68.77 155.44,68.77 154.69,68.01 154.69,64.8 154.29,64.4 154.29,63.66 v1(153.63,63)
  BOTTOM w0.14: v1(211.57,78.98) 212.84,80.25 214.34,80.25 R706.2 215.49,79.1 216.26,79.1 217.26,80.1 R703.2 ; v1(143.39,64.13) 139.43,64.13 R732.2
PCLK_TPM: length 83.1
  TOP w0.14: v1(161.5,56.37) 161.88,56.37 162.51,56.99 162.51,68.1 158.16,72.44 157.11,72.44 156.16,73.4 156.16,75.41 155.52,76.04 154.63,76.04 152.99,77.68 152.99,82.36 150.91,84.44 v1(146.26,84.44) 142.2,84.44 141.19,85.44 141.19,86.44 137.97,89.66 137.97,94.61 141.16,97.8 141.67,97.8 142.26,98.39 142.26,99.88 C290.2 142.33,100.7 142.33,101.45 R224.1
  BOTTOM w0.14: U56.21 164.86,42.71 165.36,43.21 165.36,45.78 164.55,46.59 164.55,47.99 164.04,48.5 162.21,48.5 161.35,49.36 161.35,56.22 v1(161.5,56.37)
PD#: length 10.2
  TOP w0.14: U34.47 232.98,43.72 232.76,43.94 232.18,43.94 231.81,44.31 230.03,44.31 229.02,45.32 R397.2 228.69,46.13 D18.2 D17.2 228.1,49.72 v1(228.05,49.77)
PDN#: length 8.6
  BOTTOM w0.14: R700.1 R701.1 216.23,83.04 v1(216.24,83.04) 217.89,83.04 218.75,83.91 218.75,85.56 219.16,85.96 CN12.54
PEG_RX0: length 158.9
  TOP w0.14: C147.1 27.63,128.37 27.3,128.37 v1(27.03,128.63)
  IN1 w0.089: 137.75,124.67 137.78,124.67 137.79,124.66 138.1,124.66 138.3,124.86 138.3,127.3 138.54,127.54 138.73,127.54 v1(138.97,127.78)
  IN1 w0.102: 137.75,124.67 133.44,124.67 131.86,126.26 131.86,127.32 131.35,127.83 131.35,129.86 130.98,130.24 122.85,130.24 122.46,130.62 122.46,132.9 119.73,135.63 119.73,136.45 118.65,137.52 111.89,137.52 111.51,137.15 111.51,136.54 111.28,136.31 110.94,136.31 110.7,136.54 110.7,137.24 110.35,137.6 109.84,137.6 109.48,137.24 109.48,136.44 109.35,136.31 104.42,136.31 103.13,135.02 103.13,133.21 102.88,132.95 102.45,132.95 102.19,133.21 102.19,134.32 101.84,134.68 101.33,134.68 100.97,134.32 100.97,133.33 100.72,133.08 100.12,133.08 99.98,133.22 99.98,134.36 99.61,134.73 98.33,134.73 93.63,130.03 92.26,130.03 75.5,113.27 52.82,113.27 51.48,114.61 46.14,114.61 43.35,117.41 42.67,117.41 42.3,117.04 42.3,115.81 42.05,115.55 41.61,115.55 41.36,115.81 41.36,117.29 40.99,117.66 40.39,117.66 40.01,117.29 40.01,115.81 39.76,115.55 39.4,115.55 39.15,115.81 39.15,117.29 37.86,118.58 35.07,118.58 32.63,121.01 31.11,121.01 29.37,122.75 29.37,123.86 28.99,124.24 28.99,127.29 27.9,128.38 27.29,128.38 v1(27.03,128.63)
  BOTTOM w0.089: v1(138.97,127.78) 139.29,127.46 U45.E10
PEG_RX1: length 155.7
  TOP w0.14: C144.1 27.81,130.08 26.7,130.08 26.16,129.54 25.17,129.54 v1(24.98,129.35)
  IN1 w0.102: v1(24.98,129.35) 24.98,129.73 25.1,129.85 25.43,129.85 25.54,129.75 25.54,126.95 26.63,125.86 26.63,123.9 27.69,122.84 27.69,121.79 31.22,118.27 31.88,118.27 35.08,115.07 36.51,115.07 37.63,113.95 40.93,113.95 41.69,113.19 44.45,113.19 45.52,112.12 50.98,112.12 52.15,110.96 75.71,110.96 89.95,125.2 91.88,125.2 94.8,128.13 96.97,128.13 99,130.16 103.72,130.16 104.65,131.09 107.01,131.09 109.62,133.7 111.07,133.7 112.99,135.62 117.15,135.62 119.26,133.5 119.26,130.11 120.22,129.15 121.1,129.15 122.27,127.97 126.86,127.97 127.99,126.84 128.46,126.84 128.79,126.52 128.79,125.88 129.79,124.88 130.94,124.88 133.36,122.45 133.36,121.47 133.82,121.01 136.61,121.01 137.63,122.03 138.64,122.03 139.18,122.56 139.18,123.58 140.46,124.86 140.46,126.13 140.55,126.22 140.55,126.86 140.42,126.98 140.42,127.28 v1(139.92,127.78)
  BOTTOM w0.102: v1(139.92,127.78) 139.92,127.7 140.17,127.46 U45.E8
PEG_RX2: length 159.9
  TOP w0.14: v1(24.98,132.19) 25.21,132.42 25.82,132.42 v1(26.37,131.86) 26.93,132.42 27.63,132.42 C132.1
  IN1 w0.076: 139.02,124.44 138.38,123.8 137.79,123.8 137.77,123.78 137.75,123.78
  IN1 w0.089: 139.02,124.44 139.45,124.88 139.45,125.99 v1(138.93,126.52)
  IN1 w0.102: v1(24.98,132.19) 25.26,132.47 26.06,132.47 26.32,132.21 26.32,127.26 28.03,125.55 28.03,123.78 28.41,123.39 28.41,122.16 31.02,119.54 31.62,119.54 35.1,116.06 35.77,116.06 36.03,116.32 36.03,117.08 36.28,117.33 37.73,117.33 37.98,117.08 37.98,115.04 38.35,114.66 43.74,114.66 44.26,114.14 44.64,114.14 45.78,113 51.53,113 52.23,112.3 75.99,112.3 90.11,126.42 91.65,126.42 96.4,131.17 97.88,131.17 98.26,131.56 98.26,133.1 98.49,133.33 98.83,133.33 99.07,133.1 99.07,131.2 99.43,130.84 99.93,130.84 100.29,131.2 100.29,131.66 100.54,131.91 104.49,131.91 105.8,133.23 105.8,134.9 106.32,135.42 111.8,135.42 112.77,136.38 117.53,136.38 120.81,133.1 120.81,130.94 122.56,129.19 129.16,129.19 129.8,128.55 129.8,127.28 130.31,126.77 130.31,126.01 130.68,125.64 131.19,125.64 133.05,123.78 137.75,123.78
  BOTTOM w0.102: v1(138.93,126.52) 139.29,126.16 U45.G10
PEG_RX3: length 156.9
  TOP w0.14: C158.1 27.63,126.21 26.97,126.21 v1(26.5,126.68) 26.03,126.21 25.32,126.21 v1(25.1,126.43)
  IN1 w0.076: 139.29,122.05 139.31,122.06 139.33,122.06 139.53,122.26 139.53,123.55 140.8,124.82 141.06,124.82 141.25,125.02 141.25,127.09 141.1,127.24 140.98,127.24 v1(140.87,127.13)
  IN1 w0.102: 139.29,122.05 138.9,121.65 138.9,120.89 137.96,119.95 137.04,119.95 136.79,120.2 133.87,120.2 132.8,121.27 132.8,122.32 130.8,124.32 124.77,124.32 123.25,125.84 123.25,126.5 122.64,127.11 120.48,127.11 119.67,127.92 119.67,128.69 118.78,129.57 118.78,133.26 116.93,135.11 113.21,135.11 111.3,133.21 109.81,133.21 107.21,130.61 104.9,130.61 103.89,129.6 100.33,129.6 96.99,126.26 96.99,124.17 95.68,122.87 93.04,122.87 92.4,122.23 87.91,122.23 76.06,110.37 57.13,110.37 56.73,109.97 52.28,109.97 51.39,110.85 45.42,110.85 43.82,112.46 37.01,112.46 31.75,117.71 31.05,117.71 25.99,122.77 25.99,125.75 25.65,126.09 25.43,126.09 v1(25.1,126.43)
  BOTTOM w0.102: U45.F6 141.54,126.81 141.61,126.88 141.61,127.05 141.52,127.14 140.88,127.14 v1(140.87,127.13)
PEG_RX#0: length 158.9
  TOP w0.14: C153.1 27.63,128.1 27.26,128.1 v1(27.03,127.87)
  IN1 w0.089: v1(138.97,127.13) 138.73,127.37 138.62,127.37 138.48,127.22 138.48,124.79 138.17,124.48 137.79,124.48 137.78,124.47 137.75,124.47
  IN1 w0.102: v1(27.03,127.87) 27.34,128.18 27.81,128.18 28.79,127.2 28.79,124.16 29.17,123.78 29.17,122.67 31.02,120.81 32.55,120.81 34.98,118.37 37.78,118.37 38.95,117.2 38.95,115.72 39.32,115.35 39.85,115.35 40.22,115.72 40.22,117.2 40.47,117.46 40.9,117.46 41.16,117.2 41.16,115.72 41.53,115.35 42.13,115.35 42.5,115.72 42.5,116.95 42.76,117.2 43.27,117.2 46.06,114.41 51.39,114.41 52.74,113.06 75.58,113.06 92.34,129.82 93.71,129.82 98.42,134.53 99.53,134.53 99.78,134.27 99.78,133.13 100.03,132.88 100.8,132.88 101.18,133.25 101.18,134.24 101.42,134.48 101.75,134.48 101.99,134.24 101.99,133.12 102.36,132.75 102.96,132.75 103.34,133.12 103.34,134.93 104.5,136.1 109.43,136.1 109.69,136.36 109.69,137.16 109.92,137.4 110.26,137.4 110.5,137.16 110.5,136.46 110.86,136.1 111.36,136.1 111.72,136.46 111.72,137.07 111.97,137.32 118.56,137.32 119.53,136.36 119.53,135.54 122.26,132.81 122.26,130.54 122.77,130.03 130.9,130.03 131.15,129.78 131.15,127.75 131.66,127.24 131.66,126.17 133.36,124.47 137.75,124.47
  BOTTOM w0.076: v1(138.97,127.13) 139.29,126.81 U45.F10
PEG_RX#1: length 155.7
  TOP w0.14: C138.1 28,130.51 27.85,130.36 26.61,130.36 26.05,129.8 25.13,129.8 24.98,129.96 v1(24.98,130.62)
  IN1 w0.102: v1(24.98,130.62) 24.98,130.18 25.1,130.06 25.52,130.06 25.74,129.84 25.74,127.03 26.83,125.94 26.83,123.99 27.9,122.92 27.9,121.88 31.3,118.47 31.96,118.47 35.16,115.27 36.59,115.27 37.71,114.16 41.01,114.16 41.77,113.39 44.54,113.39 45.6,112.33 51.06,112.33 52.23,111.16 75.62,111.16 89.87,125.41 91.79,125.41 94.72,128.33 96.88,128.33 98.92,130.36 103.63,130.36 104.57,131.3 106.93,131.3 109.54,133.91 110.99,133.91 112.9,135.82 117.23,135.82 119.47,133.59 119.47,130.19 120.31,129.35 121.18,129.35 122.35,128.18 126.94,128.18 128.07,127.05 128.55,127.05 128.99,126.6 128.99,125.97 129.88,125.08 131.02,125.08 133.56,122.54 133.56,121.56 133.9,121.22 136.53,121.22 137.54,122.23 138.56,122.23 138.97,122.65 138.97,123.65 140.27,124.94 140.27,126.21 140.36,126.3 140.36,126.78 140,127.13 v1(139.92,127.13)
  BOTTOM w0.102: v1(139.92,127.13) 140.25,126.81 U45.F8
PEG_RX#2: length 159.9
  TOP w0.14: C128.1 28,132.83 27.86,132.69 26.84,132.69 v1(26.37,133.16) 25.9,132.69 25.24,132.69 v1(24.98,132.95)
  IN1 w0.076: 138.9,124.57 138.3,123.97 137.79,123.97 137.77,123.99 137.75,123.99
  IN1 w0.089: v1(138.93,125.87) 139.12,125.87 139.28,125.71 139.28,124.95 138.9,124.57
  IN1 w0.102: v1(24.98,132.95) 25.26,132.67 26.15,132.67 26.53,132.29 26.53,127.34 28.23,125.64 28.23,123.86 28.61,123.48 28.61,122.24 31.11,119.74 31.71,119.74 35.19,116.27 35.69,116.27 35.82,116.4 35.82,117.16 36.2,117.54 37.81,117.54 38.19,117.16 38.19,115.12 38.44,114.87 43.82,114.87 44.34,114.35 44.73,114.35 45.87,113.2 51.62,113.2 52.32,112.51 75.9,112.51 90.02,126.62 91.56,126.62 96.32,131.38 97.79,131.38 98.05,131.64 98.05,133.18 98.41,133.54 98.92,133.54 99.27,133.18 99.27,131.29 99.51,131.05 99.85,131.05 100.08,131.29 100.08,131.74 100.46,132.11 104.4,132.11 105.6,133.31 105.6,134.99 106.23,135.62 111.72,135.62 112.68,136.59 117.61,136.59 121.01,133.18 121.01,131.02 122.64,129.4 129.24,129.4 130.01,128.63 130.01,127.36 130.51,126.86 130.51,126.09 130.77,125.84 131.28,125.84 133.13,123.99 137.75,123.99
  BOTTOM w0.102: U45.H10 139.63,125.5 139.73,125.61 139.73,125.74 139.63,125.84 138.96,125.84 v1(138.93,125.87)
PEG_RX#3: length 156.9
  TOP w0.14: C164.1 27.63,125.94 27.03,125.94 v1(26.5,125.41) 25.97,125.94 25.38,125.94 v1(25.1,125.66)
  IN1 w0.076: v1(140.87,127.78) 140.87,127.7 141.41,127.16 141.41,124.95 141.12,124.66 140.87,124.66 139.7,123.49 139.7,122.19 139.44,121.94 139.44,121.91 139.44,121.9
  IN1 w0.102: 139.44,121.9 139.1,121.57 139.1,120.8 138.04,119.74 136.96,119.74 136.7,120 133.78,120 132.6,121.18 132.6,122.23 130.72,124.11 124.69,124.11 123.05,125.76 123.05,126.42 122.56,126.91 120.4,126.91 119.47,127.84 119.47,128.6 118.58,129.49 118.58,133.17 116.84,134.91 113.29,134.91 111.39,133 109.89,133 107.3,130.41 104.98,130.41 103.97,129.4 100.42,129.4 97.19,126.17 97.19,124.09 95.77,122.67 93.13,122.67 92.49,122.03 88,122.03 76.14,110.17 57.22,110.17 56.81,109.76 52.2,109.76 51.31,110.65 45.34,110.65 43.74,112.25 36.93,112.25 31.67,117.51 30.96,117.51 25.79,122.68 25.79,125.66 25.56,125.89 25.33,125.89 v1(25.1,125.66)
  BOTTOM w0.102: v1(140.87,127.78) 141.2,127.46 U45.E6
PEG_RXN0_C: length 9.4
  TOP w0.102: 34.71,126.67 34.86,126.67 34.88,126.65 35.52,126.65 35.54,126.67 35.55,126.67 v1(35.93,127.05)
  TOP w0.14: C153.2 29.04,127.47 29.04,127.38 30.71,125.71 31.84,125.71 32.09,125.46 32.93,125.46 34.14,126.67 34.71,126.67
  BOTTOM w0.102: v1(35.93,127.05) U43.AB9
PEG_RXN1_C: length 9.9
  TOP w0.102: 33.45,129.74 33.46,129.72 33.46,129.67 33.87,129.27 33.87,128.13 34.33,127.66 34.88,127.66 v1(35.09,127.87)
  TOP w0.14: 33.45,129.74 32.63,130.55 30.2,130.55 30.05,130.4 29.43,130.4 29.3,130.54 29.3,131.1 29.14,131.25 28.92,131.25 28.78,131.11 C138.2
  BOTTOM w0.102: v1(35.09,127.87) 35.09,127.85 U43.AC10
PEG_RXN2_C: length 9.1
  TOP w0.14: v1(35.09,128.69) 34.9,128.88 34.9,129.1 32.74,131.26 30.48,131.26 29.93,131.81 29.93,132.3 29.47,132.76 29.08,132.76 C128.2
  BOTTOM w0.102: v1(35.09,128.69) U43.AC11
PEG_RXN3_C: length 14.3
  TOP w0.14: C164.2 28.78,125.68 29.04,125.93 29.22,125.93 29.41,125.75 29.41,125.35 30.31,124.44 33.03,124.44 v1(33.54,123.94) 34.04,124.44 34.35,124.44 36.81,126.91 36.81,128.94 36.22,129.53 v1(35.93,129.53)
  BOTTOM w0.102: v1(35.93,129.53) U43.AB12
PEG_RXP0_C: length 9.4
  TOP w0.14: C147.2 29.22,128.74 29.32,128.64 29.32,127.48 30.82,125.98 31.95,125.98 32.2,125.73 32.82,125.73 34.03,126.94 34.97,126.94 v1(35.09,127.05)
  BOTTOM w0.102: v1(35.09,127.05) U43.AC9
PEG_RXP1_C: length 9.9
  TOP w0.102: 33.26,129.55 33.27,129.53 33.32,129.53 33.66,129.19 33.66,128.04 34.25,127.46 35.53,127.46 v1(35.93,127.85)
  TOP w0.14: 33.26,129.55 32.52,130.29 30.31,130.29 30.16,130.13 29.03,130.13 C144.2
  BOTTOM w0.102: v1(35.93,127.85) U43.AB10
PEG_RXP2_C: length 9.1
  TOP w0.14: C132.2 28.78,132.34 28.94,132.5 29.36,132.5 29.66,132.19 29.66,131.7 30.37,131 32.63,131 34.63,128.99 34.63,128.79 34.54,128.69 v1(34.29,128.69)
  BOTTOM w0.102: v1(34.29,128.69) U43.AD11
PEG_RXP3_C: length 14.3
  TOP w0.102: 36.23,129.12 35.5,129.12 v1(35.09,129.53)
  TOP w0.14: C158.2 29.17,126.2 29.33,126.2 29.68,125.86 29.68,125.46 30.43,124.71 33.04,124.71 v1(33.54,125.21) 34.03,124.71 34.24,124.71 36.55,127.02 36.55,128.83 36.26,129.12 36.23,129.12
  BOTTOM w0.102: v1(35.09,129.53) U43.AC12
PEG_TX0: length 126.8
  IN1 w0.102: v1(31.89,123.75) 31.7,123.75 31.61,123.66 31.61,123.28 32.34,122.54 33.31,122.54 34.5,121.35 37.73,121.35 39.25,119.82 43.91,119.82 47.46,116.27 53.86,116.27 55.03,115.1 70.32,115.1 70.57,115.35 70.57,116.66 70.94,117.03 71.47,117.03 71.84,116.66 71.84,115.41 72.08,115.17 72.41,115.17 72.65,115.41 72.65,116.65 73.03,117.03 73.63,117.03 74,116.65 74,115.35 74.25,115.1 74.91,115.1 97.62,137.8 107.17,137.8 108.8,139.43 120.39,139.43 122.09,137.73 125.43,137.73 128.53,134.63 131.39,134.63 131.83,135.07 131.83,135.37 131.62,135.58 v1(131.46,135.58)
  BOTTOM w0.102: v1(31.89,123.75) 31.64,124 31.64,124.21 31.97,124.55 32.15,124.55 32.3,124.39 U43.AG6
  BOTTOM w0.14: v1(131.46,135.58) 131.57,135.58 131.78,135.37 131.78,134.61 131.66,134.49 C632.1
PEG_TX1: length 123.1
  IN1 w0.102: v1(31.71,125.21) 31.45,125.21 31.35,125.1 31.35,124.76 31.67,124.44 32.47,124.44 34.63,122.28 38.19,122.28 39.76,120.71 45,120.71 47.79,117.92 54.27,117.92 56.41,115.78 63.91,115.78 66.04,117.92 76.21,117.92 97.75,139.46 102.57,139.46 103.03,139 107.27,139 108.39,140.12 123.63,140.12 124.93,138.82 126.09,138.82 v1(126.32,139.05)
  BOTTOM w0.102: v1(31.71,125.21) 31.46,125.21 31.37,125.3 31.37,125.44 31.54,125.61 32.28,125.61 32.72,125.17 32.72,124.72 32.83,124.62 33,124.62 33.1,124.72 U43.AF7
  BOTTOM w0.14: v1(126.32,139.05) 126.49,138.88 126.77,138.88 126.93,139.05 126.93,139.46 127.51,140.04 132.06,140.04 132.65,139.45 132.65,138.07 C615.1
PEG_TX2: length 131.6
  IN1 w0.102: v1(134.34,135.53) 134.15,135.34 134.15,134.9 132.96,133.71 127.43,133.71 125.87,135.28 125.87,135.92 124.97,136.81 121.07,136.81 119.34,138.54 109.34,138.54 107.71,136.92 104.15,136.92 103.23,136 102.24,136 101.58,135.34 97.98,135.34 93.44,130.8 91.9,130.8 75.3,114.21 53.85,114.21 52.83,115.22 46.61,115.22 43.43,118.4 38.99,118.4 37.9,119.49 35.06,119.49 32.9,121.65 31.84,121.65 29.98,123.5 29.98,124.61 29.7,124.89 29.7,126.66 31.12,128.08 31.92,128.08 32.17,127.82 32.99,127.82 33.28,127.53 33.28,127.26 v1(33.49,127.05)
  BOTTOM w0.102: v1(33.49,127.05) U43.AE9
  BOTTOM w0.14: C638.1 134.34,134.65 v1(134.34,135.53)
PEG_TX3: length 122.7
  IN1 w0.102: v1(135.04,138.69) 134.78,138.44 134.78,137.31 133.77,136.31 131.48,136.31 130.67,135.49 128.56,135.49 127.09,136.97 127.09,139 125.48,140.6 107.3,140.6 106.77,140.06 97.34,140.06 77.78,120.51 56.78,120.51 55.97,121.32 47.37,121.32 46.86,121.83 39.91,121.83 38.13,123.61 34.32,123.61 32.01,125.92 32.01,126.72 31.85,126.88 31.73,126.88 v1(31.45,126.6)
  BOTTOM w0.102: v1(31.45,126.6) 31.71,126.86 32.08,126.86 U43.AG9
  BOTTOM w0.14: C617.1 134.93,137.94 134.93,138.59 v1(135.04,138.69)
PEG_TX#0: length 126.8
  IN1 w0.102: v1(132.19,135.58) 132.04,135.43 132.04,134.98 131.48,134.43 128.45,134.43 125.35,137.52 122.01,137.52 120.3,139.23 108.88,139.23 107.26,137.6 97.71,137.6 75,114.89 74.17,114.89 73.8,115.27 73.8,116.57 73.54,116.82 73.11,116.82 72.86,116.57 72.86,115.33 72.5,114.97 71.99,114.97 71.64,115.33 71.64,116.57 71.38,116.82 71.03,116.82 70.77,116.57 70.77,115.27 70.4,114.89 54.94,114.89 53.77,116.06 47.38,116.06 43.82,119.62 39.17,119.62 37.64,121.14 34.42,121.14 33.22,122.34 32.26,122.34 31.4,123.19 31.4,123.55 v1(31.2,123.76)
  BOTTOM w0.102: v1(31.2,123.76) 31.43,123.99 31.43,124.3 31.89,124.75 32.09,124.75 U43.AG7
  BOTTOM w0.14: v1(132.19,135.58) 132.05,135.44 132.05,134.73 C633.2
PEG_TX#1: length 123.1
  IN1 w0.102: v1(126.32,138.43) 126.13,138.62 124.84,138.62 123.55,139.91 108.48,139.91 107.36,138.79 102.95,138.79 102.49,139.25 97.83,139.25 76.29,117.71 66.13,117.71 63.99,115.58 56.32,115.58 54.19,117.71 47.71,117.71 44.92,120.51 39.68,120.51 38.1,122.08 34.54,122.08 32.39,124.24 31.58,124.24 31.15,124.67 31.15,125 v1(30.95,125.21)
  BOTTOM w0.102: U43.AE7 33.55,125.31 32.88,125.31 32.37,125.82 31.45,125.82 31.17,125.53 31.17,125.43 v1(30.95,125.21)
  BOTTOM w0.14: v1(126.32,138.43) 126.51,138.62 126.88,138.62 127.2,138.93 127.2,139.35 127.62,139.77 131.95,139.77 132.38,139.34 132.38,138 C614.1
PEG_TX#2: length 131.6
  IN1 w0.102: v1(32.69,127.05) 32.95,127.05 33.08,127.19 33.08,127.44 32.9,127.62 32.09,127.62 31.84,127.87 31.2,127.87 29.9,126.58 29.9,124.98 30.18,124.7 30.18,123.59 31.92,121.85 32.99,121.85 35.15,119.69 37.98,119.69 39.07,118.6 43.52,118.6 46.69,115.43 52.92,115.43 53.93,114.41 75.22,114.41 91.81,131.01 93.35,131.01 97.89,135.54 101.5,135.54 102.16,136.2 103.15,136.2 104.06,137.12 107.63,137.12 109.25,138.74 119.42,138.74 121.15,137.02 125.05,137.02 126.07,136 126.07,135.37 127.52,133.92 132.88,133.92 133.94,134.98 133.94,135.37 133.78,135.53 v1(133.61,135.53)
  BOTTOM w0.102: U43.AF9 32.8,126.64 32.69,126.75 v1(32.69,127.05)
  BOTTOM w0.14: C637.1 133.57,134.4 133.94,134.4 134.07,134.53 134.07,135.19 133.73,135.53 v1(133.61,135.53)
PEG_TX#3: length 122.7
  IN1 w0.102: v1(134.37,138.69) 134.58,138.49 134.58,137.4 133.69,136.51 131.39,136.51 130.58,135.7 128.64,135.7 127.29,137.05 127.29,139.08 125.57,140.8 107.21,140.8 106.68,140.27 97.26,140.27 77.7,120.71 56.86,120.71 56.05,121.52 47.46,121.52 46.95,122.03 40,122.03 38.22,123.81 34.41,123.81 32.22,126 32.22,126.81 31.94,127.09 31.73,127.09 v1(31.45,127.36)
  BOTTOM w0.102: U43.AG10 31.97,127.11 31.71,127.11 v1(31.45,127.36)
  BOTTOM w0.14: v1(134.37,138.69) 134.67,138.4 134.67,137.87 134.46,137.66 C616.1
PEGX_RST#: length 27.2
  TOP w0.14: v1(26.96,122.67) 27.49,122.14 R124.1 ; Q15.2 43.16,110.22 v1(43.42,110.47) 43.93,109.97 R179.2 R183.1
  IN3 w0.089: v1(43.42,110.47) 43.14,110.19 38.32,110.19 33.49,115.03 33.49,116.57 32.09,117.97 30.83,117.97 28.79,120.01 28.79,120.84 v1(26.96,122.67)
PEX_CLKREQ#: length 21.2
  TOP w0.14: v3(24.37,119.64) 24.35,119.63 R147.1 24.78,118.17 26.08,118.17 R148.1 27.39,118.6 27.9,118.09 29.14,118.09 v1(29.27,117.97) 30.18,117.97 Q11.1
  BOTTOM w0.102: 32.98,119.11 33.28,119.41 36.46,119.41 36.79,119.74 36.79,123.43 36.53,123.68 35.98,123.68 U43.AC6
  BOTTOM w0.14: v1(29.27,117.97) 31.84,117.97 32.98,119.11
PEX_PLLVDD: length 27.1
  TOP w0.508: v1(28.53,146.54) C84.1 R67.2 ; C143.2 37.09,130.79 v1(36.71,131.16) 37.06,131.51 C134.1
  IN1 w0.508: v1(36.71,131.16) 36.71,135.82 35.65,136.89 30.57,136.89 28.53,138.92 v1(28.53,146.54)
  BOTTOM w0.254: U43.AA14 37.11,130.76 v1(36.71,131.16)
  BOTTOM w0.305: v1(36.71,131.16) 36.71,131.16 37.14,131.58 U43.AA15
PEX_TERMP: length 8.2
  BOTTOM w0.127: U43.AF25 32.67,140.29 32.67,141.59 32.17,142.1
  BOTTOM w0.14: v1(28.28,144.64) 28.41,144.5 R493.2 30.77,143.49 32.17,142.1
PEX_TSTCLK: length 4.6
  TOP w0.14: R83.2 30.02,137.6 30.53,137.6 31.05,138.12 v1(31.71,138.12)
  BOTTOM w0.127: U43.AF22 33.1,137.54 33.01,137.63 32.64,137.63 32.15,138.12 v1(31.71,138.12)
PEX_TSTCLK#: length 5.3
  TOP w0.14: R83.1 29.79,138.16 v1(30.44,138.16)
  BOTTOM w0.127: 30.57,138.29 30.82,138.54 32.05,138.54 32.73,137.86 33.11,137.86 33.6,137.36 U43.AE22
  BOTTOM w0.14: 30.57,138.29 v1(30.44,138.16)
PLTRST#: length 380.8
  TOP w0.14: v1(34.02,103.64) 35.62,103.64 36.14,103.12 R215.1 37.45,102.33 U22.2 ; U20.4 159.39,106.69 159.41,106.66 R198.1 160,105.18 v1(160,105.09) ; U32.22 140.98,57.73 141.56,57.14 142.41,57.14 143.31,56.23 144.21,56.23 144.58,56.61 144.58,58.92 145.63,59.97 149.91,59.97 150.33,59.55 150.33,59.04 149.79,58.51 v1(149.49,58.51)
  IN1 w0.114: v1(159.47,50.28) 158.33,51.42 158.33,55.86 156.36,57.83 153.18,57.83 152.15,58.86 150.5,58.86 150.15,58.51 v1(149.49,58.51) ; v1(212.1,88.15) 212.42,88.48 217.43,88.48 218.02,87.89 218.02,81.59 v1(216.8,80.37)
  IN2 w0.114: v1(212.1,88.15) 211.34,88.91 204.66,88.91 200.87,92.69 194.22,92.69 192.55,91.03 182.34,91.03 181.85,91.52 163.76,91.52 v1(163.15,90.92) ; v1(160,105.09) 160.05,105.04 160.05,103.18 158.96,102.09 158.96,93.58 161.25,91.3 161.25,87.49 159.8,86.04 159.8,81.66 158.21,80.06 158.21,76.36 156.41,74.56 156.41,72.61 155.41,71.61 155.41,70.72 154.64,69.96 154.64,68.89 153.29,67.53 153.29,64.56 151.3,62.58 151.3,61.79 149.31,59.8 149.31,58.68 v1(149.49,58.51)
  IN3 w0.089: v1(149.49,58.51) 149.49,57.97 148.34,56.83 148.34,56.75 148.01,56.42 147.91,56.42 146.42,54.93 140.16,54.93 139.83,55.26 138.98,55.26 138.26,54.53 138.26,54.34 138.01,54.09 137.45,54.09 135.77,52.41 133.25,52.41 132.24,51.4 130.52,51.4 128.91,49.79 120.09,49.79 119.54,49.23 113.15,49.23 111.79,50.6 106.2,50.6 105.51,49.91 104.86,49.91 104.54,49.59 91.64,49.59 88.87,46.81 68.56,46.81 67.98,47.39 66.08,47.39 65.78,47.69 63.7,47.69 63.07,48.32 61.46,48.32 59.97,49.8 50.73,49.8 48.79,51.74 41.37,51.74 40.73,52.39 35.67,52.39 34.12,53.95 34.12,56.23 33.39,56.96 33.39,66.56 33.23,66.72 33.23,78.09 35.64,80.49 35.64,94.47 34.56,95.55 34.56,98.92 33.42,100.06 33.42,103.04 v1(34.02,103.64)
  BOTTOM w0.14: v1(160,105.09) 160.05,105.04 160.05,103.4 159.91,103.26 159.91,97.95 158.85,96.88 158.85,95.22 v1(163.15,90.92) ; v1(159.47,50.28) 159.03,49.83 159.03,49.32 159.44,48.9 159.44,41.36 158.71,40.62 158.71,39.68 159.01,39.38 159.47,39.38 159.83,39.73 R785.1 ; R702.2 216.24,80.68 216.54,80.37 v1(216.8,80.37) ; v1(149.49,58.51) 144.26,58.51 143.85,58.91 142.36,58.91 141.82,59.45 141.82,59.77 139.5,62.09 138.65,62.09 ; R694.2 212.7,88.76 v1(212.1,88.15)
PLTRST#_TPM: length 13.6
  BOTTOM w0.14: R784.1 172.69,39.24 v1(172.17,38.72) 171.84,38.39 164.88,38.39 163.81,39.46 U56.16 161.02,39.46 R785.2
PM_EXTTS#1: length 2.5
  TOP w0.14: R297.2 157.56,74.4 v1(157.29,74.13)
  BOTTOM w0.14: v1(157.29,74.13) 157.88,74.72 JDIM1.198
PROC_DETECT: length 10.1
  BOTTOM w0.076: U45.D61 107.33,128.44 107.33,128.67 106.98,129.02 106.4,129.02 106.33,129.09 105.95,129.09 105.88,129.02 104.4,129.02 103.72,129.7 103.72,131.58 103.04,132.25 101.81,132.25
  BOTTOM w0.14: TP116.1 100.8,132.7 101.24,132.25 101.81,132.25
PROCHOT_EC: length 10.9
  TOP w0.14: U32.17 139.44,59.73 138.65,58.94 138.65,58.38 138.05,57.77 136.23,57.77 135.85,57.39 135.85,56.98 135.21,56.35 R367.2 134.59,55.24 134.32,54.97 Q29.2 133.82,55.99 v1(133.56,56.24)
PS_FB_CLAMP: length 8.9
  BOTTOM w0.102: U43.F3 49.6,121.35 49.18,120.93 49.18,120.76 48.89,120.46 48.68,120.46 47.33,119.11
  BOTTOM w0.14: R603.1 44.43,115.97 v1(44.43,116.37) 44.43,116.47 45.93,117.97 46.19,117.97 47.33,119.11
PWR_DEBUG: length 1.1
  TOP w0.14: R127.1 93.94,121.52 93.81,121.65 TP35.1
PWR_DEBUG_R: length 18.5
  TOP w0.14: R127.2 95.22,121.6 96.41,122.79 96.73,122.79 v1(96.76,122.77) ; R109.2 99.35,125.84 v1(99.5,125.99)
  IN3 w0.089: v1(96.76,122.77) 96.76,122.79 97.49,123.53 97.49,123.81 99.5,125.82 v1(99.5,125.99)
  BOTTOM w0.076: U45.H59 108.5,126.22 107.45,126.22 107.32,126.35 106.55,126.35 106.39,126.18 105.47,126.18 104.29,127.36 103.72,127.36
  BOTTOM w0.14: 103.72,127.36 100.77,127.36 100.75,127.38 100.05,127.38 99.5,126.83 v1(99.5,125.99)
PWRLED#: length 230.1
  TOP w0.203: 139.13,57.03 139.23,56.93 U32.24
  TOP w0.254: R31.1 R44.1 10.62,154.55 10.88,154.29 10.88,153.4 11.41,152.87 v1(12.28,152.87) ; 139.13,57.03 138.66,57.03 v1(138.13,56.5)
  IN3 w0.254: v1(12.28,152.87) 15.88,149.26 15.88,143.54 19.74,139.68 19.74,128.71 22.56,125.89 22.56,121.42 25.42,118.56 26.46,118.56 30.62,114.41 31.45,114.41 35.12,110.74 35.12,101.85 35.52,101.45 35.52,100.4 35.02,99.9 35.02,95.75 36.1,94.67 36.1,80.3 33.7,77.89 33.7,73.93 34.58,73.04 34.58,61.66 33.97,61.05 33.97,57.03 34.58,56.42 34.58,54.14 35.87,52.85 41.02,52.85 41.67,52.21 48.99,52.21 50.93,50.27 60.16,50.27 61.65,48.78 63.26,48.78 63.89,48.16 65.97,48.16 66.27,47.85 68.17,47.85 68.75,47.28 88.67,47.28 91.53,50.14 104.43,50.14 104.66,50.37 105.2,50.37 105.89,51.06 111.99,51.06 113.17,49.89 119.45,49.89 119.82,50.25 128.71,50.25 130.33,51.86 132,51.86 134.48,54.34 135.22,54.34 136.16,55.28 136.86,55.28 138.08,56.5 v1(138.13,56.5)
R_PEG_TX0: length 6.4
  BOTTOM w0.076: U45.C22 131.88,128.29 131.4,128.77 131.4,128.96 131.69,129.25 131.69,129.69 131.93,129.93 131.93,132.76 131.71,132.97 131.71,133.27 C632.2
R_PEG_TX1: length 9.6
  BOTTOM w0.076: C615.2 132.63,136.46 132.63,136.24 132.46,136.07 131.09,136.07 130.7,135.68 130.7,131.95 131.35,131.31 131.35,129.86 131.41,129.8 131.5,129.8 131.64,129.94 U45.A23
R_PEG_TX2: length 6.3
  BOTTOM w0.076: C638.2 134.28,133.46 134.28,133.32 132.95,131.99 132.95,130.36 133.01,130.3 133.01,129.88 132.66,129.53 132.66,129.33 132.93,129.06 U45.C21
R_PEG_TX3: length 9
  BOTTOM w0.076: 133.05,133.84 133.05,133.82 133,133.77 133,133.28 132.55,132.83 132.55,130.53 132.43,130.41 132.43,130.2 U45.A21
  BOTTOM w0.14: C617.2 135.08,137.02 134.77,137.02 134.64,136.89 134.64,136.41 134.36,136.13 133.44,136.13 133.05,135.75 133.05,133.84
R_PEG_TX#0: length 6.4
  BOTTOM w0.076: U45.C23 132.01,128.61 132.14,128.61 132.24,128.71 132.24,128.82 131.86,129.2 131.86,129.63 132.09,129.86 132.09,132.83 131.88,133.04 131.88,133.62 131.97,133.71 C633.1
R_PEG_TX#1: length 9.6
  BOTTOM w0.076: U45.B23 131.37,129.6 131.19,129.79 131.19,131.24 130.54,131.89 130.54,135.75 131.02,136.23 132.39,136.23 132.46,136.31 132.46,136.46 C614.2
R_PEG_TX#2: length 6.3
  BOTTOM w0.076: C637.2 134.04,133.7 134.12,133.62 134.12,133.39 132.79,132.06 132.79,130.29 132.84,130.23 132.84,129.95 132.49,129.6 132.49,129.26 132.7,129.06 132.7,128.95 132.63,128.88 U45.B21
R_PEG_TX#3: length 9
  BOTTOM w0.076: U45.B22 132.2,129.71 132.26,129.77 132.26,130.48 132.38,130.6 132.38,132.89 132.84,133.35 132.84,133.77 132.79,133.82 132.79,133.84
  BOTTOM w0.14: C616.2 134.37,136.7 134.37,136.52 134.25,136.39 133.32,136.39 132.79,135.86 132.79,133.84
R_SPK2: length 6.2
  TOP w0.203: 236.43,36.05 236.58,36.2 U34.23
  TOP w0.508: TP102.1 239.73,33.38 238.72,33.38 236.43,35.67 236.43,36.05
R_SPK+: length 54.1
  TOP w0.203: v2(232.62,45.07) 232.62,44.97 233.78,43.81 U34.45
  TOP w0.508: R431.1 v2(238.92,3.31)
  IN1 w0.508: v2(238.92,3.31) 238.92,4.63 234.83,8.72 234.83,9.36 234.53,9.66 234.53,24.86 233.89,25.5 233.89,28.8 232.74,29.96 229.19,29.96 228.23,30.92 228.23,42.21 228.93,42.91 229.75,42.91 231.91,45.07 v2(232.62,45.07)
R_SPK+_1: length 6.1
  TOP w0.508: R431.2 239.73,5.94 C518.1 239.73,6.23 240.2,6.71 v2(240.2,6.91)
  BOTTOM w0.508: v2(240.2,6.91) 240.2,6.42 v1(239.35,5.57) 238.87,5.09 CN22.1
R_SPK-: length 57.1
  TOP w0.203: v1(233.51,45.3) 233.51,45.07 233.36,44.92 233.36,44.69 234.18,43.87 U34.44
  TOP w0.508: v2(238.03,3.29) 238.01,3.31 R430.1
  IN1 w0.508: v2(238.03,3.29) 238.03,4.26 233.94,8.35 233.94,8.99 233.64,9.29 233.64,24.49 233,25.13 233,28.43 232.37,29.07 228.82,29.07 227.34,30.55 227.34,42.58 228.56,43.8 229.38,43.8 231.54,45.96 233.08,45.96 233.51,45.53 v1(233.51,45.3)
R_SPK-_1: length 5.8
  TOP w0.508: v1(239.31,6.91) 238.36,5.95 C517.1 237.19,5.94 R430.2
  BOTTOM w0.508: CN22.2 238.74,6.34 v1(239.31,6.91)
RAM_ID0: length 16.4
  BOTTOM w0.089: U45.AT3 143.8,109.8 144.27,109.8 144.29,109.82 144.3,109.82 144.47,109.99 144.47,110.29 144.61,110.43 144.94,110.43 145.16,110.22 145.16,110.11 145.69,109.58 146.39,109.58 146.67,109.31 146.67,108.8 147.66,107.81
  BOTTOM w0.14: 147.66,107.81 147.91,107.81 148.8,106.92 149.56,106.92 150.33,106.16 152.1,106.16 152.87,106.92 R646.2 154.38,106.16 v1(155.33,106.16) 155.52,106.16 R647.1
RAM_ID1: length 13
  TOP w0.14: R227.1 149.06,102.59 R214.2 147.86,103.78 147.86,104.18 145.42,106.62 145.42,106.9 143.98,108.35 143.98,109.55 143.2,110.32 143.2,110.74 v1(143.65,111.19) 143.82,111.36 v1(143.82,111.99)
  BOTTOM w0.089: U45.AM3 143.52,112.29 v1(143.82,111.99)
RAM_ID2: length 18.6
  TOP w0.14: v1(150.71,115.2) 150.6,115.09 149.51,115.09 149.07,114.65 149.07,114.3 148.12,113.34 146.97,113.34 146.64,113.01 146.64,112.02 v1(146.72,111.95)
  BOTTOM w0.076: U45.AM2 144.41,112.36 144.7,112.66 145.01,112.66 145.22,112.86 145.73,112.86 146.65,111.95 v1(146.72,111.95)
  BOTTOM w0.14: v1(150.71,115.2) 150.73,115.17 151.47,115.17 151.67,114.97 152.74,114.97 153.01,114.7 153.01,114.01 153.35,113.66 154.99,113.66 155.19,113.46 155.19,111.73 155.41,111.52 R637.2 R638.1
RAM_ID3: length 23.3
  IN1 w0.114: v1(142.35,114.69) 142.38,114.69 143.04,114.03 144.66,114.03 145.59,113.1 146.16,113.1 147.53,111.73 147.53,109.97 146.9,109.33 146.9,108.62 147.24,108.28 148.14,108.28 149.55,106.87 152.18,106.87 153.88,108.57 v1(155.53,108.57)
  BOTTOM w0.102: v1(142.35,114.69) 142.38,114.69 142.49,114.57 U45.AH4
  BOTTOM w0.14: v1(157.44,109.97) 157.18,109.71 R642.1 R641.2 155.92,108.96 v1(155.53,108.57)
REGOUT:
  vias: v1(220.05,80.48)
RF_EN: length 131.9
  TOP w0.14: v1(156.68,51.93) 156.68,53.07 156.94,53.34 156.94,54 156.81,54.13 U32.66
  IN3 w0.089: v1(212.94,66.71) 214.21,65.44 214.21,63.71 217.8,60.11 219.05,60.11 220.68,58.49 220.68,44.55 216.62,40.5 209.13,40.5 206.33,43.29 203.67,43.29 198.74,48.22 198.74,48.88 197.85,49.77 197.32,49.77 196.3,48.75 166.07,48.75 164.3,50.53 159.85,50.53 158.45,51.93 v1(156.68,51.93)
  BOTTOM w0.14: v1(212.94,66.71) 213.06,66.71 214.05,67.69 214.05,68.75 210.78,72.02 210.78,73.95 208.59,76.13 208.59,79.36 210.42,81.19 211.01,81.19 213.32,83.5 217.84,83.5 218.35,84.01 218.35,85.53 219.28,86.46 CN12.56
RJ45-TX0+: length 9.3
  TOP w0.127: L5.3 137.67,158.88 136.76,157.97 v1(136.06,157.97) 136.06,157.14 135.67,156.75 135.39,156.75 135.33,156.82 U9.4 U9.5 135.33,158.24 135.82,158.73 136.4,158.73 137.1,159.44 CN1.1
RJ45-TX0-: length 9.4
  TOP w0.127: CN1.2 136.43,160.01 136.67,159.77 136.67,159.62 136.22,159.17 135.64,159.17 134.83,158.35 U9.6 U9.3 134.88,157.09 134.88,156.76 135.29,156.35 135.87,156.35 136.43,156.91 v1(136.76,156.91) 136.53,157.13 136.53,157.39 136.69,157.54 136.94,157.54 137.48,158.08 L5.2
RJ45-TX1+: length 10.7
  TOP w0.127: CN1.3 135.38,161.11 135.52,160.97 135.52,160.61 134.96,160.05 134.96,159.75 134.3,159.09 134.3,158.45 134.33,158.43 U9.7 U9.2 134.3,157.12 134.3,156.47 135.07,155.7 v1(135.73,155.7) 135.73,155.32 135.82,155.23 136.43,155.23 136.56,155.36 136.56,155.66 137.62,156.72 L7.3
RJ45-TX1-: length 10.7
  TOP w0.127: CN1.6 132.89,160.01 133.87,159.03 133.87,158.51 133.83,158.46 U9.8 U9.1 133.87,157.1 133.87,156.14 134.71,155.3 v1(134.71,154.92) 135.24,154.92 135.37,154.8 136.61,154.8 136.99,155.18 136.99,155.48 137.43,155.92 L7.2
RJ45-TX2+: length 8.5
  BOTTOM w0.127: L23.2 137.25,158.37 137.1,158.23 136.58,158.23 v1(136.41,158.4) 136.41,157.92 136.25,157.76 135.79,157.76 135.72,157.83 U37.5 U37.4 134.07,157.83 134.03,157.79 133.83,157.79 133.48,158.14 133.48,158.35 v1(133.71,158.58) 133.26,159.04 133.26,160.01 133.69,160.44 133.76,160.51 134.02,160.51 134.15,160.38 134.15,160.12 CN1.4
RJ45-TX2-: length 8.5
  BOTTOM w0.127: CN1.5 133.02,160.38 132.83,160.19 132.83,158.98 v1(132.43,158.58) 133.65,157.36 134.07,157.36 134.1,157.33 U37.3 U37.6 136.31,157.33 v1(136.51,157.13) 136.95,157.57 L23.3
RJ45-TX3+: length 10.8
  BOTTOM w0.127: CN1.7 130.64,160.77 130.64,160.51 131.15,160 131.15,158.78 v1(132.65,157.29) 132.55,157.18 132.55,156.72 132.66,156.6 133.1,156.6 133.28,156.77 133.99,156.77 134.05,156.83 U37.2 U37.7 135.73,156.83 136.38,156.18 136.75,156.18 136.91,156.34 L26.2
RJ45-TX3-: length 10.8
  BOTTOM w0.127: CN1.8 130.53,160.01 130.72,159.82 130.72,158.61 131.61,157.72 131.61,157.53 v1(131.36,157.29) 132.48,156.17 133.28,156.17 133.46,156.34 134.02,156.34 134.03,156.33 U37.1 U37.8 135.58,156.33 136.17,155.75 136.67,155.75 136.88,155.54 L26.3
ROM_CS: length 16.8
  TOP w0.14: v1(51.7,129.53) 53.04,128.18 v1(53.04,126.35) 55.44,123.96 55.44,116.59 56.22,115.81 R171.1
  BOTTOM w0.102: v1(51.7,129.53) 51.3,129.13 U43.D12
ROM_SCLK: length 19
  BOTTOM w0.102: 55.46,126.25 54.72,126.98 54.72,127.52 53.67,128.57 53.29,128.57 53.16,128.71 52.83,128.71 52.41,129.12 U43.C12
  BOTTOM w0.14: 55.46,126.25 59.52,122.18 59.52,121.27 60.41,120.38 63.97,120.38 v1(64.22,120.13) 64.87,119.47 R583.2 R589.1
ROM_SI: length 20.2
  BOTTOM w0.102: 55.53,126.55 54.92,127.15 54.92,127.61 53.76,128.78 53.38,128.78 53.03,129.12 U43.B12
  BOTTOM w0.14: R590.1 R584.1 v1(66.39,120.39) 66.15,120.63 60.52,120.63 59.8,121.35 59.8,122.28 55.53,126.55
ROM_SO: length 21.5
  BOTTOM w0.102: U43.A12 55.13,127.69 55.13,127.31 55.71,126.73
  BOTTOM w0.14: 55.71,126.73 58.65,123.79 58.65,123.79 60.08,122.37 60.08,121.5 60.64,120.93 68.01,120.93 v1(68.42,120.52) R585.1 R591.2
RSMRST#: length 50.7
  TOP w0.14: U32.112 148.24,68.85 v1(148.12,68.97)
  IN3 w0.089: v1(150.72,98.82) 150.72,96.1 151.29,95.53 153.76,95.53 157.46,91.83 158.08,91.83 159.12,90.79 159.12,88.94 159.2,88.86 159.2,88.34 161.22,86.32 161.22,81.98 163.31,79.9 163.31,78.65 161.27,76.61 161.27,76.27 157.62,72.63 155.94,72.63 154.98,71.66 154.69,71.66 154.16,71.13 154.16,70.8 153.94,70.58 153.12,70.58 152.87,70.83 149.98,70.83 148.12,68.97 v1(148.12,68.97)
  BOTTOM w0.14: v1(150.72,98.82) 150.12,99.42 R679.2 R678.1
