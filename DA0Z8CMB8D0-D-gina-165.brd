# Allegro board DA0Z8CMB8D0-D-gina-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RTC_RST#: length 104.7
  TOP w0.14: R726.2 128.29,64.7 C711.1 ; J2.1 128.29,66.92 C711.1 ; C711.1 128.92,66.23 v1(129.12,66.23)
  IN1 w0.114: v1(141.07,109.1) 141.49,108.68 141.49,108.35 141.91,107.93 143.34,107.93 146.06,105.22 147.71,105.22 150.52,102.41 150.52,101.88 150.94,101.46 152.05,101.46 153.37,100.14 153.37,99.04 154.83,97.58 154.83,97.33 156.98,95.18 v1(161.1,95.18)
  IN3 w0.089: v1(161.1,95.18) 161.1,94.9 166.01,89.98 166.01,85.77 167.94,83.84 167.94,73.48 165.9,71.45 164.57,71.45 161.11,67.99 157.95,67.99 157.1,67.14 155.63,67.14 154.36,65.86 v1(154.27,65.86)
  BOTTOM w0.089: v1(141.07,109.1) 140.77,109.4 U45.AU7
  BOTTOM w0.14: v1(154.27,65.86) 154.27,66.62 153.3,67.6 150.78,67.6 150.38,68 148.24,68 145.86,65.62 145.86,65.39 ; v1(129.12,66.23) 130.21,66.23 131.42,65.02 134.13,65.02 135.31,66.2 137.9,66.2 138.35,66.65 139.24,66.65 139.79,66.11 142.88,66.11 143.6,65.39 v1(144.1,65.39) 145.86,65.39 ; 145.86,65.39 146.62,64.63 147.21,64.63 R730.2
RTC_X1: length 15.9
  BOTTOM w0.076: 144.99,106.54 144.84,106.69 143.99,106.69 143.73,106.94 142.81,106.94 142.57,107.18 142.57,107.73 U45.AW5
  BOTTOM w0.14: 144.99,106.54 146.08,105.44 147.66,105.44 149.51,103.59 150.74,103.59 R655.1 151.98,103.37 C664.2 152.6,104 153.76,104 v1(154.01,104.25) 154.24,104.48 Y5.1
RTC_X2: length 15.9
  BOTTOM w0.076: 144.74,106.41 143.98,106.41 143.61,106.78 142.57,106.78 142.24,107.11 U45.AY5
  BOTTOM w0.14: 144.74,106.41 145.96,105.19 147.58,105.19 149.41,103.36 150.19,103.36 R655.2 151.6,102.59 151.72,102.47 C665.2 152.1,102.41 152.84,101.66 153.58,101.66 153.88,101.96 v1(154.01,101.96) 154.03,101.99 Y5.2
RX_DVDD18: length 18
  BOTTOM w0.203: 107.78,149.72 107.44,150.06 U40.24 ; 99.57,154.34 100.25,153.66 U40.46 ; U40.12 106.17,155.68 106.56,156.07 ; v1(99.91,152.89) 99.94,152.86 U40.44 ; 108.92,155.06 108.8,155.06 107.8,154.06 U40.14
  BOTTOM w0.381: C570.2 98.98,154.92 99.57,154.34
  BOTTOM w0.508: v1(110.32,146.67) 110.07,146.67 109.8,146.93 L28.2 109.8,147.69 109.71,147.79 C585.1 109.7,148.46 C588.1 108.54,148.95 107.78,149.72 ; v1(98,154.37) 98.39,154.76 C570.2 ; 108.92,155.06 C568.2 109.17,156.07 v1(108.92,156.07) ; v1(107.78,156.96) 107.78,157.07 C561.2 107.1,157.4 107.1,156.6 106.56,156.07
S5_ON: length 354.9
  TOP w0.14: PQ26.2 205.8,47.23 201,47.23 198.94,49.29 v1(198.91,49.29) ; v1(152.61,65.39) 153.25,66.02 153.25,66.79 153.04,66.99 U32.100 153.04,68.69 152.64,69.09 152.64,69.93 R315.1
  IN1 w0.114: v1(146.85,61.55) 146.8,61.55 146.01,62.34 146.01,62.78 146.42,63.19 147.09,63.19 148.47,64.57 148.47,65.24 148.87,65.64 152.36,65.64 v1(152.61,65.39)
  IN3 w0.089: v1(204.68,70.98) 206.84,68.82 209.11,68.82 213.57,64.36 213.57,61.95 216.56,58.97 219.1,58.97 220.49,57.58 220.49,44.75 216.81,41.07 212.13,41.07 203.91,49.29 v1(198.91,49.29) 198.18,50.02 193.63,50.02 193.38,49.77 166.29,49.77 162.84,53.23 162.84,63.41 160.92,65.33 158.41,65.33 158.09,65.01 156.42,65.01 154.9,63.48 153.37,63.48 153.12,63.74 153.12,64.88 v1(152.61,65.39) ; v1(74.41,92.14) 74.46,92.19 75.47,92.19 76.44,91.22 76.44,84.12 68.22,75.9 64.36,75.9 63.86,75.4 63.33,75.4 62.84,74.9 62.83,74.9 61.21,73.28 61.21,70.16 60.18,69.12 60.18,64.37 60.32,64.23 60.32,62.73 60.04,62.45 60.04,60.82 59.05,59.83 59.05,55.71 60.57,54.2 60.57,53.52 61.28,52.82 61.69,52.82 62.63,51.88 62.93,51.88 63.8,51.01 64.91,51.01 65.17,50.75 70.19,50.75 71.22,49.72 78.13,49.72 78.89,50.48 80.33,50.48 80.81,50.96 82.18,50.96 82.43,51.21 88.78,51.21 90,52.43 97.09,52.43 97.8,53.14 104.81,53.14 105.74,54.07 114.63,54.07 115.76,52.93 115.76,52.52 116.1,52.19 118.07,52.19 119.36,53.48 123.63,53.48 124.5,52.62 127.91,52.62 129.86,54.57 131.55,54.57 134.05,57.07 134.45,57.07 137.03,59.65 138.83,59.65 140.5,57.98 142.87,57.98 143.05,58.16 143.99,58.16 146.07,60.25 146.07,60.78 v1(146.85,61.55)
  BOTTOM w0.14: v1(204.68,70.98) 201.13,70.98 PR175.1 ; PQ35.2 94.7,101.5 95.11,101.09 96.71,101.09 97.35,101.74 97.35,102.84 97.88,103.36 100.84,103.36 101.2,103.72 101.62,103.72 102.26,104.36 103.08,104.36 103.36,104.08 PQ37.2 v3(103.36,99.42) 102.98,99.04 93.13,99.04 91.24,100.93 85.89,100.93 84.97,100.01 81.66,100.01 76.98,95.33 76.98,94.54 74.58,92.14 v1(74.41,92.14)
S5D: length 92.6
  TOP w0.14: PR121.2 197.93,47.74 v1(193,47.74)
  TOP w0.254: v1(215.5,47.02) 217.84,47.02 218.53,46.34 218.53,43.46 216.9,41.84 206.42,41.84 PC84.2 206.1,42.96 205.47,43.6 PQ29.3 202.6,43.6 201.84,44.36 PR122.2 201.18,44.48 PR121.2
  BOTTOM w0.14: PQ45.2 166.21,71.43 167.26,70.39 167.26,68.09 166.96,67.8 166.96,66.02 163.01,62.07 163.01,52.45 166.71,48.75 173.82,48.75 177.12,45.45 190.71,45.45 v1(193,47.74)
  BOTTOM w0.254: v1(165.19,72.32) 165.24,72.32 PQ45.2 ; v1(215.5,47.02) 215.34,47.19 PQ53.4
SATA_IREF: length 6.2
  BOTTOM w0.102: R512.1 138.65,133.71 138.49,133.87 138.49,134.78 138.95,135.24 v1(139.02,135.24)
  BOTTOM w0.254: R512.1 138.39,133.2 138.39,131.32 137.71,130.64 U45.A12
SATA_LED#: length 5.1
  BOTTOM w0.076: U45.U3 143.78,120.31 145,120.31 145.12,120.43 145.98,120.43 146.17,120.62 147.35,120.62 147.48,120.75 147.82,120.75 148.06,120.51 R575.2
SATA_RCOMP: length 5.8
  BOTTOM w0.241: U45.C12 137.73,128.9 137.73,129.57 138.08,129.92 138.08,130.54 138.72,131.18 138.72,132.65 139.78,133.71 R513.2
SATA_RXN0: length 145.1
  IN3 w0.089: v1(38.13,97.32) 37.8,97.65 37.61,97.65 37.37,97.9 37.37,98.93 37.86,99.42 37.86,100.88 40.04,103.06 42.72,103.06 44.68,105.01 54.9,105.01 55.71,104.2 69.07,104.2 70.36,102.91 70.36,102.37 71.7,101.03 75.69,101.03 77.68,103.01 77.68,114.97 93.97,131.25 98.18,131.25 99.72,129.71 108.86,129.71 110.4,128.18 126.56,128.18 127.75,126.98 128.61,126.98 128.99,126.6 128.99,125.97 129.5,125.46 131.78,125.46 132.6,124.65 140.08,124.65 140.23,124.79 142.01,124.79 142.25,125.04 142.25,125.38 142.19,125.44 141.94,125.44 141.81,125.3 v1(141.81,125.2)
  BOTTOM w0.076: U45.J5 142.09,124.75 141.89,124.75 141.81,124.83 v1(141.81,125.2)
  BOTTOM w0.14: C685.2 32.86,95.49 32.86,95.77 v1(33.36,96.28) 32.86,96.78 32.86,97.15 33.38,97.67 37.78,97.67 v1(38.13,97.32)
SATA_RXN0_C: length 14.5
  BOTTOM w0.14: CN11.5 35.31,83.98 34.82,83.49 34.49,83.49 34.02,83.96 34.02,88.95 32.73,90.24 32.73,91.48 v1(33.28,92.03) 32.71,92.61 32.71,94.2 32.85,94.34 C685.1
SATA_RXP0: length 145.1
  IN3 w0.089: v1(141.83,125.83) 142.02,125.64 142.27,125.64 142.45,125.46 142.45,124.95 142.09,124.59 140.31,124.59 140.17,124.44 132.51,124.44 131.7,125.26 129.41,125.26 128.79,125.88 128.79,126.52 128.52,126.78 127.67,126.78 126.48,127.97 110.31,127.97 108.78,129.51 99.63,129.51 98.1,131.05 94.05,131.05 77.89,114.88 77.89,102.93 75.78,100.82 71.62,100.82 70.16,102.28 70.16,102.82 68.99,104 55.63,104 54.81,104.81 44.76,104.81 42.81,102.85 40.12,102.85 38.07,100.8 38.07,99.34 37.57,98.84 37.57,97.98 37.7,97.86 37.8,97.86 v1(38.13,98.19)
  BOTTOM w0.102: v1(141.83,125.83) 142.16,125.5 U45.H5
  BOTTOM w0.14: v1(38.13,98.19) 37.88,97.94 33.27,97.94 32.59,97.26 32.59,96.78 v1(32.09,96.28) 32.59,95.77 32.59,95.49 C684.2
SATA_RXP0_C: length 14.6
  BOTTOM w0.14: CN11.6 35.34,82.71 34.83,83.22 34.38,83.22 33.75,83.85 33.75,88.84 32.46,90.13 32.46,91.59 v1(32.01,92.03) 32.46,92.48 32.45,92.49 32.45,94.11 C684.1
SATA_TXN0: length 138.3
  IN3 w0.089: v1(135.98,131.43) 135.75,131.2 135.75,130.82 134.96,130.03 133.18,130.03 131.12,127.97 127.62,127.97 126.27,129.32 110.52,129.32 109.66,130.18 99.96,130.18 97.57,132.57 96.37,132.57 95.66,131.86 93.9,131.86 76.54,114.5 76.54,103.36 76.03,102.85 71.3,102.85 69.47,104.68 55.91,104.68 55.1,105.5 48.37,105.5 47.84,106.03 44.28,106.03 42.55,104.3 40.6,104.3 37.39,101.1 37.39,99.62 36.9,99.12 36.9,96.9 37.58,96.22 37.8,96.22 v1(38.13,96.55)
  BOTTOM w0.076: v1(135.98,131.43) 135.71,131.16 135.71,131.04 136.01,130.74 136.01,130.44 136.17,130.29 136.17,129.95 136,129.78 135.89,129.78 135.55,129.44 U45.B15
  BOTTOM w0.14: v1(38.13,96.55) 37.89,96.31 37.44,96.31 37.23,96.52 36.8,96.52 v1(36.31,97.01) 35.78,96.49 35.2,96.49 34.42,95.71 34.42,95.29 C686.2
SATA_TXN0_C: length 9.8
  BOTTOM w0.14: C686.1 34.44,94.15 34.44,93.75 v1(33.97,93.28) 34.36,92.88 34.36,92.45 33.98,92.07 33.98,89.9 34.72,89.17 34.72,87.4 35.03,87.09 35.28,87.09 35.85,86.52 CN11.3
SATA_TXP0: length 138.3
  IN3 w0.089: v1(135.34,131.43) 135.54,131.23 135.54,130.9 134.87,130.24 133.1,130.24 131.04,128.18 127.7,128.18 126.36,129.52 110.61,129.52 109.75,130.39 100.04,130.39 97.65,132.78 96.29,132.78 95.57,132.06 93.81,132.06 76.34,114.59 76.34,103.45 75.95,103.06 71.38,103.06 69.55,104.89 56,104.89 55.19,105.7 48.45,105.7 47.92,106.23 44.2,106.23 42.47,104.5 40.51,104.5 37.19,101.18 37.19,99.7 36.69,99.21 36.69,96.82 37.5,96.02 37.8,96.02 v1(38.13,95.68)
  BOTTOM w0.076: v1(135.34,131.43) 135.54,131.23 135.54,130.97 135.85,130.67 135.85,130.49 135.77,130.41 135.52,130.41 135.44,130.34 135.44,130.16 135.53,130.07 U45.A15
  BOTTOM w0.14: v1(38.13,95.68) 37.78,96.04 37.33,96.04 37.12,96.25 36.81,96.25 v1(36.31,95.74) 35.82,96.22 35.31,96.22 34.69,95.6 34.69,95.28 34.86,95.12 C687.2
SATA_TXP0_C: length 9.8
  BOTTOM w0.14: C687.1 34.87,94.34 34.71,94.17 34.71,93.81 v1(35.24,93.28) 34.63,92.67 34.63,92.34 34.25,91.96 34.25,90.01 34.98,89.28 34.98,87.51 35.14,87.36 35.39,87.36 35.82,87.79 CN11.2
SB_ACDC: length 172.6
  TOP w0.14: PR54.1 42.26,79.42 43.8,80.96 v1(44.15,80.96) ; U32.21 142.73,58.13 143.44,57.41 v1(143.44,57.13)
  IN1 w0.114: v1(30.62,74.66) 30.42,74.46 30.42,69.08 29.78,68.44 29.78,66.86 30.28,66.35 30.28,65.59 29.66,64.97 29.66,49.88 31.86,47.69 36.75,47.69 38.49,49.43 49.81,49.43 50.25,49.87 52.66,49.87 54.35,51.56 61.29,51.56 61.55,51.83 63.48,51.83 63.68,51.63 64.86,51.63 65.52,50.97 67.29,50.97 67.86,50.39 70.55,50.39 72.02,48.92 77.38,48.92 77.99,49.53 81.6,49.53 81.96,49.18 89.36,49.18 90.23,50.05 96.53,50.05 97,49.58 108.93,49.58 110.96,47.55 118.45,47.55 120,49.11 128.59,49.11 131.34,51.86 135.12,51.86 137.35,54.09 140.39,54.09 v1(143.44,57.13)
  IN2 w0.114: v1(44.15,80.96) 42.45,79.26 34.2,79.26 31.2,76.26 31.2,75.24 v1(30.62,74.66)
SCL/LED_CR_NC: length 3.6
  TOP w0.14: TP93.1 216.1,78.61 216.1,79.55 216.32,79.77 216.32,80.58 216.48,80.74 U24.42
SD_CD#: length 4
  BOTTOM w0.14: CN19.11 225.94,57.72 225.89,57.77 v1(225.26,57.77) R748.2
SD_CLK: length 4.9
  BOTTOM w0.14: R779.2 C777.1 225.26,43.43 v1(225.36,43.52) 225.37,43.53 CN19.5
SD_CMD: length 4
  BOTTOM w0.14: R762.2 224.38,51.03 v1(225.26,51.03) CN19.2
SD_DAT0: length 6
  BOTTOM w0.14: CN19.7 226.07,38.53 225.51,39.1 225.51,39.79 v1(225.33,39.96) 225.19,40.11 C779.1 R783.2
SD_DAT1: length 4.8
  BOTTOM w0.14: CN19.8 226.69,36.9 v1(225.26,38.34) 224.75,38.85 R786.2
SD_DAT2: length 4
  BOTTOM w0.14: R753.2 224.42,56.03 v1(225.26,56.03) CN19.9
SD_DAT3: length 4
  BOTTOM w0.14: CN19.1 v1(225.26,53.53) 224.42,53.53 R758.2
SD_WP: length 5.7
  BOTTOM w0.14: R788.2 224.38,36.68 v1(225.26,35.8) 225.97,35.09 CN19.10
SDA/SPIDI: length 6.1
  TOP w0.14: U24.44 217.48,79.97 217.13,79.61 217.13,77.71 216.62,77.2 TP94.1 216.74,76.57 R295.1
SENSEA: length 2.7
  TOP w0.14: U34.13 232.58,35.92 232.42,35.76 v1(232.42,35.42) 232.5,35.34 R410.1
SIO_EXT_SCI#: length 108.5
  TOP w0.14: v1(149.82,59.32) 149.46,59.32 149.01,58.86 146.06,58.86 144.82,57.62 144.82,56.51 144.31,55.99 143.21,55.99 142.31,56.9 141.42,56.9 140.99,57.33 U32.23
  IN3 w0.089: v1(146.29,126.7) 146.36,126.63 146.36,124.42 145.14,123.19 145.14,122.03 145.39,121.78 145.63,121.78 146.07,121.34 146.07,119.73 146.31,119.49 146.77,119.49 147.33,118.94 147.33,118.43 148.14,117.62 148.14,116.13 148.61,115.65 148.61,112.6 147.31,111.31 147.31,109.95 146.69,109.32 146.69,108.69 147.15,108.22 147.15,107.17 146.6,106.62 146.6,105.29 148.53,103.36 149.06,103.36 151.44,100.97 151.44,100.3 152.4,99.35 152.4,97.66 153.52,96.54 154.57,96.54 159.97,91.14 159.97,89.71 160.79,88.89 160.79,87.97 161.16,87.6 162.07,86.69 162.07,82.38 164.17,80.28 164.17,78.3 162.15,76.28 162.15,75.94 157.64,71.43 156.28,71.43 154.3,69.45 153.02,69.45 149.47,65.9 149.47,62.98 149.8,62.65 149.8,59.34 v1(149.82,59.32)
  BOTTOM w0.089: U45.G2 144.46,125.57 145.1,125.57 145.89,126.35 145.93,126.35 v1(146.29,126.7) 146.81,127.23 146.81,127.33 147.61,128.13 147.61,128.91 148.1,129.4 148.42,129.4
  BOTTOM w0.14: 148.42,129.4 150.59,129.4 R528.1
SIO_EXT_SMI#: length 110.4
  TOP w0.14: R160.1 165.06,117.84 164.09,118.81 v1(162.98,118.81) ; v1(151.98,62.21) 151.14,63.05 150.45,63.05 150,62.59 150,61.63 149.06,60.69 141.11,60.69 140.94,60.53 U32.15
  IN1 w0.114: v1(162.98,118.81) 162.98,118.84 157.35,124.46 156.3,124.46 154.83,125.93 152.71,125.93 152.42,125.65 150.77,125.65 149.95,126.48 148.04,126.48 147.06,125.5 146.83,125.5 146.67,125.33 143.65,125.33 142.5,124.19 v1(142.4,124.19)
  IN2 w0.114: v1(151.98,62.21) 151.98,62.59 152.82,63.43 153.75,63.43 154.05,63.73 154.05,64.33 153.76,64.63 153.76,67.39 155.07,68.71 155.07,69.07 155.63,69.63 156.05,69.63 156.84,70.42 156.84,74.38 158.64,76.18 158.64,79.67 161.06,82.09 161.06,86.28 162.01,87.23 162.01,93.94 165.69,97.62 165.69,106.83 162.46,110.06 161.11,110.06 160.66,110.51 160.66,111.07 160.09,111.63 160.09,114.22 159.81,114.5 159.81,116.16 161.24,117.59 162.26,117.59 162.52,117.84 162.52,118.35 v1(162.98,118.81)
  BOTTOM w0.14: U45.K4 142.67,124.19 v1(142.4,124.19)
SIO_RCIN#: length 87
  TOP w0.14: v1(143.17,119.48) 143.61,119.05 144.68,119.05 145.02,119.39 148.26,119.39 R139.1 ; v1(142.07,65.01) 141.52,65.01 141.44,64.93 U32.4
  IN3 w0.089: v1(142.07,65.01) 142.07,65.39 143.34,66.66 146.39,66.66 147.65,67.92 147.65,69.82 149.13,71.3 153.36,71.3 154.21,72.15 154.79,72.15 156.3,73.65 156.3,73.72 157.11,74.53 157.74,74.53 161.21,78 161.21,78.12 162.42,79.33 162.42,80.12 160.73,81.81 160.73,86.15 158.73,88.15 158.73,88.66 158.63,88.77 158.63,90.62 157.88,91.36 157.27,91.36 153.57,95.06 151.09,95.06 150.25,95.91 150.25,99.07 148.65,100.66 148.65,101.1 146.64,103.11 146.22,103.11 145.37,103.95 145.37,105.77 145.11,106.03 145.11,109.36 145.54,109.79 145.54,110.65 145.94,111.05 145.94,111.69 146.29,112.04 146.29,114.41 146.52,114.64 146.52,115.69 144.25,117.96 144.25,118.41 v1(143.17,119.48)
  BOTTOM w0.089: U45.V4 142.87,119.79 v1(143.17,119.48)
SKU_ID0: length 11.2
  BOTTOM w0.076: 148.17,118.98 148.05,119.1 147.87,119.1 147.47,119.5 146.02,119.5 145.62,119.11 U45.Y1
  BOTTOM w0.14: 148.17,118.98 148.18,118.97 149.83,118.97 150.16,118.64 151.41,118.64 151.51,118.54 152.17,118.54 152.61,118.98 153.5,118.98 153.64,118.85 R587.2 R588.1
SKU_ID1: length 10.1
  TOP w0.14: R101.1 148.29,127.09 R104.2 147.15,126.86 146.34,126.04 v1(145.19,126.04) 144.87,126.04 143.88,125.06 143.88,123.69 143.46,123.26 v1(142.4,123.26)
  BOTTOM w0.102: U45.N5 142.19,123.08 142.37,123.26 v1(142.4,123.26)
SM_INTRUDER#: length 12.2
  BOTTOM w0.076: 144.36,106.03 143.85,106.03 143.48,106.4 142.44,106.4 141.74,107.1 141.74,108.56 141.8,108.62 141.8,109.08
  BOTTOM w0.089: 141.8,109.08 U45.AU6
  BOTTOM w0.14: 144.36,106.03 145.7,104.68 147.4,104.68 148.06,104.02 148.07,104.02 149.31,102.78 R665.2
SM_RCOMP_0: length 10.2
  TOP w0.381: v1(108.05,109.9) 107.72,109.9 107.43,110.19 v1(105.75,110.19) 100.01,110.19 99.56,109.75 v1(99.56,109.63)
  BOTTOM w0.178: v1(108.05,109.9) 108.26,109.7 U45.AU60
  BOTTOM w0.381: R639.2 99.52,109.67 v1(99.56,109.63)
SM_RCOMP_1: length 8.5
  TOP w0.381: v1(101.33,106.79) 102.83,106.79 v1(103.59,107.55) 104.6,108.56 v1(107.78,108.56)
  BOTTOM w0.178: U45.AV60 107.97,108.75 v1(107.78,108.56)
  BOTTOM w0.381: R645.1 100.55,106.79 v1(101.33,106.79)
SM_RCOMP_2: length 5.6
  BOTTOM w0.241: U45.AU61 107.41,109.81 105.9,109.81
  BOTTOM w0.381: 105.9,109.81 104.78,108.7 R640.2
SMB0ALERT#: length 11.5
  BOTTOM w0.076: U45.AL2 144.17,113.14 144.6,113.57 145.01,113.57 145.1,113.48 146.94,113.48 147.02,113.39
  BOTTOM w0.14: 147.02,113.39 147.82,113.39 148.1,113.12 151.88,113.12 152.1,112.89 152.31,112.89 154.2,110.99 R636.2
SMB1ALERT#: length 12.9
  BOTTOM w0.076: U45.AU4 143.21,109.06 143.21,108.57 143.33,108.45 143.7,108.45 143.83,108.31 143.83,107.64 143.89,107.58 143.89,107.28 144.12,107.04 145.25,107.04
  BOTTOM w0.14: R651.2 152.37,105.14 148.73,105.14 148.04,105.83 148.04,105.93 147.56,106.41 145.88,106.41 145.25,107.04
SMB_ME0_CLK: length 13.2
  TOP w0.14: v1(146.91,110.17) 146.87,110.17 146.44,110.6 146.44,110.93 147.07,111.57 147.52,111.57 148.79,112.84 148.79,113.28 149.54,114.03 151.82,114.03 152.08,113.78 152.49,113.78 152.98,113.29 v1(152.98,113.12)
  BOTTOM w0.076: U45.AN1 145.01,111.61 145.11,111.52 145.22,111.52 145.88,110.85 146.23,110.85 v1(146.91,110.17)
  BOTTOM w0.14: v1(152.98,113.12) 152.99,113.12 153.01,113.14 R622.2
SMB_ME0_DAT: length 3.5
  BOTTOM w0.076: 147.66,113.65 145.17,113.65 144.96,113.86 U45.AK1
  BOTTOM w0.14: R619.2 147.66,113.65
SMB_ME1_CLK: length 31.6
  TOP w0.14: R260.2 145.3,93.69 Q19.4 145.29,94.67 144.99,94.97 R242.2 143.98,94.97 143.72,95.23 143.72,96 144.41,96.68 v1(144.41,96.86) 144.41,97.01 145.39,98 148.19,98 148.5,98.31 152,98.31 152.29,98.6 152.29,99.74 152.82,100.26 152.82,100.95 152.13,101.64 152.13,102.07 151.01,103.18 151.01,104.46 149.97,105.51 148.99,105.51 146.57,107.93 v1(146.44,107.93)
  BOTTOM w0.076: v1(146.44,107.93) 145.9,107.93 145.64,108.19 145.64,108.46 145.02,109.09 144.69,109.09 144.68,109.1 143.84,109.1 U45.AU3
SMB_ME1_DAT: length 35.1
  TOP w0.14: v1(146.06,114.77) 145.87,114.58 145.87,112.21 145.16,111.5 145.16,110.05 145.63,109.58 146.21,109.58 146.55,109.24 146.55,109.07 149.32,106.3 151.84,106.3 152.54,105.6 152.54,101.79 153.21,101.11 153.21,100.1 152.76,99.66 v1(152.76,99.17) 152.76,98.46 152.22,97.91 148.66,97.91 148.27,97.52 R240.2 147.03,97.38 146.59,96.94 Q19.1 146.59,95.11 146.97,94.73 R243.2
  BOTTOM w0.076: U45.AH3 143.78,114.32 144.3,114.32 144.47,114.49 144.47,114.67 144.7,114.9 145.92,114.9 v1(146.06,114.77)
SMB_PCH_CLK: length 30.7
  TOP w0.14: v1(147.38,108.9) 147.38,108.79 149.48,106.69 152.08,106.69 152.93,105.84 152.93,101.95 153.6,101.28 153.6,99.94 153.23,99.57 153.23,98.36 152.39,97.52 149.79,97.52 148.83,96.55 148.83,94.88 149.18,94.52 150.35,94.52 150.53,94.34 Q20.6 150.53,93.13 150.83,92.82 R255.2
  BOTTOM w0.076: v1(147.38,108.9) 147.38,109.1 146.52,109.97 145.88,109.97 145.6,110.25 145.6,110.44 145.14,110.91 145.14,110.98 144.95,111.16 144.69,111.16 144.4,110.86 U45.AP2
SMB_PCH_DAT: length 37.6
  TOP w0.14: R244.2 151,94.93 149.36,94.93 149.23,95.06 Q20.3 149.23,96.4 149.96,97.13 152.6,97.13 v1(154.01,98.54) 154.39,98.92 154.39,100.95 154.01,101.33 154.01,106.03 152.89,107.15 152.89,107.88 153.86,108.85 153.86,111.33 153.69,111.5 153.69,113.46 152.26,114.89 151.75,114.89 150.96,115.68 150.58,115.68 150.38,115.48 149.35,115.48 148.6,114.74 148.6,114.39 147.96,113.75 146.92,113.75 146.77,113.9 v1(146.77,114.23)
  BOTTOM w0.076: v1(146.77,114.23) 145.98,114.23 145.48,114.74 144.95,114.74 U45.AH1
SMBALERT#: length 16.5
  IN1 w0.114: v1(146.34,111.46) 146.45,111.35 146.45,109.33 146.64,109.14 146.64,108.57 147.15,108.06 148.05,108.06 149.46,106.65 154,106.65 v1(155.28,107.93)
  BOTTOM w0.076: U45.AN2 144.27,111.71 144.28,111.71 144.63,112.07 145.02,112.07 145.17,111.92 145.87,111.92 v1(146.34,111.46)
  BOTTOM w0.14: v1(155.28,107.93) 155.16,108.05 R643.1
SP5: length 72.5
  TOP w0.14: U24.18 206.23,89.21 206.15,89.13 204.95,89.13 v1(202.03,86.22)
  IN1 w0.114: v1(222.72,38.85) 221.57,39.99 221.57,46.92 222.51,47.86 222.51,59.66 219.4,62.77 218.33,62.77 217.96,63.14 217.96,66.04 214.35,69.64 210.5,69.64 209.45,70.69 207.72,70.69 204.54,73.88 204.54,77.09 201.17,80.46 201.17,85.36 v1(202.03,86.22)
  BOTTOM w0.14: R786.1 v1(222.72,38.85)
SP6: length 70.9
  TOP w0.14: v1(202.66,86.22) 202.66,86.29 205.08,88.71 U24.19
  IN1 w0.114: v1(222.5,40.89) 221.95,41.43 221.95,43.04 222.87,43.96 222.87,59.82 219.13,63.56 219.13,65.38 214.51,70.01 211.79,70.01 211.67,70.14 211.67,70.98 211.54,71.1 211.16,71.1 211.03,70.98 211.03,70.14 210.91,70.01 210.65,70.01 209.56,71.1 207.83,71.1 204.9,74.03 204.9,77.24 201.54,80.61 201.54,85.1 v1(202.66,86.22)
  BOTTOM w0.14: R783.1 v1(222.5,40.89)
SP7: length 71.5
  TOP w0.14: v1(203.29,86.22) 205.28,88.21 U24.20
  IN1 w0.114: v1(203.29,86.22) 201.95,84.88 201.95,81.41 206,77.35 206,73.45 207.94,71.52 211.92,71.52 212.05,71.39 212.05,70.51 212.18,70.38 212.97,70.38 213.1,70.51 213.1,71.36 213.22,71.49 213.57,71.49 213.69,71.36 213.69,70.51 213.83,70.38 214.67,70.38 219.57,65.47 219.57,63.65 223.26,59.96 223.26,41.51 223.13,41.39 222.72,41.39 222.59,41.51 v1(222.59,42.78)
  BOTTOM w0.14: v1(222.59,42.78) 222.72,42.65 R779.1
SP8: length 67.9
  TOP w0.14: v1(203.92,86.22) 205.42,87.71 U24.21
  IN1 w0.114: v1(203.92,86.22) 203.92,86.09 202.4,84.57 202.4,83.26 202.52,83.14 203.79,83.14 203.92,83.01 203.92,82.66 203.79,82.53 202.52,82.53 202.4,82.41 202.4,82.03 202.52,81.9 203.79,81.9 203.92,81.77 203.92,81.39 203.79,81.26 203.16,81.26 203.03,81.14 203.03,80.86 206.38,77.51 206.38,75.63 207.84,74.17 211.95,74.17 220.84,65.28 220.84,63.45 224.01,60.29 224.01,55.36 224.13,55.23 225.89,55.23 226.02,55.1 226.02,54.59 225.89,54.47 224.13,54.47 224.01,54.34 224.01,53.83 224.13,53.7 225.89,53.7 226.02,53.58 226.02,53.07 225.89,52.94 224.13,52.94 224.01,52.82 224.01,52.42 v1(224.49,51.93)
  BOTTOM w0.14: R762.1 223.61,51.05 223.61,51.55 223.99,51.93 v1(224.49,51.93)
SP9: length 72.4
  TOP w0.14: U24.22 210.62,87.21 210.52,87.31 205.65,87.31 v1(204.56,86.22)
  IN1 w0.114: v1(224.53,61.02) 223.8,61.02 221.21,63.6 221.21,65.46 212.07,74.6 207.93,74.6 206.75,75.78 206.75,77.67 204.3,80.11 204.3,83.01 204.43,83.14 205.2,83.14 205.33,83.26 205.33,83.84 205.2,83.96 203.16,83.96 203.03,84.09 203.03,84.44 203.16,84.57 205.2,84.57 205.33,84.69 205.33,85.07 205.2,85.2 204.17,85.2 204.05,85.33 204.05,85.58 204.56,86.09 v1(204.56,86.22)
  BOTTOM w0.14: v1(224.53,61.02) 226.27,61.02 226.4,61.15 226.4,61.83 226.27,61.96 222.89,61.96 222.77,61.83 222.77,54.78 222.64,54.65 221.57,54.65 221.45,54.52 221.45,54.09 221.57,53.96 222.64,53.96 222.77,53.83 222.77,53.32 222.64,53.2 221.57,53.2 221.45,53.07 221.45,52.56 221.57,52.43 223.47,52.43 223.6,52.56 R758.1
SP10: length 71.6
  TOP w0.14: v1(205.19,86.22) 205.85,86.88 210.4,86.88 210.56,86.71 U24.23
  IN1 w0.114: v1(224.53,59.75) 224.88,59.75 225,59.88 225,61.35 224.88,61.48 223.86,61.48 223.73,61.6 223.73,61.96 223.86,62.09 224.89,62.09 225.02,62.21 225.02,62.59 224.89,62.72 222.72,62.72 222.59,62.85 222.59,63.23 222.72,63.36 224.89,63.36 225.02,63.48 225.02,63.86 224.89,63.99 224.24,63.99 224.11,64.12 224.11,64.63 223.99,64.75 223.43,64.75 223.31,64.88 223.31,65.26 223.43,65.39 224.91,65.39 225.03,65.52 225.03,65.9 224.91,66.02 221.17,66.02 218.53,68.67 218.53,69.58 218.4,69.71 217.51,69.71 217.38,69.83 217.38,70.21 217.51,70.34 218.4,70.34 218.53,70.47 218.53,70.9 218.4,71.03 216.16,71.03 212.22,74.97 208.08,74.97 207.11,75.94 207.11,77.82 204.68,80.25 204.68,80.76 204.81,80.88 205.59,80.88 205.72,81.01 205.72,81.39 205.59,81.52 204.81,81.52 204.68,81.64 204.68,82.64 204.81,82.77 205.57,82.77 205.7,82.9 205.7,85.71 v1(205.19,86.22)
  BOTTOM w0.14: R753.1 223.17,56.41 223.17,60.31 223.3,60.44 225.89,60.44 226.02,60.31 226.02,59.88 225.89,59.75 v1(224.53,59.75)
SP12: length 66.9
  TOP w0.14: v1(207.22,73.9) 207.22,75.26 209.29,77.33 210.24,77.33 211.03,78.11 211.03,79.1 212.53,80.6 212.63,80.6 212.98,80.95 U24.35
  IN1 w0.114: v1(207.22,73.9) 207.31,73.81 211.77,73.81 219.95,65.62 219.95,63.82 223.64,60.14 223.64,51.42 223.76,51.29 225.13,51.29 225.26,51.16 225.26,50.66 225.13,50.53 223.76,50.53 223.64,50.4 223.64,49.89 223.76,49.77 225.13,49.77 225.26,49.64 225.26,49.26 225.13,49.13 223.76,49.13 223.64,49.01 223.64,48.24 223.76,48.12 225.13,48.12 225.26,47.99 225.26,47.61 225.13,47.48 223.76,47.48 223.64,47.35 223.64,46.18 224.53,45.29 224.53,43.7 223.86,43.04 223.86,38.85 v1(222.72,37.7)
  BOTTOM w0.14: R788.1 v1(222.72,37.7)
SP13: length 68.1
  TOP w0.14: v1(219.67,68.69) 219.67,71.1 222.21,73.64 v1(223.1,73.64) 223.99,73.64 225.89,75.55 225.89,81.26 225.97,81.34 225.97,84.34 225.43,84.87 221.17,84.87 221.01,84.71 U24.54
  IN1 w0.114: v1(219.67,68.69) 221.69,66.67 226.91,66.67 227.03,66.54 227.03,65.13 226.91,65.01 224.62,65.01 224.49,64.88 224.49,64.5 224.62,64.37 226.27,64.37 226.4,64.25 226.4,63.74 226.27,63.61 225.53,63.61 225.4,63.48 225.4,62.54 225.53,62.41 227.03,62.41 227.16,62.28 227.16,61.83 227.03,61.71 225.53,61.71 225.4,61.58 225.4,61.07 225.53,60.94 227.03,60.94 227.16,60.82 227.16,60.44 227.03,60.31 225.53,60.31 225.4,60.18 225.4,59.67 225.53,59.55 227.03,59.55 227.16,59.42 227.16,58.91 227.03,58.78 225.53,58.78 225.4,58.66 225.4,58.15 225.53,58.02 227.03,58.02 227.16,57.9 227.16,56.12 227.03,55.99 224.66,55.99 224.53,56.12 v1(224.53,59.12)
  BOTTOM w0.14: R748.1 223.6,58.99 223.72,59.12 v1(224.53,59.12)
SP_PLLVDD: length 1.4
  BOTTOM w0.381: v1(43.42,123.68) 43.84,124.1 U43.N6 U43.M6
  vias: v1(43.27,122.03)
SPD_A0: length 5.9
  BOTTOM w0.14: R764.1 123.49,48.7 122.28,48.7 R763.2 v1(120.79,48.17) 119.97,47.35 118.89,47.35
SPD_A1: length 4.5
  BOTTOM w0.14: R771.1 121.79,46.21 121.74,46.26 R768.2 v1(120.79,46.85) 120.61,46.85 119.85,46.08 U55.2
SPD_A2: length 4
  BOTTOM w0.14: R777.1 R773.2 v1(120.74,44.56) 120.35,44.56 120.1,44.81 118.89,44.81
SPD_CLK_SCLK: length 2.9
  BOTTOM w0.14: 113.43,44.81 v1(111.59,44.81) R772.2
SPD_CLK_SDATA: length 2.9
  BOTTOM w0.14: R776.2 v1(111.59,43.54) U55.5
SPI_CLK_8M: length 8.5
  TOP w0.14: v1(149.69,130.77) 149.89,130.97 152.21,130.97 152.36,130.82 U14.6 152.36,128.01 R102.2 153.15,127.22 153.15,126.38 R112.1
SPI_CS0#_UR_ME: length 99.1
  TOP w0.14: v1(152.61,66.61) 152.64,66.64 U32.101 ; R80.2 149.56,137.52 R85.1 149.06,137.16 148.57,137.65 148.14,137.65 146.21,135.72 146.21,133.56 145.86,133.21 143.82,133.21 v1(143.21,132.6)
  IN1 w0.114: v1(166.91,86.14) 166.63,86.14 164.3,83.8 164.3,79.64 160.9,76.24 160.9,74.51 157.55,71.15 157.55,69.89 157.21,69.55 157.21,68.97 156.36,68.12 156.36,67.61 155.41,66.66 152.66,66.66 v1(152.61,66.61)
  IN3 w0.089: v1(166.91,86.14) 167,86.23 167,90.21 162.35,94.86 162.35,95.15 161.79,95.71 161.79,96.33 158.26,99.85 158.26,103.71 158.96,104.41 158.96,105.9 158.48,106.38 158.48,109.3 157.59,110.19 157.59,111.94 155.77,113.76 155.77,114.6 154.31,116.06 154.31,116.57 154.1,116.79 153,116.79 152.57,117.21 152.57,118.13 152.1,118.6 151.15,118.6 150.16,119.59 150.16,121.69 149.82,122.03 149.24,122.03 148.85,122.42 148.85,125.41 147.95,126.31 147.95,127.04 147.37,127.62 147.37,127.75 147.37,127.75 147.37,128.66 146.41,129.61 146.41,131.4 145.22,132.6 v1(143.21,132.6)
SPI_HOLD_IO3_ME: length 4.7
  TOP w0.14: U14.7 153.63,129.14 154.01,128.76 154.34,128.76 v1(154.97,128.13) 154.97,128.13 154.97,127.45 R106.1 R105.2
SPI_SI_8M: length 4.3
  TOP w0.14: R111.1 151.19,125.88 v1(151.19,127.16) 151.22,127.2 R100.2 151.22,128.76 151.09,128.9 U14.5
SPI_SO_8M: length 4
  TOP w0.14: v1(153.37,141.41) R75.2 R78.2 153.63,139.17 U14.2
SPI_WP_IO2_ME: length 4.1
  TOP w0.14: U14.3 152.36,139.06 R77.2 R74.2 151.99,141.37 v1(152.08,141.46)
SPKR: length 142.4
  TOP w0.14: D19.2 v1(221.01,39.73)
  IN1 w0.114: v1(221.01,39.73) 221.01,47.06 222.01,48.06 222.01,59.46 219.2,62.27 218.13,62.27 217.46,62.93 217.46,65.83 214.15,69.15 210.27,69.15 209.27,70.15 207.56,70.15 203.95,73.77 203.95,74.69 203.41,75.22 203.41,76.95 201.27,79.08 191.5,79.08 187.92,82.66 182.46,82.66 181.09,84.02 177.58,84.02 172.72,88.88 165.57,88.88 164.93,88.25 162.26,88.25 v1(160.74,89.77)
  IN3 w0.089: v1(160.74,89.77) 160.35,90.16 160.35,91.3 152.78,98.87 152.78,99.51 151.82,100.46 151.82,102.76 149.44,105.14 147.41,105.14 147.03,105.51 147.03,106.16 147.8,106.92 147.8,109.23 147.69,109.33 147.69,111.15 148.99,112.45 148.99,115.81 148.52,116.28 148.52,118.89 147.41,120 v1(147.1,120)
  BOTTOM w0.076: v1(147.1,120) 146.81,120.29 146.3,120.29 146.07,120.06 146.07,120.03 145.48,119.44 145.17,119.44 145.05,119.56 144.47,119.56 U45.V2
  BOTTOM w0.14: v1(147.1,120) 147.28,120 147.41,119.87 147.66,119.87 148.04,119.49 R580.2
SRTC_RST#: length 75.7
  TOP w0.14: v1(128.96,66.84) 129.14,66.84 129.73,66.25 R722.2 130.63,65 C710.1
  IN2 w0.114: v1(145.5,66.1) 146.49,66.1 147.2,65.39 148.68,65.39 149.28,66 149.28,67.06 151.22,68.99 151.22,71.99 151.47,72.25 151.47,72.63 151.22,72.88 151.22,74.91 149.44,76.69 149.44,79.49 150.45,80.5 150.45,83.8 151.09,84.44 151.09,86.1 147.53,89.66 147.53,91.64 143.61,95.56 142.95,95.56 139.6,98.91 139.6,107 v1(141.07,108.47)
  BOTTOM w0.076: U45.AV6 141.21,108.47 v1(141.07,108.47)
  BOTTOM w0.14: v1(128.96,66.84) 132,66.84 132.27,67.11 136.7,67.11 137.09,66.72 137.68,66.72 138.13,67.17 139.53,67.17 140.06,66.63 144.33,66.63 144.87,66.1 v1(145.5,66.1)
STRAP0: length 11.4
  BOTTOM w0.102: U43.D1 51.3,119.97 51.49,119.78 51.49,119.11
  BOTTOM w0.14: v1(47.71,110.98) 47.71,112.51 R627.2 48.65,113.45 48.65,114.75 R607.1 50.24,117.2 50.76,117.2 51.49,117.94 51.49,119.11
STRAP1: length 13.1
  BOTTOM w0.102: U43.D2 51.3,120.55 50.96,120.2 50.96,119.92 51.2,119.68 51.2,119.11
  BOTTOM w0.14: v1(46.44,110.98) 46.44,112.39 R626.1 46.62,113.48 46.62,114.72 R606.1 48.51,116.62 49.16,116.62 50.12,117.59 50.63,117.59 51.2,118.16 51.2,119.11
STRAP2: length 14.3
  BOTTOM w0.102: 46.9,119.11 46.95,119.11 48.38,120.54 48.38,120.93 48.73,121.28 49.05,121.28 49.2,121.42 49.2,121.75 49.49,122.04 49.72,122.04 50.14,122.46 U43.E4
  BOTTOM w0.14: v1(43.89,112.12) R623.2 R618.2 43.89,114.67 43.44,115.12 43.44,115.66 44,116.21 44,116.82 45.49,118.31 46.1,118.31 46.9,119.11
STRAP3: length 12.5
  BOTTOM w0.102: U43.E3 50.86,121.25 50.86,120.59 50.66,120.39 50.66,119.93 50.94,119.65 50.94,119.11
  BOTTOM w0.14: R625.1 46.36,113.45 46.36,114.75 R605.1 v1(46.93,116.18) 47.62,116.87 49.03,116.87 50,117.84 50.38,117.84 50.94,118.4 50.94,119.11
STRAP4: length 12.9
  BOTTOM w0.102: 51.77,119.11 51.77,119.9 51.7,119.98 51.7,121.26 U43.D3
  BOTTOM w0.14: v1(48.98,110.98) 48.85,111.11 48.85,112.51 R628.1 48.9,113.48 48.9,114.72 R608.1 49.49,115.31 49.49,116.06 50.38,116.95 51.01,116.95 51.77,117.71 51.77,119.11
SUSACK#_R: length 7.7
  BOTTOM w0.076: R615.2 147.53,114.66 147.2,114.33 147.2,114 147.02,113.83 145.27,113.83 144.95,114.15 144.6,114.15 144.31,113.86 U45.AK2
  BOTTOM w0.14: R620.1 150.32,113.61 149.77,114.16 148.42,114.16 148.29,114.29 R615.2
SUSB#: length 100.3
  TOP w0.14: U32.82 155.03,60.53 154.55,60.05 153.63,60.05 152.87,59.29 v1(151.98,59.29)
  IN2 w0.114: v1(142.33,59.55) 143.09,58.78 147.53,58.78 148.42,57.9 149.54,57.9 149.92,58.28 149.92,58.51 150.26,58.85 150.26,59.36 150.71,59.8 151.47,59.8 v1(151.98,59.29)
  IN3 w0.089: v1(142.33,59.55) 142.33,59.67 139.57,62.43 139.57,66.93 141.61,68.97 143.27,68.97 145.55,71.26 145.55,72.79 146.71,73.95 146.71,74.77 147.36,75.42 153.38,75.42 153.92,74.89 155.85,74.89 156.73,75.77 157.33,75.77 159.75,78.19 159.75,79.66 159.41,80 159.41,82.5 159.17,82.74 159.17,86.11 156.71,88.56 156.71,90.23 154.31,92.63 153.17,92.63 151.88,93.92 150.63,93.92 149.05,95.5 149.05,96.3 147.28,98.08 147.28,99.54 146.5,100.31 144.9,100.31 144.58,100.64 144.58,101.57 142.96,103.19 142.96,103.82 142.22,104.55 142.22,105.65 142.58,106 142.58,107.81 141.94,108.44 141.94,109.38 v1(142.38,109.81) ; v1(151.98,59.29) 151.98,61.58 152.46,62.06 152.46,63.46 152.61,63.61 v1(152.61,64.53)
  BOTTOM w0.089: v1(142.38,109.81) 142.61,109.81 U45.AT4
  BOTTOM w0.14: R736.2 152.61,64.07 v1(152.61,64.53)
SUSC#: length 104.4
  TOP w0.14: v1(143.21,59.55) 143.21,59.72 143.7,60.21 149.46,60.21 150.64,61.39 150.64,62 150.86,62.21 v1(150.86,62.19) 151.04,62.01 151.04,60.82 151.55,60.31 154.43,60.31 155.05,60.93 U32.83
  IN3 w0.089: v1(141.08,114.69) 141.48,114.28 142.45,114.28 142.64,114.09 143.9,114.09 144.24,113.75 144.24,111.83 142.96,110.56 142.96,106 142.41,105.46 142.41,104.63 143.15,103.89 143.15,103.27 144.77,101.65 144.77,100.71 144.87,100.61 146.47,100.61 146.78,100.3 146.79,100.3 147.3,99.79 147.85,99.79 148.55,99.09 148.55,97.07 149.24,96.38 149.24,95.58 150.71,94.11 151.96,94.11 153.25,92.82 154.42,92.82 156.9,90.33 156.9,88.64 159.36,86.19 159.36,82.82 159.6,82.58 159.6,80.08 159.94,79.74 159.94,78.11 157.41,75.58 156.81,75.58 155.93,74.7 153.84,74.7 153.3,75.23 147.43,75.23 146.9,74.69 146.9,73.87 145.75,72.72 145.75,71.01 145.49,70.74 145.49,69.31 144.8,68.63 142.52,68.63 139.76,65.87 139.76,63 v1(143.21,59.55)
  BOTTOM w0.102: U45.AJ6 141.54,114.23 v1(141.08,114.69)
  BOTTOM w0.14: v1(150.86,62.19) 150.45,62.59 150.45,63.23 150,63.68 R734.2
SUSLED#: length 231.8
  TOP w0.203: v1(138.92,54.62) 138.92,54.87 139.38,55.33 U32.28
  TOP w0.254: R32.1 11.52,155.43 v2(11.64,155.3) 11.52,155.18 R45.1
  IN3 w0.254: v2(11.64,155.3) 11.41,155.08 11.41,152.95 13.83,150.53 13.83,144.99 19.39,139.43 19.39,128.56 22.18,125.77 22.18,121.17 25.26,118.09 26.37,118.09 27.39,117.08 27.39,115.89 29.5,113.78 31.07,113.78 31.33,113.52 31.33,112.35 33.08,110.6 33.08,107.78 32.34,107.04 32.34,103.23 33.14,102.44 33.14,99.95 34.29,98.8 34.29,95.44 35.37,94.36 35.37,86.85 33.65,85.14 33.65,83.18 31.86,81.39 31.86,78.55 32.96,77.45 32.96,66.61 33.12,66.45 33.12,56.84 33.85,56.11 33.85,53.83 35.56,52.12 35.84,52.12 36.48,51.47 48.68,51.47 50.62,49.53 59,49.53 60.48,48.05 62.95,48.05 63.58,47.42 65.66,47.42 65.97,47.11 67.87,47.11 68.44,46.54 88.98,46.54 91.76,49.32 104.65,49.32 104.97,49.63 105.69,49.63 106.38,50.32 111.68,50.32 113.04,48.96 119.66,48.96 120.2,49.5 129.02,49.5 130.64,51.13 132.35,51.13 133.36,52.13 135.88,52.13 137.56,53.81 138.12,53.81 138.92,54.61 v1(138.92,54.62)
SUSON: length 71.9
  TOP w0.14: PR111.1 194.23,50.95 v1(194.14,51.04) ; R312.1 144.36,70.06 v1(143.87,69.58) 143.84,69.55 U32.123 143.84,66.91 144.37,66.38 144.37,64.49 144.92,63.95 150.15,63.95 151.09,64.88 151.85,64.88 152.1,64.63 152.1,64.37 152.49,63.99 v1(153.63,63.99)
  IN3 w0.089: v1(153.63,63.99) 154.01,63.99 155.03,65.01 155.58,65.01 156.41,65.84 157.75,65.84 158.07,65.52 160.99,65.52 163.03,63.48 163.03,53.45 166.46,50.02 193.13,50.02 v1(194.14,51.04)
SYS_COM_REQ: length 55.3
  TOP w0.14: R137.1 147.9,120.76 147.45,120.76 v1(147.19,121.02) 146.69,121.52 TP39.1 ; v1(103.59,124.44) 103.61,124.44 v1(104.24,123.81)
  IN1 w0.114: v1(104.24,123.81) 104.43,123.81 104.94,123.3 108.54,123.3 110.07,121.78 110.96,121.78 114.51,125.33 122.26,125.33 124.45,123.14 129.78,123.14 130.98,121.95 131.6,121.95 131.84,121.71 131.84,120.83 133.29,119.38 134.69,119.38 135.09,118.98 136.86,118.98 137.21,118.63 138.9,118.63 140.25,119.98 142.56,119.98 142.83,120.25 145.17,120.25 145.97,121.05 147.16,121.05 v1(147.19,121.02)
  BOTTOM w0.076: U45.U1 145.92,120.61 146.1,120.79 146.95,120.79 v1(147.19,121.02)
SYS_HWPG: length 53.4
  IN2 w0.114: v1(156.55,44.81) 158.2,44.81 160.93,47.55 160.93,50.42 161.41,50.89 161.41,53.74 163.15,55.48 163.15,57.34 164.04,58.23 164.04,61.58 164.5,62.04 165.64,62.04 165.95,62.34 179.16,62.34 179.92,63.1 190.58,63.1 v1(191.6,64.12)
  BOTTOM w0.14: v1(156.55,44.81) 156.55,44.1 156.38,43.93 D37.1 ; v1(191.6,64.12) PR199.2
SYS_PEX_RST_MON#: length 15.4
  TOP w0.14: R170.1 54.7,115.56 54.7,123.05 TP22.1 52.76,124.98 51.36,124.98 51.11,125.23 51.11,126.05 50.12,127.04 v1(50.08,127.04)
  BOTTOM w0.102: v1(50.08,127.04) 50.1,127.04 U43.E9
SYS_PWROK: length 161.4
  TOP w0.14: R261.1 87.41,91.02 87.41,90.05 83.7,86.34 82.17,86.34 81.35,85.52 81.35,84.86 v1(81.39,84.82)
  IN3 w0.089: v1(157.69,69.43) 160.03,69.43 165.9,75.29 165.9,77.2 166.46,77.76 166.46,83.2 164.41,85.25 164.41,86.9 163.79,87.52 162.6,88.71 162.6,91.4 157.12,96.88 157.12,97.58 v1(154.9,99.81) 154.9,99.93 154.45,100.38 154.45,101.05 153.96,101.54 153.96,105.09 155.39,106.52 155.64,106.52 156.5,107.38 156.5,109.56 155.7,110.36 155.7,111.7 155.7,112.47 152.43,115.73 v1(152.05,115.73)
  BOTTOM w0.14: v1(152.05,115.73) 151.72,116.06 R601.1 ; v1(81.39,84.82) 81.43,84.78 83.54,84.78 95.08,73.24 102.65,73.24 103.1,72.79 115.75,72.79 116.91,71.62 126.41,71.62 128.54,69.5 135.79,69.5 137.08,68.21 144.13,68.21 146.55,70.63 153.09,70.63 153.42,70.29 154.06,70.29 154.73,69.62 157.52,69.62 157.69,69.45 v1(157.69,69.43) ; R673.1 154.14,100.18 154.52,99.81 v1(154.9,99.81) 154.9,99.54 R683.1 R687.1 155.14,97.9 155.15,97.89 U47.4
SYS_PWROK_R: length 31.6
  IN1 w0.114: v1(147.66,115.5) 148.43,115.5 148.64,115.29 150.19,115.29 150.71,115.81 151.34,115.81 151.85,116.32 152.42,116.32 154.83,113.9 155.14,113.9 157.44,111.61 157.44,110.41 158.71,109.14 158.71,106.66 158.02,105.98 158.02,102.17 v1(157.44,101.58)
  BOTTOM w0.076: U45.AG2 144.31,115.36 144.6,115.65 145.01,115.65 145.27,115.91 145.73,115.91 146.62,115.02 147.18,115.02 v1(147.66,115.5)
  BOTTOM w0.14: v1(157.44,101.58) R666.1 ; v1(147.66,115.5) 147.66,115.53 148.07,115.93 C660.2 148.81,115.41 149.67,115.41 R601.2
SYS_RESET#: length 258.4
  TOP w0.14: v1(82.75,104.5) 82.75,105.51 83.66,106.42 R195.2
  IN1 w0.114: v1(156.83,99.88) 157.36,100.42 157.79,100.42 158.52,101.14 158.52,104.5 158.88,104.86 158.88,105.94 159.22,106.28 159.22,109.34 157.95,110.61 157.95,111.82 155.43,114.33 155.43,114.89 155.12,115.2 154.23,115.2 152.14,117.3 152.14,118.67 v1(151.77,119.03) ; v1(155.15,67.62) 151.8,67.62 150.71,66.53 149.06,66.53 148.3,65.77 147.66,65.77 147.28,65.39 147.28,64.5 146.9,64.12 146.25,64.12 144.94,62.81 144.94,62.11 v1(145.37,61.68)
  IN2 w0.114: v1(146.92,118.75) 147.2,118.75 147.56,119.11 148.8,119.11 149.18,118.73 151.47,118.73 v1(151.77,119.03)
  IN3 w0.089: v1(155.15,67.62) 156.92,67.62 157.76,68.46 160.92,68.46 164.38,71.92 165.71,71.92 167.47,73.68 167.47,83.65 165.54,85.57 165.54,89.79 158.07,97.25 158.07,98.03 156.83,99.27 v1(156.83,99.88) ; v1(145.37,61.68) 145.37,61.6 145.22,61.45 145.22,60.16 143.7,58.63 142.86,58.63 142.68,58.45 140.7,58.45 139.02,60.13 136.85,60.13 134.26,57.54 133.86,57.54 131.76,55.44 130.08,55.44 128.18,53.55 125.87,53.55 125.41,53.09 124.69,53.09 123.83,53.95 117.84,53.95 117.27,53.39 115.97,53.39 114.66,54.7 111.87,54.7 111.3,55.27 109.8,55.27 109.13,54.59 105.6,54.59 104.62,53.61 103.66,53.61 103.03,54.23 98.22,54.23 96.89,52.9 89.8,52.9 88.58,51.68 82.21,51.68 81.96,51.43 80.62,51.43 80.13,50.95 78.7,50.95 77.94,50.19 71.42,50.19 70.38,51.22 65.37,51.22 65.11,51.48 63.99,51.48 63.08,52.39 62.78,52.39 62.4,52.77 62.4,53.19 61.54,54.05 61.54,54.52 60.23,55.83 60.23,59.14 60.51,59.42 60.51,62.25 60.79,62.53 60.79,64.48 60.65,64.63 60.65,68.93 61.68,69.96 61.68,73.09 63.53,74.93 64.06,74.93 64.39,75.26 68.24,75.26 76.97,83.99 76.97,90.71 78.83,92.57 78.83,99.13 82.34,102.65 82.34,104.1 v1(82.75,104.5)
  BOTTOM w0.076: U45.AC3 143.8,117.29 143.91,117.29 143.96,117.23 144.31,117.23 144.4,117.32 145.01,117.32 145.14,117.19 146.12,117.19 146.57,117.64 146.57,118.4 v1(146.92,118.75)
  BOTTOM w0.14: v1(151.77,119.03) 152.23,119.49 R581.1 ; R728.2 145.6,64.06 145.17,63.64 145.17,62.72 144.92,62.47 144.92,62.14 v1(145.37,61.68)
SYS_SHDN#: length 318.4
  TOP w0.14: Q9.3 97.11,133.46 95.98,132.33 94.2,132.33 93.68,131.81 93.68,129.14 93.05,128.51 v1(92.16,128.51)
  TOP w0.208: v1(195.41,66.56) 195.41,66.25 195.63,66.04 PU5.6
  IN1 w0.114: v1(195.41,66.56) 195.56,66.4 197.67,66.4 v1(198.79,67.52) 199.2,67.93 203.92,67.93 204.56,67.29 208.37,67.29 212.3,63.36 212.3,53.45 212.81,52.94 212.81,51.8 211.16,50.15 204.68,50.15 202.27,47.74 196.43,47.74 v1(194.78,49.39)
  IN3 w0.089: v1(107.14,45.19) 107.39,45.19 107.93,44.65 123.84,44.65 124.32,45.13 131.91,45.13 132.34,44.7 133.83,44.7 135.46,46.33 136.23,46.33 138.34,48.43 142.96,48.43 144.6,50.07 148.85,50.07 150.96,52.18 155.66,52.18 156.3,52.82 158.33,52.82 160.13,51.01 164.41,51.01 166.03,49.39 v1(194.78,49.39) ; v1(59.95,52.13) 59.95,52.26 57.36,54.85 57.36,59.51 57.09,59.78 57.09,61.85 58.15,62.91 58.15,66.07 58.07,66.15 58.07,67.72 57.48,68.31 57.48,72.43 58.33,73.29 58.33,74.71 59.64,76.02 60.13,76.02 61.53,77.42 62.87,77.42 63.87,78.41 68.11,78.41 70.75,81.05 70.75,83.07 71.43,83.75 71.43,91.65 v1(71.69,91.91)
  BOTTOM w0.14: v1(92.16,128.51) 92.53,128.14 92.53,123.13 92.23,122.82 88.89,122.82 84.03,117.97 84.03,110.98 86.5,108.52 86.5,104.33 PQ34.3 86.45,102.6 82.99,102.6 76.13,95.74 76.13,94.93 74.44,93.24 73.02,93.24 v1(71.69,91.91) ; PR191.2 198.85,67.58 v1(198.79,67.52) ; v1(59.95,52.13) 61.85,50.23 64.91,50.23 66.26,48.88 66.26,47.06 68.35,44.97 87.37,44.97 89.89,47.49 102.95,47.49 104.73,45.7 104.73,44.05 104.99,43.8 105.67,43.8 106.13,44.26 SW2.3 107.03,45.08 v1(107.14,45.19) 107.14,45.72 106.9,45.96 C769.1 D35.1
  BOTTOM w0.208: v1(195.41,66.56) 195.89,67.04 PR197.2
SYSTEM_AGND: length 9.2
  TOP w0.381: v1(202.68,67.34) 202.68,67.4 202.29,67.78 PR82.1
  BOTTOM w0.508: PR187.2 200.11,69.33 200.59,68.84 PR198.1 201.48,66.15 v1(202.02,66.68) v1(202.68,67.34) ; PR195.1 194.13,68.18 PR190.2 194.89,68.7 v1(194.78,68.82)
TD_IREF: length 4.7
  BOTTOM w0.203: R511.2 138.01,133.58 138.01,131.39 137.39,130.77 137.39,130.26 137.25,130.12 137.25,129.88 137.36,129.78 U45.B12
TEMP_MBAT: length 150.1
  TOP w0.14: v1(68.06,52.43) 68.06,52.36 67.5,51.8 v1(65.49,51.8) 62.32,51.8 60.92,53.2 56.09,53.2 54.38,51.49 39.77,51.49 38.62,52.64 37.96,52.64 36.81,51.49 33.3,51.49 32.47,50.66 30.31,50.66 29.42,51.55 29.42,59.17 29.8,59.55 31.33,59.55 PR98.2 32.01,60.23 PR101.1 ; U32.73 154.66,56.93 v1(153.98,56.24)
  IN1 w0.114: v1(68.06,52.43) 68.56,51.93 71.19,51.93 72.52,50.59 76.87,50.59 77.4,51.12 81.3,51.12 81.41,51.23 88.32,51.23 88.67,51.58 97.2,51.58 97.67,51.11 111.09,51.11 113.12,49.09 117.81,49.09 119.39,50.67 127.85,50.67 130.58,53.4 131.73,53.4 v1(134.45,56.12)
  BOTTOM w0.14: v1(134.45,56.12) 135.72,57.39 139.4,57.39 140.04,56.75 140.04,55.99 141.18,54.85 145.84,54.85 146.25,55.26 153,55.26 v1(153.98,56.24)
TERM0:
  vias: v1(151.82,161.15) v2(151.14,160.26) v2(151.14,159.24) v2(152.99,160.26) v2(153.76,160.26) v2(154.52,160.26)
TESTLOW_AK8: length 14.6
  TOP w0.089: v1(140.06,113.19) 140.72,112.53 140.72,110.35 140.32,109.94
  TOP w0.14: R225.2 143.72,102.88 144.26,103.42 144.26,104.67 142.51,106.43 142.51,106.7 141.96,107.25 v1(140.67,107.25) 140.28,107.64 140.28,109.9 140.32,109.94
  BOTTOM w0.102: v1(140.06,113.19) 140.09,113.19 U45.AK8
TESTLOW_AL8: length 17.4
  TOP w0.089: 140.1,110.16 140.55,110.6 140.55,112.25 140.17,112.63 v1(139.79,112.63)
  TOP w0.14: R233.2 143.72,100.77 143.24,101.25 143.24,102.75 144.02,103.53 144.02,104.57 142.82,105.77 142.53,105.77 v1(142.33,105.98) 142.2,106.11 142.2,106.67 141.87,106.99 141.26,106.99 141.06,106.79 140.47,106.79 140.04,107.22 140.04,110.09 140.1,110.16
  BOTTOM w0.102: U45.AL8 140.16,112.61 139.81,112.61 v1(139.79,112.63)
TESTLOW_C34: length 7.9
  BOTTOM w0.076: U45.C34 124.26,128.9 124.09,129.07 123.91,129.07 123.71,129.27 123.68,129.38 123.68,129.51 123.7,129.57 123.71,129.58 123.74,129.66 123.74,129.83 123.65,130.06 123.39,130.32 122.99,130.32 122.51,130.8 v1(122.51,133.13) 122.18,133.13 121.12,134.2 R505.2
TESTLOW_C35: length 7.7
  BOTTOM w0.076: R504.2 120.29,134.47 v1(121.27,133.49) 122.28,132.47 122.28,130.79 122.92,130.16 123.3,130.16 123.4,130.05 123.42,130.05 123.51,129.97 123.57,129.8 123.57,129.69 123.52,129.57 123.51,129.54 123.51,129.35 123.55,129.2 123.65,129.05 U45.C35
TESTMODE: length 11.2
  TOP w0.14: v1(29.56,124.25) 29.38,124.43 R116.1
  BOTTOM w0.102: U43.AD9 34.32,127.02 34.32,127.67 34.12,127.87 30.57,127.87
  BOTTOM w0.14: v1(29.56,124.25) 29.04,124.77 v1(29.04,127.62) 29.3,127.87 30.57,127.87
THERM+: length 1.3
  TOP w0.14: TP10.1 49.39,128.84 v1(49.26,128.72)
  BOTTOM w0.102: v1(49.26,128.72) 49.66,129.12 U43.F12
THERM-: length 1.6
  TOP w0.14: v1(50.08,129.52) 50.76,128.84 TP11.1
  BOTTOM w0.102: v1(50.08,129.52) 50.48,129.12 U43.E12
THRMTRIP#: length 16.3
  TOP w0.14: v1(101.56,132.85) 101.56,132.72 100.26,131.43 Q9.1 98.51,130.97 97.74,130.2 R96.1
  BOTTOM w0.076: U45.D60 107.97,128.27 107.51,128.73 107.51,128.94 107.18,129.28 107.18,129.49 106.98,129.68 106.56,129.68 106.34,129.9 106,129.9 105.75,129.65 105.75,129.31 105.62,129.18 104.57,129.18 103.88,129.87 103.88,131.65 102.99,132.55 102.14,132.55 101.86,132.83 101.84,132.83 101.81,132.85
  BOTTOM w0.14: v1(101.56,132.85) 101.81,132.85
TP_DC_TEST_A4: length 7
  BOTTOM w0.14: U45.A4 143.09,130.23 143.09,130.31 144.23,131.45 144.23,131.81 146.16,133.74 146.16,134.5 TP110.1
TP_DC_TEST_A60: length 8.5
  BOTTOM w0.076: TP112.1 103.64,134.68 103.64,132.62 103.92,132.33 104.59,132.33 104.71,132.22 104.71,131.35 105.43,130.63 107.59,130.63 108.1,130.13 U45.A60
TP_DC_TEST_A62: length 7.5
  BOTTOM w0.076: U45.A62 105.92,130.07 105.54,129.7 105.54,129.39 105.5,129.35 104.66,129.35 104.05,129.96 104.05,131.73 103.03,132.75 102.65,132.75 TP115.1
TP_DC_TEST_AV1: length 9.8
  BOTTOM w0.14: TP144.1 152.74,105.65 150.07,105.65 149.31,106.41 148.65,106.41 147.89,107.17 146.26,107.17 145.44,107.99 145.44,108.37 145.06,108.76 U45.AV1
TP_DC_TEST_AW1: length 5.2
  BOTTOM w0.14: TP145.1 148.65,105.65 147.63,106.66 146.01,106.66 144.82,107.85 U45.AW1
TP_DC_TEST_AW63: length 8.7
  BOTTOM w0.14: TP147.1 105.62,101.33 103.98,102.97 103.98,105.92 106.08,108.02 U45.AW63
TP_DC_TEST_AY60: length 8.2
  BOTTOM w0.14: TP146.1 104.96,102.55 104.23,103.29 104.23,105.19 106.05,107.02 107.65,107.02 U45.AY60
TP_DC_TEST_B2: length 7
  BOTTOM w0.14: U45.B2 144.53,129.78 144.99,129.78 145.5,130.29 145.5,132.57 146.49,133.56 146.49,135.21 TP111.1
TP_GND: length 6
  TOP w0.508: v1(69.58,105.98) 69.58,105.8 69.2,105.42 R194.2
  BOTTOM w0.229: CN7.6 69.55,105.88 69.58,105.85 v1(69.58,105.98) ; CN7.3 71.05,104.99
  BOTTOM w0.254: 71.05,104.99 71.05,105.29 70.37,105.98 v1(69.58,105.98)
TP_INT: length 18.1
  TOP w0.14: Q17.1 75.35,107.86 R188.2 R187.1 74,108.06 74.51,107.55 74.51,107.04 v1(77.17,104.38)
  BOTTOM w0.14: v1(77.17,104.38) 77.17,104 76.41,103.23 74.06,103.23 73.03,104.27 73.03,105.06 72.74,105.35 71.79,105.35 71.55,105.1 CN7.2
TP_INT_PCH: length 106.2
  TOP w0.14: R156.1 161.26,118.22 160.36,118.22 159.93,118.65 159.93,119.08 159.52,119.49 v1(159.37,119.49) ; v1(84.54,101.33) 83.52,102.35 83.27,102.35 81.05,104.57 81.05,105.58 79.79,106.84 Q17.3 76.24,107.29 R188.1
  IN1 w0.114: v1(141.74,122.31) 142.19,121.87 144.29,121.87 145.37,122.95 147.08,122.95 147.38,123.25 148.22,123.25 148.44,123.47 150.04,123.47 150.92,124.35 152.96,124.35 153.24,124.63 154.25,124.63 154.82,124.07 154.82,123.15 155.35,122.62 155.63,122.62 156.09,122.16 156.3,122.16 157.44,121.01 157.84,121.01 v1(159.37,119.49)
  IN2 w0.076: v1(141.74,122.31) 141.35,122.7 140.2,122.7 140.04,122.54 140.04,122.16
  IN2 w0.114: 140.04,122.16 140.04,121.27 138.48,119.71 136.92,119.71 136.46,120.17 133.55,120.17 131.5,118.11 130.83,118.11 130.19,117.47 126.23,117.47 125.67,116.91 113.65,116.91 112.06,115.31 109.6,115.31 109.46,115.17 108.16,115.17 105.37,112.38 99.02,112.38 97.24,110.6 97.24,109.58 92.36,104.71 91.78,104.71 88.53,101.46 84.67,101.46 v1(84.54,101.33)
  BOTTOM w0.14: v1(141.74,122.31) 141.72,122.31 141.54,122.13 U45.R6
TP_PWR: length 1.2
  BOTTOM w0.203: CN7.31 57.05,103.63 v1(56.88,103.46)
  vias: v1(56.03,103.81)
TPCLK: length 83.3
  TOP w0.14: R386.2 R385.1 v1(87.97,50.81) ; v1(152.87,60.87) 154.64,62.65 154.64,62.98 155,63.33 U32.89
  IN3 w0.089: v1(151.98,56.24) 152.87,57.13 v1(152.87,60.87)
  BOTTOM w0.14: v1(151.98,56.24) 151.74,56.48 147.13,56.48 145.74,55.09 141.32,55.09 140.29,56.12 140.29,57.01 139.53,57.77 135.09,57.77 v1(134.71,57.39) 133.31,55.99 128.82,55.99 126.94,54.11 126.22,54.11 121.88,49.76 97.25,49.76 94.37,52.64 88.55,52.64 87.97,52.05 v1(87.97,50.81)
TPCLK_R: length 3.7
  TOP w0.14: v1(88.35,48.12) 87.97,48.5 R385.2 C475.2
  BOTTOM w0.14: CN18.3 v1(88.35,48.12)
TPD_INT#: length 9.8
  TOP w0.14: Q30.3 161.5,52.05 v1(161.25,51.8) 160.99,51.8 160.61,52.18 158.2,52.18 157.44,52.94 157.44,54.47 156.98,54.93 U32.68
TPD_INT#_D: length 94.3
  TOP w0.14: Q30.1 163.53,56.5 163.15,56.88 163.15,68.37 158.43,73.09 157.38,73.09 156.8,73.67 156.8,75.68 156.04,76.44 156.04,78.72 154.77,79.99 154.77,82.28 154.01,83.04 153.37,83.04 151.77,84.64 v1(151.77,85.45) ; R130.1 148.09,121.59 147.37,121.59 146.85,122.1 146.1,122.1 145.78,121.78 145.78,121.15 145.52,120.89 145.07,120.89 144.16,119.98 140.24,119.98 139.99,120.23 139.99,120.58 140.31,120.9 140.72,120.9 141.1,121.29 v1(141.1,121.34)
  IN1 w0.114: v1(147.66,100.62) 147.66,100.19 148.75,99.09 148.75,98.46 150.07,97.14 150.07,87.49 151.6,85.96 151.6,85.63 v1(151.77,85.45)
  IN3 w0.089: v1(141.1,121.34) 140.67,121.78 140.29,121.78 139.66,121.14 139.66,119.31 139.99,118.98 139.99,117.46 140.45,116.99 142.73,116.99 142.83,116.88 143.99,116.88 144.6,116.27 144.6,114.71 145,114.31 145,111.44 144.59,111.03 144.59,110.16 144.17,109.75 144.17,105.33 144.36,105.14 144.36,103.64 146.59,101.41 146.59,101.04 147.02,100.62 v1(147.66,100.62)
  BOTTOM w0.076: U45.U7 140.89,121.12 v1(141.1,121.34)
TPDATA: length 92.3
  TOP w0.14: v1(152.88,61.49) 152.9,61.52 153.13,61.52 154.39,62.77 154.39,63.23 154.89,63.73 U32.90 ; R384.1 v1(84.54,50.81) 84.54,50.89 84.99,51.34 88.89,51.34 89.61,50.62 90,50.62 90.26,50.36 R387.2
  IN3 w0.089: v1(151.98,56.88) 152.61,57.51 152.61,60.31 152.36,60.56 152.36,60.97 v1(152.88,61.49)
  BOTTOM w0.14: v1(151.98,56.88) 150.96,56.88 150.32,57.52 145.47,57.52 143.28,55.33 141.46,55.33 140.58,56.21 140.58,57.1 139.66,58.02 134.58,58.02 v1(133.44,56.88) 132.79,56.23 128.72,56.23 126.84,54.35 126.12,54.35 121.78,50 97.35,50 94.47,52.88 88.45,52.88 87.5,51.93 85.58,51.93 84.54,50.89 v1(84.54,50.81)
TPDATA_R: length 4.3
  TOP w0.14: v1(87.05,48.12) 86.94,48.12 C474.2 R384.2
  BOTTOM w0.14: CN18.4 87.35,48.42 v1(87.05,48.12)
TX0N_R: length 2.3
  TOP w0.127: R2.1 150.08,163.29 149.7,163.29 149.46,163.53 149.04,163.53 148.93,163.42 U4.2
TX0P_R: length 2.3
  TOP w0.127: R1.1 150.08,164.09 149.73,164.09 149.6,163.96 149.09,163.96 148.93,164.12 U4.1
TX1N_R: length 2.4
  TOP w0.127: R29.1 149.45,156.94 148.48,156.94 147.94,156.4 U7.4
TX1P_R: length 2.4
  TOP w0.127: R27.1 149.45,157.74 148.64,157.74 148,157.1 U7.3
TX2N_R: length 2.3
  BOTTOM w0.127: R438.1 149.84,163.53 149.04,163.53 148.93,163.42 U35.3
TX2P_R: length 2.3
  BOTTOM w0.127: U35.4 148.93,164.12 149.09,163.96 149.95,163.96 R434.1
TX3N_R: length 2.4
  BOTTOM w0.127: R464.1 149.45,156.94 148.66,156.94 148.12,156.4 U36.1
TX3P_R: length 2.4
  BOTTOM w0.127: R460.1 149.2,157.84 149.1,157.74 148.69,157.74 148.05,157.1 U36.2
