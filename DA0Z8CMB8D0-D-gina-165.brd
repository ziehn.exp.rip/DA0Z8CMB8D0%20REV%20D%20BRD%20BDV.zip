# Allegro board DA0Z8CMB8D0-D-gina-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VCC_SENSE: length 93.9
  TOP w0.381: PR5.2 151.68,153.92 v1(152.28,154.52)
  IN1 w0.254: v1(114.77,148.45) 114.79,148.47 114.79,155.77 117.12,158.1 126.74,158.1 130.2,154.64 133.09,154.64 134.72,153.02 143.48,153.02 144.6,154.14 151.9,154.14 v1(152.28,154.52)
  IN3 w0.254: v1(104.83,139.63) 105.44,139.63 107.83,142.02 111.56,142.02 114.26,144.72 114.26,147.94 v1(114.77,148.45)
  BOTTOM w0.203: R526.2 101.43,130.79 100.8,130.16 100.8,128.72 100.59,128.51 97.58,128.51 96,130.08 96,130.53 95.35,131.19 95.35,136.47 97.65,138.78 99.48,138.78 100.57,139.86 102.35,139.86 103.31,138.9 104.2,138.9 104.83,139.53 v1(104.83,139.63)
  BOTTOM w0.381: PR127.1 151.78,155.02 v1(152.28,154.52) 151.81,154.05 PC87.1
VCC_SENSE_R: length 6.5
  BOTTOM w0.203: R522.2 102.71,131.03 R526.1 102.71,130.66 103.28,130.1 103.28,129.74 105.58,127.43 U45.E63
VCCRTC_3: length 3.2
  TOP w0.14: v3(84.74,73.03) 84.54,73.24 R795.2
  TOP w0.508: R795.2 83.66,74.07 83.16,74.56 Q42.3
VCCRTC_4: length 2.1
  TOP w0.508: R795.1 v3(81.82,73.24) R797.2
VCCST_PWRGD: length 51.1
  TOP w0.14: U15.2 v1(82.76,129.9)
  IN3 w0.089: v1(82.76,129.9) 86.57,129.9 91.78,135.11 97.24,135.11 v1(98.41,133.94)
  BOTTOM w0.076: C622.2 103.82,135.76 103.82,132.67 103.97,132.52 104.66,132.52 104.89,132.29 104.89,131.41 105.5,130.8 107.66,130.8 108.05,130.4 108.24,130.4 108.43,130.21 108.43,129.77 108.77,129.42 U45.B59
  BOTTOM w0.14: v1(98.41,133.94) 98.41,132.44 97.65,131.68 97.27,131.68 96.62,132.33 R521.1 96.48,136.92 97.37,137.8 v1(97.67,137.8) 98.17,138.3 99.69,138.3 100.77,139.38 101.79,139.38 102.46,138.71 R497.1 102.46,137.48 102.29,137.32 101.89,137.32 101.42,136.86 R499.1 101.42,136.54 101.9,136.06 103.39,136.06 C622.2
VCCST_PWRGD_EN: length 5.7
  BOTTOM w0.14: U42.2 98.51,136 98.76,135.75 98.76,134.96 99.18,134.55 99.18,134.26 R519.1 98.62,134.5 98.15,134.5 R518.1 97.54,134.1 v1(96.91,134.73)
VCCST_PWRGD_R: length 2.8
  BOTTOM w0.14: U42.4 100.55,136.65 100.66,136.77 100.66,137.65 v1(100.67,137.65) 100.8,137.78 R497.2
VCCST_PWRGD_XDP: length 1.2
  TOP w0.14: TP86.1 86.81,93.8 R254.2
VDD10: length 62.1
  TOP w0.305: U24.3 218.48,91.37 218.18,91.68 218.18,92.18 217.94,92.41 ; v1(215.6,79.61) 215.98,79.99 U24.41 ; U24.61 220.9,88.21 221.82,89.13 C303.2 ; 221.19,83.55 221.03,83.71 U24.52 ; 215.88,92.57 215.88,91.52 215.98,91.42 U24.8
  TOP w0.508: C335.2 215.6,78.99 v1(215.6,79.61) ; C303.2 221.98,89.1 222.2,89.1 v1(222.59,89.49) ; R286.1 205.6,81.8 v1(205.34,82.05) ; C296.2 C297.2 217.51,92.85 217.94,92.41 ; C296.2 215.36,92.94 214.84,93.46 v1(214.84,94.47) ; C296.2 215.86,92.69 215.86,92.59 215.88,92.57 ; 221.19,83.55 222.84,81.9 C329.2 223.09,82.14 v1(223.48,82.53)
  IN2 w0.508: v1(207.76,85.2) 208.49,85.2 212.39,81.3 212.39,77.38 212.61,77.17 212.61,74.53 214.94,72.2 216.57,72.2 219.54,75.17 219.54,76.69 220.68,77.83 222.97,77.83 ; v1(214.84,94.47) 214.84,93.71 215.48,93.07 219.03,93.07 220.05,92.06 220.05,90.92 221.95,89.01
  BOTTOM w0.508: v1(207.76,85.2) 207.76,84.46 v1(205.34,82.05)
  vias: v1(224.49,77.56) v1(224.49,76.92) v1(225.13,76.95)
VDD33: length 16.6
  TOP w0.305: U24.11 214.48,91.13 214.24,91.37 214.02,91.37 213.62,91.77 213.62,92.24 214.08,92.69 ; U24.58 221.31,86.71
  TOP w0.508: R292.2 214.33,77.48 v1(214.33,76.82) ; 221.31,86.71 222.08,86.71 222.2,86.6 C309.2 C311.2 v1(221.83,85.58) ; v1(212.68,94.47) 212.02,93.81 212,93.81 ; 214.08,92.69 C295.2 C294.2 212.87,92.94 212,93.81 ; 212,93.81 R253.1 ; R291.2 v1(217.64,77.58) ; R295.2 v1(216.87,75.79)
  IN2 w0.508: 212.68,91.8 v1(212.68,94.47)
  vias: v1(215.22,73.42) v1(215.22,72.81) v1(218.78,91.8) v1(219.41,91.8) v1(220.3,90.79)
VDD33_18: length 3.9
  TOP w0.305: U24.53 221.8,84.21 v1(221.95,84.06) 222.21,84.06 222.34,84.18 C314.2 R285.1
VDDREG:
  vias: v1(218.91,74.91)
VIN: length 153.8
  TOP w0.14: v1(45.17,72.88) 45.17,72.89 44.93,73.14 43.65,73.14 42.88,73.9 40.22,73.9 39.97,73.65
  TOP w0.508: v2(149.46,142.58) 149.19,142.85 PR22.1 ; v2(182.18,50.59) 182.86,49.9 PR115.1 ; 11.83,126.95 11.83,127.68 v3(10.98,128.53) 10.96,128.53 10.07,129.42 v2(10.07,135.44) ; PR26.1 v1(12.97,140.79) ; PR19.1 151.89,145.38 151.7,145.58 151.44,145.58 151.37,145.65 v1(151.34,145.65) ; v1(69.96,85.48) 71.51,83.93 71.51,81.54 73.25,79.8 PR52.1 ; v1(33.11,104.91) 32.67,104.91 31.95,105.64 PR39.1 ; v1(185.76,47.74) 185.76,46.97 187.28,45.45 192.24,45.45 193.89,47.1 197.09,47.1 PR121.1 199.83,43.65 199.78,43.6 PR124.1
  IN1 w0.127: v1(49.62,68.43) 49.48,68.56 49.12,68.56 48.86,68.82 48.86,69.32 46.22,71.95 46.22,72.8 45.89,73.14 45.42,73.14 v1(45.17,72.88)
  IN1 w0.254: v1(50.73,73.19) 50.37,73.19 48.64,74.92 48.64,75.21 48.34,75.51 47.84,75.51 47.83,75.5 45.99,75.5 45.56,75.93 44.83,75.93 v1(44.33,75.42)
  IN3 w0.508: v1(12.97,140.79) 12.75,140.57 11.26,140.57 10.07,139.38 v2(10.07,135.44) ; v1(69.96,85.48) 69.96,90.18 70.6,90.81 70.6,95.49 69.64,96.44 69.64,99.26 67.83,101.08 56.73,101.08 56.55,100.9 53.85,100.9 53.15,101.61 51.24,101.61 v2(50.12,102.73) ; v1(193.76,61.07) 191.73,63.1 184.62,63.1 v1(183.73,62.21)
  BOTTOM w0.14: PR192.2 50.24,68.43 49.63,68.43 49.62,68.42 v1(49.62,68.43)
  BOTTOM w0.254: PR177.2 51.07,72.85 v1(50.73,73.19)
  BOTTOM w0.508: PD8.2 93.33,99.68 91.65,101.36 85.61,101.36 84.72,100.47 81.52,100.47 76.56,95.51 76.56,94.72 74.65,92.82 73.51,92.82 71.51,90.81 71.51,85.86 71.13,85.48 v1(69.96,85.48) ; PR204.1 194.12,61.43 v1(193.76,61.07)
  vias: v1(137.37,150.73) v1(138.13,150.73) v1(141.28,150.61) v1(141.74,151.01) v2(11.64,122.92) v2(11.67,122.16) v2(11.69,121.35) v2(12.72,121.34) v2(12.73,122.08) v2(37.5,71.21) v2(37.47,70.37) v2(37.58,72.07) v2(37.6,69.63) v2(37.93,68.18) v2(37.93,67.29) v2(37.93,66.4) v2(37.93,65.64) v2(39.18,71.97) v2(40.67,71.84) v2(42,83.17) v2(42,82.41) v2(42,81.64) v2(42,80.88) v2(42,80.12) v2(43.01,70.85) v2(43.72,84.31) v2(43.77,85.15) v2(43.9,70.85) v2(44.79,70.85) v2(48.6,102.73) v2(49.36,102.73) v2(62.59,84.72) v2(63.31,84.72) v2(64.02,84.72) v2(64.75,84.72) v2(134.25,150.73) v2(134.96,150.73) v2(136.61,150.73) v2(140.39,154.37) v2(141.11,154.37) v2(149.82,143.67) v2(150.07,142.99) v2(150.07,142.2) v2(150.55,143.67) v2(178.37,85.43) v2(178.75,86.06) v2(178.77,51.42) v2(179.03,50.66) v2(179.13,85.43) v2(179.51,86.06) v2(179.54,51.42) v2(179.89,85.43) v2(181.47,50.61) v2(184.24,71.28) v2(185.15,71.33) v2(185.63,72.6) v2(186.39,72.6) v2(187.03,51.55) v2(187.03,50.78) v2(187.08,71.26) v2(187.33,72.6) v2(187.79,51.55) v2(187.79,50.78) v2(187.94,71.31) v2(207.02,64.88) v2(207.4,65.49) v2(207.78,66.13) v2(207.78,64.88) v2(208.24,65.49) v2(208.62,64.88) v3(10.75,121.9) v3(67.01,82.43) v3(134.81,151.49)
VSS_SENSE: length 95.1
  TOP w0.254: PR4.2 152.87,153.71 v1(152.87,154.34)
  IN1 w0.254: v1(114.77,147.68) 115.25,148.17 115.25,155.58 117.31,157.64 126.55,157.64 130.01,154.19 132.9,154.19 134.53,152.56 143.67,152.56 144.87,153.76 152.28,153.76 v1(152.87,154.34)
  IN3 w0.254: v1(104.23,139.63) 104.23,139.35 104.66,138.92 105.5,138.92 107.96,141.39 111.64,141.39 114.77,144.51 v1(114.77,147.68)
  BOTTOM w0.254: PR128.2 152.87,154.89 v1(152.87,154.34) 152.9,154.3 PC88.1 ; R530.2 101.56,129.78 101.3,129.52 101.3,128.63 100.67,128 97.57,128 95.65,129.92 95.65,130.42 94.96,131.11 94.96,136.64 97.42,139.11 99.33,139.11 100.47,140.24 102.55,140.24 103.56,139.23 104.06,139.23 104.23,139.39 v1(104.23,139.63)
VSS_SENSE_R: length 6
  BOTTOM w0.203: U45.E62 106.71,127.39 106.36,127.03 105.99,127.03 105.93,127.09 105.41,127.09 104.16,128.34
  BOTTOM w0.254: R530.1 R532.1 103.74,128.76 104.16,128.34
1.5GFX_DRVH: length 6.7
  TOP w0.254: v1(16.47,120.53) 16.87,120.13 PU2.9
  BOTTOM w0.457: PQ31.4 12.6,123.8 14.74,121.65 15.35,121.65 v1(16.47,120.53)
1.5GFX_DRVL: length 5.6
  TOP w0.254: v1(18.66,120.42) 18.37,120.13 PU2.6
  BOTTOM w0.457: v1(18.66,120.42) 18.66,120.65 15.94,123.37 PQ30.4
1.5GFX_EN: length 4.2
  TOP w0.14: PR34.2 17.99,114.92 18.37,114.54 18.88,114.54 v1(19.14,114.28)
  TOP w0.254: v1(17.41,115.73) 17.37,115.77 PU2.3
  TOP w0.381: PR34.2 17.99,115.15 v1(17.41,115.73)
  BOTTOM w0.508: v1(17.41,115.73) 16.85,115.17 PC101.2
1.5GFX_FB: length 3.9
  TOP w0.254: v1(18.25,115.73) 18.2,115.73 17.87,116.06 PU2.4
  BOTTOM w0.254: PR154.2 16.7,116.47 16.74,116.43 PR153.1 18.03,116.43 18.25,116.21 v1(18.25,115.73)
1.5GFX_SW: length 8.3
  TOP w0.254: PU2.8 17.37,120.47 v1(17.27,120.57) 17.19,120.65 PC17.2
  TOP w0.508: v1(12.02,130.16) 11.8,130.38 PR29.1
  BOTTOM w0.457: 14.18,124.27 14.18,123.2 14.97,122.41 15.58,122.41 17.27,120.72 v1(17.27,120.57)
  vias: v3(14.06,127.36)
1.5GFX_TRIP: length 2.9
  TOP w0.14: v1(17.74,114.28) 17.49,114.28 PR35.2
  TOP w0.254: PR35.2 16.73,115.43 16.87,115.57 PU2.2
1.5GFX_TST: length 4.1
  TOP w0.14: PR32.2 21.01,116.56 v1(22.01,117.56)
  TOP w0.254: PR32.2 20.4,116.56 PU2.5
1.5GFX_VBST: length 3.1
  TOP w0.14: v1(14.88,121.46) PR30.2
  TOP w0.254: PU2.10 16.37,119.89 15.84,120.42 PR30.2
2ND_MBCLK: length 239.8
  TOP w0.14: R242.1 145.28,95.75 Q19.3 145.29,97.29 v1(145.42,97.42) ; U32.115 147.04,69.85 147.48,70.29 147.48,71.84 147,72.32 v1(147,72.77) 148.29,74.06 R300.1 ; Q12.6 64.87,115.44 65.74,116.32 v1(67.65,116.32) 70.19,113.78 70.19,104.38 69.05,103.23 v1(69.05,102.6)
  IN1 w0.114: v1(147,72.77) 146.9,72.86 146.9,75.42 147.72,76.23 147.72,86.02 148.93,87.23 148.93,96.33 148.74,96.51 148.16,96.51 147.25,97.42 v1(145.42,97.42)
  IN3 w0.089: v1(69.05,102.6) 69.05,102.09 70.88,100.26 70.88,97.72 72.6,96 72.6,93.58 72.12,93.1 72.12,91.6 71.78,91.26 71.78,83.61 71.09,82.92 71.09,80.91 68.25,78.07 64.01,78.07 63.01,77.07 62.6,77.07 57.82,72.29 57.82,68.46 58.41,67.87 58.41,66.29 58.96,65.74 58.96,65.12 58.55,64.71 58.55,62.8 58.34,62.59 58.34,61.79 57.98,61.44 57.98,54.73 60.54,52.18 60.54,51.81 62.21,50.14 64.55,50.14 64.85,49.84 69.86,49.84 70.86,48.84 78.49,48.84 79.26,49.6 80.72,49.6 80.95,49.83 81.64,49.83 81.87,49.6 89.09,49.6 91.04,51.55 97.45,51.55 98.15,52.26 105.17,52.26 106.06,53.15 114.31,53.15 114.89,52.57 114.89,52.16 115.81,51.24 118.89,51.24 119.25,51.6 128.14,51.6 129.76,53.23 131.45,53.23 133.94,55.72 134.69,55.72 134.98,56.02 134.98,56.21 136.75,57.98 139.46,57.98 140.22,57.22 142.34,57.22 142.85,56.71 145,56.71 146.76,58.47 146.76,59.95 147.62,60.81 147.62,62.69 146.46,63.86 144.35,63.86 143.98,63.48 142.83,63.48 142.45,63.86 141.89,63.86 141.06,64.69 141.06,65.9 142.83,67.67 145.88,67.67 146.5,68.3 146.5,70.74 147,71.24 v1(147,72.77)
2ND_MBDATA: length 240
  TOP w0.14: R299.1 146.77,73.52 146.39,73.14 v1(146.39,72.75) 146.39,72.35 147.07,71.66 147.07,70.44 146.64,70.01 U32.116 ; Q19.6 147.02,93.7 147.28,93.96 R243.1 148.03,93.96 148.21,94.13 148.21,94.99 147.91,95.28 147.91,95.61 v1(148.4,96.1) ; v1(69.68,102.6) 69.68,103.15 70.7,104.17 70.7,113.9 67.78,116.82 v1(64.98,116.82) 64.47,116.82 63.33,115.68 63.33,114.54 62.94,114.14 Q12.3
  IN1 w0.114: v1(146.39,72.75) 146.39,75.42 147.35,76.38 147.35,87.56 147.91,88.12 147.91,95.61 v1(148.4,96.1)
  IN3 w0.089: v1(69.68,102.6) 69.68,101.96 71.22,100.42 71.22,97.88 72.98,96.12 72.98,93.46 72.48,92.95 72.48,91.42 72.12,91.07 72.12,83.47 71.43,82.78 71.43,80.77 67.74,77.07 63.5,77.07 63.16,76.73 62.75,76.73 58.2,72.18 58.2,68.56 58.75,68.01 58.75,66.43 59.3,65.88 59.3,64.97 58.89,64.56 58.89,62.56 59.32,62.13 59.32,61.18 58.33,60.19 58.33,54.88 60.88,52.32 60.88,51.95 62.35,50.48 63.63,50.48 63.63,50.48 64.69,50.48 64.99,50.18 70,50.18 71,49.18 78.35,49.18 79.11,49.94 80.55,49.94 80.78,50.18 81.9,50.18 82.13,49.94 88.94,49.94 90.89,51.89 97.31,51.89 98.01,52.6 105.03,52.6 105.92,53.49 114.45,53.49 115.23,52.71 115.23,52.3 115.95,51.58 118.75,51.58 119.11,51.95 128,51.95 129.62,53.57 131.31,53.57 134.28,56.54 134.83,56.54 137.14,58.85 139.08,58.85 140.29,57.64 143.01,57.64 143.2,57.82 145.62,57.82 146.41,58.61 146.41,60.32 147.28,61.18 147.28,62.55 146.47,63.36 144.87,63.36 144.36,62.85 142.19,62.85 140.55,64.49 140.55,66.15 142.45,68.06 145.63,68.06 146.16,68.59 146.16,72.53 v1(146.39,72.75)
27M_CRT_IN: length 4.5
  BOTTOM w0.14: Y2.3 100.71,146.32 C593.2 101.19,146.93 v1(101.94,147.68) 102.57,148.32 U40.34
27M_CRT_OUT: length 6.4
  BOTTOM w0.14: Y2.1 101.94,144.81 101.94,146.29 102.44,146.79 C594.2 102.44,146.91 v1(103.21,147.68) 102.97,147.92 U40.33
27M_XTAL_IN_R: length 13.4
  BOTTOM w0.102: U43.C11 52.44,127.94 53.18,127.94 53.23,127.99 53.93,127.99 54.45,127.46 54.45,126.9 55.46,125.89
  BOTTOM w0.14: Y4.3 59.81,119.45 C656.2 58.12,121.13 v1(58.12,122.54) 56.22,124.44 56.22,125.13 55.46,125.89
27M_XTAL_OUT: length 15.9
  BOTTOM w0.102: U43.B10 53.19,127.73 53.35,127.73 53.41,127.78 53.84,127.78 54.25,127.38 54.25,126.75 55.46,125.54
  BOTTOM w0.14: 55.46,125.54 55.94,125.06 55.94,124.34 57.67,122.61 v1(57.67,121.01) 57.67,120.34 C658.2 59.4,118.61 61.54,118.61 Y4.1
1642_BOOT1: length 2.7
  TOP w0.279: PU3.1 51.06,76.31
  TOP w0.305: 51.06,76.31 51.01,76.31 50.58,76.74 v1(50.35,76.74) 50.22,76.87 50.22,77.5 PR56.1
1642_BOOT2: length 4.1
  TOP w0.279: v1(56.65,77.96) 56.65,76.49 56.47,76.31 PU3.18
  TOP w0.381: PR50.1 57.44,78.75 v1(56.65,77.96)
1642_COMP: length 4.5
  TOP w0.14: PC44.2 57.74,71.55 v1(57.74,72.37)
  TOP w0.254: PU3.12 55.16,72.54 56.3,71.4 PR75.2
  TOP w0.381: PR75.2 56.9,71.31 56.93,71.28 PC44.2
1642_EN: length 6.4
  TOP w0.254: PR70.2 PR66.1 50.17,74.96 v1(50.38,75.17) 50.52,75.31 PU3.3
  BOTTOM w0.14: v1(51.01,75.55) 50.63,75.17 v1(50.38,75.17)
  BOTTOM w0.254: v1(50.38,75.17) 50.2,75.17 50,74.96 PR66.1 49.68,75.86 49.75,75.93 PR166.1
1642_FB: length 6
  TOP w0.254: PU3.11 54.66,72.29 55.08,71.87 PC46.2 54.8,70.98 54.17,70.98 PR78.2 53.86,71.26 53.32,70.72 53.32,69.88 52.71,69.28 v1(52.71,69.05)
1642_FBRTN: length 17.5
  TOP w0.254: v1(50.22,71.87) 49.87,71.87 49.39,71.38 49.23,71.38 PC45.2 ; PU3.10 54.16,71.87 v1(54.47,71.56) ; v1(57.08,72.91) 57.63,72.91 58.23,73.51 PQ15.1
  IN2 w0.381: v1(54.47,71.56) 54.47,72.09 54.06,72.5 50.63,72.5 50.22,72.09 v1(50.22,71.87)
  BOTTOM w0.254: PC45.2 49.26,71.26 49.87,71.87 v1(50.22,71.87) ; PR179.2 57.67,72.32 v1(57.08,72.91) 56.78,72.61 PR176.2
  BOTTOM w0.305: PR179.2 55.19,71.83 v1(55.18,71.84) 54.9,71.56 v1(54.47,71.56)
1642_ISEN1: length 3.5
  TOP w0.254: PR62.1 58.47,75.9 57.78,75.21 57.78,75.06 v1(57.49,74.76) 57.44,74.81 PU3.15
1642_LGATE1:
  vias: v1(52.59,78.7) v2(51.91,78.71)
1642_LGATE2:
  vias: v1(54.7,79.23) v2(54.44,78.47)
1642_PGOOD: length 5.5
  TOP w0.14: PU3.16 56.59,75.31 57.31,76.03 57.54,76.03 57.87,76.37 57.87,76.64 v1(58.14,76.9)
  TOP w0.254: v1(58.14,76.9) 58.14,77.37 58.26,77.5 PR57.1
  BOTTOM w0.14: PR167.1 58.48,76.48 58.14,76.82 v1(58.14,76.9) 58.09,76.95 v1(57.36,76.95)
1642_PHASE1: length 14
  TOP w0.279: PU3.24 52.66,77.47 52.46,77.67 51.68,77.67 v2(51.55,77.81)
  TOP w0.381: PC40.1 50.94,79.05 51.14,78.85 51.14,78.22 v2(51.55,77.81)
  IN1 w0.762: v2(47.71,86.65) 48.04,86.32 48.04,81.57 50.99,78.62 50.99,78.37 v2(51.55,77.81)
  vias: v1(45.93,87.97) v2(46.29,90.15) v2(47.71,88.99) v2(47.76,91.07) v2(47.79,90.1) v2(47.76,87.72) v2(49.23,90.1)
1642_PHASE2: length 12.3
  TOP w0.254: 55.16,77.83 PU3.19
  TOP w0.381: PC36.1 55.99,79.49 55.99,79 v2(55.6,78.61) 55.16,78.17 55.16,77.83
  IN1 w0.762: v2(56.73,87.33) 56.73,86.98 57.21,86.5 57.21,80.6 55.6,78.99 v2(55.6,78.61)
  vias: v1(59.88,86.12) v1(60.88,82.28) v2(55.51,87.28) v2(56.8,89.39) v2(56.78,88.4) v2(57.77,88.33) v2(57.82,87.28) v2(58.86,89.39) v2(58.84,88.38) v2(58.89,87.31) v2(59.83,88.38) v2(59.85,87.28)
1642_PSI: length 5.2
  TOP w0.254: PU3.4 50.74,74.81 v1(50.33,74.41)
  BOTTOM w0.14: v3(51.06,73.8) 50.45,74.41 v1(50.33,74.41)
  BOTTOM w0.254: v1(50.33,74.41) 50,74.41 49.68,74.09 PR174.1 50.02,73.42 50.02,72.91 49.69,72.57 PR178.1
1642_PVCC: length 10.8
  TOP w0.254: PR62.2 59.49,76.56 59.49,76.77 v1(59.61,76.9) ; PC38.2 v2(53.52,78.3) 53.6,78.3 54.16,77.73 PU3.21
  BOTTOM w0.254: v1(59.61,76.9) 59.06,77.45 56.17,77.45 v1(55.74,77.02) 54.89,77.02 54.82,77.09 PR164.1 53.68,78.14 v2(53.52,78.3)
1642_REFADJ: length 3.3
  TOP w0.254: PU3.6 51.81,73.48 v1(50.72,72.39) 50.72,71.5 50.48,71.26 PR76.2
1642_REFIN: length 4
  TOP w0.254: PU3.7 52.66,72.53 52.53,72.4 51.79,72.4 v1(51.25,71.87)
  BOTTOM w0.254: v1(51.25,71.87) 51.28,71.87 51.5,71.65 PR182.2
  BOTTOM w0.381: PR181.1 PR182.2
1642_TON: length 4.6
  TOP w0.254: PU3.9 53.66,71.88 v1(53.28,71.5)
  BOTTOM w0.254: v1(53.28,71.5) v1(53.73,71.94) 53.73,72.8 PC119.2 53.67,72.85 PR177.1
1642_TSNS: length 5.9
  TOP w0.254: PU3.13 57.07,73.81 v1(57.11,73.77)
  BOTTOM w0.254: PR169.2 59.26,74.83 58.51,74.08 PR173.1 58.04,73.81 57.85,73.62 57.26,73.62 v1(57.11,73.77) 56.78,74.1 56.78,74.48 56.49,74.77 PR168.1
1642_UGATE1: length 15.6
  TOP w0.14: v2(44.51,86.09) v1(44.51,85.33)
  TOP w0.305: v2(44.51,86.09) 44.31,86.29 PR46.2
  IN1 w0.762: v2(44.51,86.09) 45.04,85.56 45.04,80.43 47.8,77.67 49.91,77.67 50.38,77.2 v2(50.38,76.01)
1642_UGATE2: length 3.4
  TOP w0.305: PR47.2 57.49,82.21 58.12,81.57 58.12,80.63 58.68,80.07 PQ12.4
  vias: v1(58.25,78.6)
1642_VID: length 3.2
  TOP w0.254: PU3.5 51.12,74.31 50.12,73.31 50.12,72.75 49.92,72.55 PR74.1
1642_VREF: length 16.1
  TOP w0.254: PU3.8 53.16,72.36 52.54,71.74 52.18,71.74 v1(52.05,71.61) 51.85,71.61 PR77.1 51.66,71.1 52.56,71.1 PC47.1
  IN1 w0.254: v1(52.05,71.61) 52.05,71.48 52.56,70.98 54.7,70.98 55.2,71.48 57.74,71.48 58.72,72.47 v1(60.8,72.47)
  BOTTOM w0.254: v1(60.8,72.47) 60.14,72.47 v3(59.8,72.81) 59.29,73.32 PR173.2
24707_LX: length 14.5
  IN1 w0.381: v1(53.06,65.17) 51.49,65.17 48.35,68.31 46.69,68.31 45.56,69.44 v2(42.18,69.44)
  BOTTOM w0.279: PC125.1 v1(53.06,65.17) 53.34,64.89 PU9.19
  vias: v2(41.37,67.54) v2(42.21,68.3) v2(42.23,67.13) v2(42.54,66.24) v2(43.27,66.53) v2(43.9,66.02) v3(45.58,65.52)
24737_ACDET: length 4.5
  BOTTOM w0.279: PR189.2 60.24,68.04 59.43,67.23 PR196.2 59.05,67.2 v1(58.38,66.53) 58,66.15 58,65.64 57.75,65.39 PU9.6
24737_ACN: length 8
  TOP w0.14: v1(52.76,67.57) 52.76,67.46 PC55.1
  TOP w0.203: v1(54.54,66.96) 54.16,66.58 PC55.1
  BOTTOM w0.14: PR192.1 51.8,68.56 52.44,68.56 52.73,68.27 PC121.2
  BOTTOM w0.203: PU9.1 54.74,66.61 54.54,66.81 v1(54.54,66.96) 54.54,67.17 53.4,68.31 53.08,68.31 PC121.2
24737_ACP: length 7.3
  TOP w0.305: v1(55.18,66.94) 55.2,66.97 PC53.2
  BOTTOM w0.14: PC121.1 52.24,68.94 51.68,68.94 PR188.1 ; v1(55.18,66.94) 55.24,66.88 PU9.2
  BOTTOM w0.203: v1(55.18,66.94) 55.03,67.09 55.03,67.34 53.68,68.69 53.3,68.69 52.73,69.26 PC121.1
24737_BM#: length 5.3
  TOP w0.14: v3(56.35,61.78) 56.23,61.9 PR94.1
  TOP w0.254: v1(57.9,62.09) 58.04,62.23 PQ21.2 57.03,63.03 56.73,62.72 PR94.1
  BOTTOM w0.254: PU9.11 57.1,62.67 57.68,62.09 v1(57.9,62.09)
24737_BST: length 3.9
  TOP w0.254: v2(53.12,62.9) 52.82,63.2 v1(52.82,63.64)
  BOTTOM w0.254: v2(53.12,62.9) 53.12,62.95 PR201.2
  BOTTOM w0.279: PR201.2 53.28,63.82 53.35,63.89 PU9.17
24737_CMPIN: length 6
  TOP w0.254: v1(56.6,66.99) 56.6,66.53 v1(56.98,66.15) 57.73,65.4 PR88.2 58.27,65.8 58.87,65.8 PR89.1
  BOTTOM w0.254: PR194.2 56.54,67.64 56.42,67.52 56.42,67.17 v1(56.6,66.99) 56.47,66.99 56.24,66.76 PU9.4
24737_CMPOUT: length 12
  TOP w0.14: v3(61.55,67.29) 61.19,66.93 PQ18.2
  TOP w0.254: 59.32,64.67 59.98,64.67 60.03,64.62 PR90.2 ; 59.32,64.67 PR89.2 ; 59.32,64.67 59.78,65.13 59.78,65.77 59.15,66.4 v1(59.15,66.6) 59.48,66.93 PQ18.2
  IN1 w0.254: v1(55.79,67.05) 55.79,66.57 56.1,66.26 58.81,66.26 v1(59.15,66.6)
  BOTTOM w0.254: PR193.1 55.79,67.36 v1(55.79,67.05) 55.74,67 PU9.3
24737_DH: length 15.4
  TOP w0.381: PQ17.4 41.94,70.91 42.88,69.96 44.94,69.96 46.62,68.28 47.86,68.28 v1(48.85,67.29) 51.14,65.01 52.45,65.01 v2(53.06,64.4)
  BOTTOM w0.279: PU9.18 53.07,64.39 v2(53.06,64.4)
24737_DL: length 12.7
  IN1 w0.508: v2(46.8,66.56) 47.68,66.56 52.69,61.55 v2(53.91,61.55)
  BOTTOM w0.14: v2(53.91,61.55) 53.81,61.45 v3(53.04,61.45)
  BOTTOM w0.279: PU9.15 54.74,62.18 54.11,61.55 v2(53.91,61.55)
  BOTTOM w0.508: v2(46.8,66.56) 46.3,67.05 PQ48.4
24737_ILIM: length 9.7
  TOP w0.254: PR102.2 56.93,59.47 v3(56.65,59.75) 56.15,60.25 56.15,60.55 56.17,60.57 PR97.1
  TOP w0.305: PR102.2 57.8,59.74 v1(57.49,60.05)
  BOTTOM w0.254: PU9.10 57.91,63.39 58.02,63.28 58.02,63.21 58.79,62.44 59.39,62.44 PR203.2
  BOTTOM w0.305: v1(57.49,60.05) 58.66,60.05 59.66,61.06 PC130.2 59.66,62.17 PR203.2
24737_REGN: length 6.1
  TOP w0.381: PD5.2 51.39,62.09 51.47,62.16 52.54,62.16 v1(52.87,61.83) 53.08,61.83 53.58,62.33 v1(53.6,62.33)
  BOTTOM w0.279: v1(53.6,62.33) 53.67,62.4 53.67,63.04 PU9.16
  BOTTOM w0.381: PC129.1 52.48,62.24 53.5,62.24 v1(53.6,62.33)
24737_SRN: length 7.6
  BOTTOM w0.14: v1(58.89,58.4) 58.89,58.66 58.24,59.3 PR205.1 57.86,59.39 57.64,59.17 57.64,58.37 PC133.1 57.62,57.85 57.62,57.64 57.24,57.26 56.73,57.26 56.22,57.77 55.89,57.77 55.64,57.53 PR209.1
  BOTTOM w0.381: PR205.1 58.27,59.42 PC132.2
24737_SRP: length 7.4
  BOTTOM w0.14: PR206.1 57.28,59.38 57.39,59.27 57.39,58.4 PC133.2 57.31,57.92 57.31,57.77 57.08,57.54 56.83,57.54 56.35,58.02 55.9,58.02 55.64,58.28 PR208.1 ; v1(54.7,60.69) 55.18,60.21 55.18,60.07 PC131.2
  BOTTOM w0.381: PR206.1 56.57,59.67 PC131.2
24737_VCC: length 11.9
  TOP w0.381: PC58.2 53.87,65.14 53.11,65.9 v1(53.04,65.9) 51.27,65.9 v1(50.25,66.91) 48.6,68.56 48.6,70.09 47.44,71.25 PR73.2
  BOTTOM w0.279: PU9.20 53.55,65.39 v1(53.04,65.9)
51216_DRVH: length 5.3
  BOTTOM w0.762: v2(195.16,54.59) v1(193.76,53.2) 192.91,52.34 PQ52.1
51216_DRVL: length 5.3
  BOTTOM w0.762: v2(195.59,56.8) v1(194.89,57.5) 194.38,58.01 PQ52.8
51216_MODE: length 2.3
  TOP w0.208: PR113.2 v1(198.38,52.69) 198.38,52.94 198.1,53.23 PU6.19
51216_REF: length 3.6
  TOP w0.208: PC67.1 198.79,58.98 198.79,58.12 v1(198.69,58.02) 198.5,57.83 PU6.6
  TOP w0.305: PR104.1 198.59,58.84 PC67.1
51216_REFIN: length 6.1
  TOP w0.14: v1(194.44,58.95) PC69.1
  TOP w0.208: PU6.8 197.7,57.9 197.39,58.2 196.96,58.2 196.73,58.43 196.73,58.78 PR104.2
  TOP w0.305: PR99.1 PR104.2 195.5,58.84 PC69.1
51216_S3: length 4.6
  TOP w0.208: PU6.17 197.3,53.13 v1(197.04,52.87) 196.1,51.93 PR110.2
  BOTTOM w0.381: PR212.2 196.18,52.01 v1(197.04,52.87) 197.1,52.93 PR211.2
51216_S5: length 4.3
  TOP w0.208: PU6.16 196.9,53.59 196.63,53.32 196.11,53.32 v1(195.58,52.8) 194.98,52.19 PR111.2
  BOTTOM w0.508: PR211.1 v1(195.58,52.8)
51216_SW: length 12.6
  TOP w0.508: PR105.1 v2(180.2,59.17)
  IN3 w0.762: v2(195.18,55.43) 193.2,55.43 191.86,54.09 186.19,54.09 v2(185.38,54.9)
  BOTTOM w0.14: v2(195.18,55.43) v1(194.47,55.43)
51216_TRIP: length 4.4
  TOP w0.14: PR112.2 196.81,51.3 v1(196.81,49.89)
  TOP w0.208: PU6.18 197.7,52.82 197.24,52.36 PR112.2
51216_VBST: length 1.1
  TOP w0.14: PR108.1 194.17,53.27 v1(193.91,53.02)
51225_CS1: length 3.4
  TOP w0.208: PU5.1 198.71,66.74 v1(199.4,67.42) 199.53,67.55 200.52,67.55 200.75,67.78 PR82.2
51225_CS2: length 3.6
  TOP w0.208: PU5.5 196.62,67.1 196.45,67.27 v1(195.41,67.27)
  BOTTOM w0.208: v1(195.41,67.27) 194.95,66.81 193.73,66.81 PR195.2
51225_DH1: length 8.8
  IN1 w0.762: v2(207.53,63.59) 206.49,63.59 205.95,64.12 199.86,64.12 v2(199.78,64.2)
  BOTTOM w0.14: v1(199.37,63.61) 199.37,63.79 v2(199.78,64.2)
51225_DH2: length 14.8
  IN3 w1.016: v2(183.65,70.49) 184.79,69.35 188.6,69.35 193.66,64.3 v2(195.06,64.3)
  BOTTOM w0.14: v1(194.27,64.3) v2(195.06,64.3)
51225_DL1: length 3.9
  IN1 w0.762: v2(198.81,63.23) 199.32,62.72 v2(201.81,62.72)
  BOTTOM w0.14: v1(198.08,63.23) v2(198.81,63.23)
51225_DL2: length 8.6
  TOP w0.203: PU5.11 196.62,63.36 196.44,63.18 v2(196.02,63.18)
  BOTTOM w0.762: 188.73,63.81 190.76,63.81 191.4,63.18 v1(192.87,63.18) v2(196.02,63.18)
51225_EN1: length 4.6
  TOP w0.208: v1(199.88,67.04) 199.88,66.71 199.21,66.04 PU5.20
  BOTTOM w0.254: PR197.1 197.44,67.04 197.57,66.91 199.75,66.91 v1(199.88,67.04)
51225_FB1: length 6.7
  TOP w0.203: PU5.2 197.82,67.29 v1(198.08,67.55)
  BOTTOM w0.14: v1(199.86,68.31) 199.86,68.56 PR187.1
  BOTTOM w0.381: v1(198.08,67.55) 198,67.62 197.21,67.62 196.86,67.98 196.86,68.41 197.71,69.26 PR186.1 PR187.1
51225_FB2: length 4.1
  TOP w0.208: v1(196.33,67.83) 196.53,67.83 197.02,67.34 PU5.4
  TOP w0.305: PR80.2 195.97,68.18 v1(196.33,67.83)
  BOTTOM w0.14: PR80.2 195.41,68.45 v1(195.41,69.07)
  BOTTOM w0.305: v1(196.33,67.83) 195.97,68.18 PR80.2
51225_SW1: length 9.2
  TOP w0.762: v2(208.97,56.75) 208.57,56.35 PR106.1
  IN3 w0.762: v2(206.59,62.59) 204.94,62.59 202.27,65.26 v2(199.88,65.26)
  vias: v1(206.97,61.45)
51225_SW2: length 15.5
  IN2 w1.016: v2(180.81,66.05) 182.25,67.5 191.91,67.5 193.99,65.41 v2(194.88,65.41)
  vias: v1(184.11,68.41) v2(180.78,64.58) v2(182.97,69.33)
51225_VBST1: length 1.5
  TOP w0.14: v1(199.91,62.98) 200.9,63.97 PR92.2
51225_VBST2: length 1
  TOP w0.14: PR91.1 193.99,63.33 v1(193.89,63.23)
51225_VCLK: length 2.4
  TOP w0.208: PU5.19 199.44,65.64 199.96,66.15 v1(199.98,66.15) 200.41,66.15 PR86.1
51225_VIN: length 3.7
  TOP w0.208: 196.94,62.85 197.02,62.93 PU5.12
  TOP w0.508: 196.94,62.85 v1(196.94,62.78) 196.94,62.67 v1(196.5,62.24) 195.93,61.66 PC64.2
  BOTTOM w0.508: PR204.2 196.02,61.76 v1(196.5,62.24)
51624_B-RAMP: length 2.9
  TOP w0.191: v1(147.26,146.81) 147.26,147.31 147.43,147.48 PU1.11
  TOP w0.203: PR14.2 147.26,146.39 v1(147.26,146.81)
  BOTTOM w0.203: v1(147.26,146.81) 147.26,146.35 PR143.1
51624_COMP: length 5.7
  TOP w0.191: 149.37,153.07 149.37,153.07 149.03,152.72 PU1.26
  TOP w0.203: PC4.2 149.68,153.38 149.37,153.07 v1(149.37,153.09) ; v1(149.72,154.65) 149.3,155.06 PR1.1
  BOTTOM w0.203: v1(149.37,153.09) 149.68,153.4 PR131.2 149.68,154.61 v1(149.72,154.65) 149.72,154.81 PR126.2
51624_CSN1: length 34.4
  TOP w0.14: PR13.2 131.68,145.22 132.22,144.69 132.22,144.56 v1(132.29,144.48)
  TOP w0.191: PU1.18 150.6,149.27
  TOP w0.203: 150.6,149.27 150.83,149.03 150.83,148.88 151.4,148.31 v1(151.45,148.31) 151.61,148.31 152.22,148.92 PC7.1
  IN2 w0.114: v1(151.45,148.31) 151.9,147.86 151.9,147.46 150.45,146.01 150.45,145.65 148.95,144.15 147.47,144.15 146.81,143.49 142.15,143.49 141.45,144.19 137.38,144.19 136.55,145.03 132.84,145.03 v1(132.29,144.48)
  BOTTOM w0.14: PC95.2 153.37,148.41 PR140.2 v1(153.4,149.59) ; PR150.1 132.04,141.98 132.04,144.23 v1(132.29,144.48)
  BOTTOM w0.203: PC95.2 152.16,148.45 151.59,148.45 v1(151.45,148.31)
51624_CSN2: length 3.3
  TOP w0.178: PU1.19 150.71,149.67
  TOP w0.203: 150.71,149.67 151.14,149.67 151.44,149.36 v1(151.44,148.94)
  BOTTOM w0.203: PR138.1 v1(150.83,148.89) 151.36,148.89 151.44,148.97 v1(151.44,148.94)
51624_CSP1: length 32
  TOP w0.14: PR12.2 132.4,145.25 v1(132.29,145.25)
  TOP w0.191: PU1.17 150.31,148.87 150.48,148.7
  TOP w0.203: PC9.1 152.45,147.69 v1(151.48,147.69) 151.26,147.69 150.48,148.47 150.48,148.7
  IN2 w0.114: v1(151.48,147.69) 151.48,147.34 150.24,146.1 150.24,145.74 148.87,144.37 147.38,144.37 146.72,143.71 142.24,143.71 141.54,144.41 137.47,144.41 136.64,145.25 v1(132.29,145.25)
  BOTTOM w0.14: PR140.1 153.37,147.63 PC95.1 ; PR151.1 132.3,142.1 132.3,143.81 132.72,144.23 132.72,144.89 132.42,145.2 132.34,145.2 v1(132.29,145.25)
  BOTTOM w0.203: PC95.1 151.54,147.63 v1(151.48,147.69)
51624_CSP2: length 2.6
  TOP w0.191: PU1.20 150.45,150.07 150.46,150.06 151.53,150.06 v1(151.67,150.2)
  TOP w0.203: v1(151.67,150.2) 152.1,150.2 152.19,150.11 PR8.1
51624_DROOP: length 5.9
  TOP w0.191: 150.38,152.76 149.72,152.76 149.43,152.47 PU1.25
  TOP w0.203: PC1.1 151.48,154.67 151.22,154.67 PC4.1 150.46,153.41 v1(150.74,153.13) 150.38,152.76
  BOTTOM w0.203: v1(150.74,153.13) 150.74,153.76 PR131.1
51624_F-IMAX: length 4.4
  TOP w0.191: PU1.10 147.03,147.79 146.82,147.59 146.82,147.26 146.73,147.17
  TOP w0.203: PR16.1 146.26,146.19 146.73,146.65 v1(146.73,147.19)
  BOTTOM w0.203: PR142.2 146.27,146.19 146.73,146.65 v1(146.73,147.19)
51624_GFB: length 4
  TOP w0.191: PU1.23 150.81,151.27
  TOP w0.254: PR4.1 152.88,152.14 v1(152.87,152.13) 152.61,151.88 152.1,151.88 151.49,151.27 150.81,151.27
51624_IMON: length 4
  TOP w0.191: v1(148.41,147.14) 148.23,147.32 PU1.13
  TOP w0.203: PC10.1 149.3,146.17 148.41,147.06 v1(148.41,147.14)
  BOTTOM w0.203: v1(148.41,147.14) 148.41,147.6 148.34,147.67 PR139.1
51624_NC: length 3.3
  TOP w0.191: v1(144.85,150.57) 144.85,150.57 144.96,150.47 PU1.4
  BOTTOM w0.203: PR137.2 146.1,150.22 v1(145.74,150.57) v1(144.85,150.57)
51624_O-USR: length 5.6
  TOP w0.191: PU1.9 146.63,147.9 v1(146.14,147.41)
  TOP w0.203: PR15.1 144.65,146.83 v1(144.99,147.18) 145.22,147.41 v1(146.14,147.41)
  BOTTOM w0.203: v1(146.14,147.41) 145.96,147.41 145.53,146.97 145.53,146.72 144.99,146.19 PR15.1
51624_OCP-I: length 4.8
  TOP w0.191: 147.83,147.17 147.83,146.64 PR17.2 ; 147.83,147.17 v1(147.8,147.14) ; 147.83,147.17 PU1.12
  BOTTOM w0.203: PR139.2 147.56,147.61 147.8,147.37 v1(147.8,147.14) 147.8,146.53 148.14,146.19 PR145.1
51624_PWM1: length 6
  TOP w0.14: v1(141.84,149.39) 142.2,149.74 v1(142.63,149.74)
  TOP w0.191: PU1.6 145.27,149.67 145.22,149.72 144.34,149.72 144.21,149.59 143.65,149.59 143.49,149.74 v1(142.63,149.74)
  BOTTOM w0.178: PU7.8 142.55,149.67 v1(142.63,149.74)
51624_PWM2: length 2.4
  TOP w0.191: PU1.5 144.54,150.07 144.27,150.34 PR7.1
51624_SKIP#: length 9.6
  TOP w0.191: PU1.7 145.38,149.27 144.75,148.64 v1(144.62,148.64)
  BOTTOM w0.178: PU7.1 141.74,146.47
  BOTTOM w0.254: 141.74,146.47 142.2,146.92 142.2,148.07 142.68,148.55 144.53,148.55 v1(144.62,148.64) 144.88,148.64 145.25,149.01 v1(145.25,149.21) 145.25,149.46 144.49,150.22 PR136.1
51624_SLEWA: length 5.8
  TOP w0.191: PU1.15 149.03,147.79
  TOP w0.203: v1(150.44,147.17) 150.44,147.32 150.16,147.6 149.22,147.6 149.03,147.79
  BOTTOM w0.14: PR148.2 151.96,146.16 v1(152.99,146.16)
  BOTTOM w0.203: v1(150.44,147.17) 150.44,146.39 PR149.1 150.9,146.26 151.86,146.26 PR148.2
51624_THERM: length 11.6
  TOP w0.191: 149.19,147.14 148.63,147.71 PU1.14
  TOP w0.203: PC11.1 149.83,147.05 v1(149.83,147.14) 149.19,147.14
  IN2 w0.305: v1(144.1,146.67) 144.74,146.03 148.42,146.03 149.53,147.14 v1(149.83,147.14)
  BOTTOM w0.203: PR146.2 149.83,146.36 v1(149.83,147.14)
  BOTTOM w0.305: PR147.1 143.6,146.17 v1(144.1,146.67)
51624_V5A: length 4.5
  TOP w0.191: v1(148.13,153.11) 148.13,153.09 148.23,152.99 PU1.28
  TOP w0.203: v1(148.13,153.11) 148.13,153.19 147.79,153.53 PC3.1
  BOTTOM w0.14: PR132.1 146.92,154.82 v1(146.77,154.97)
  BOTTOM w0.203: PR132.1 147.28,153.96 v1(148.13,153.11)
51624_VBAT: length 4.7
  TOP w0.14: v1(152.99,146.16) 151.96,146.16 PR19.2
  TOP w0.191: PU1.16 150,148.27 151.34,146.92 151.34,146.54 151.72,146.16 PR19.2
51624_VDD: length 3.6
  TOP w0.191: v1(144.66,151.79) 144.95,151.79 145.48,151.27 PU1.2
  TOP w0.203: PC6.1 144.23,151.59 144.43,151.79 v1(144.66,151.79)
  BOTTOM w0.203: v1(144.66,151.79) 144.26,151.39 PR133.1
51624_VFB: length 2.6
  TOP w0.191: PU1.24 150.55,151.67
  TOP w0.254: 150.55,151.67 151.13,151.67 v1(151.6,152.13) 151.68,152.22 PR5.1
51624_VREF: length 28.2
  TOP w0.191: PU1.27 148.63,153.03 v1(148.75,153.16)
  TOP w0.203: PC2.1 147.79,154.64 148.75,153.68 v1(148.75,153.16) ; PR14.1 147.71,144.8 v1(148.04,144.8)
  IN1 w0.203: v1(148.04,144.8) 151.15,144.8 v1(151.32,144.97) 152.43,146.08 152.43,148.76 150.71,150.48 150.71,150.99 148.78,152.91 148.78,153.14 v1(148.75,153.16)
  BOTTOM w0.14: PR126.1 148.65,155.56 v1(148.04,154.95)
  BOTTOM w0.203: v1(148.04,144.8) 146.98,144.8 146.37,145.41 PR142.1 145.25,145.41 145.25,145.41 PR144.1 ; PR126.1 149.13,155.01 149.13,153.6 148.75,153.23 v1(148.75,153.16) ; PR148.1 151.55,144.97 v1(151.32,144.97)
  BOTTOM w0.305: PR144.1 144.63,145.39 PR147.2
51624_VRON: length 6.6
  TOP w0.191: v1(144.65,148.03) 145.49,148.87 PU1.8
  TOP w0.203: PR18.1 143.45,147.04 v1(143.6,147.18) 143.89,147.48 PR11.2 ; PR9.2 144.1,148.91 144.1,148.45 143.89,148.24 PR11.2 ; PR11.2 144.37,147.93 144.47,148.03 v1(144.65,148.03)
  BOTTOM w0.254: v1(144.65,148.03) 144.44,148.03 144.34,147.93 PR11.2
+DDR_VTT_RUN: length 120.3
  TOP w0.508: R360.1 v1(63.46,57.39) ; R355.1 v1(63.46,58.53) ; R334.1 126.2,62.82 126.65,62.37 126.65,61.69 126.32,61.36 126.32,59.93 126.96,59.29 127.72,59.29 128.1,58.91 128.1,57.16 127.8,56.85 127.8,55.91 127.21,55.33 v1(127.21,53.07) ; v1(70.04,52.46) 70.04,52.83 R371.1 ; R371.1 R372.1 R373.1 ; R371.1 R370.1 R369.1 R368.1 ; R351.1 v1(63.36,59.8) ; R364.1 v1(63.46,56.12) ; 64.08,62.34 v1(63.46,62.34) ; R346.1 v1(63.38,61.07)
  IN1 w1.524: 199.73,58.35 198.76,59.32 192.72,59.32 191.3,60.74 169.33,60.74 165.82,64.25 164.17,64.25 160.64,67.78 160.64,71.43
  IN2 w1.524: 127.09,51.93 125.13,49.97 113.04,49.97 112.59,50.43 97.67,50.43 97.31,50.78 90.64,50.78 ; 149.95,52.13 144.94,52.13 144.1,51.29 142.33,51.29
  BOTTOM w0.14: 64.08,62.34 v1(63.46,62.34)
  BOTTOM w0.508: R746.1 v1(63.46,58.53) R355.1 ; R346.1 v1(63.38,61.07) R742.1 ; R360.1 v1(63.46,57.39) R750.1 ; R351.1 v1(63.36,59.8)
  vias: v1(61.17,57.9) v1(61.27,64.55) v1(61.27,56.12) v1(61.73,61.73) v1(62.7,65.26) v1(70.65,52.43) v1(160.28,84.82) v1(160.28,84.18) v1(160.28,83.42) v1(160.49,76.06) v1(160.77,76.95) v1(160.74,72.37) v1(161.02,72.93) v2(161.5,72.48) v2(201.05,57.39) v2(201.61,56.93)
+FB_PLLAVDD: length 35.4
  TOP w0.508: C115.1 28.28,136.03 27.26,135.01 v1(27.26,134.86) ; C115.1 L13.1 ; C115.1 28.43,136.38 v1(29.55,136.38) ; v1(49.24,132.83) 49.01,133.06 C129.2 ; C110.2 48.65,136.72 v1(48.4,136.97) ; v1(42.58,137.02) 42.58,136.84 41.95,136.21 C116.1
  IN2 w0.508: 48.6,135.75 48.6,133.21 48.97,132.83 v1(49.24,132.83) ; 48.6,135.75 48.6,136.77 v1(48.4,136.97) ; 48.6,135.75 47.33,135.75 47.08,135.49 42.5,135.49 42.12,135.87 ; 42.12,135.87 42.12,136.38 42.58,136.84 v1(42.58,137.02) ; 42.12,135.87 36.79,135.87 35.77,136.89 29.93,136.89 29.55,136.51 v1(29.55,136.38)
  BOTTOM w0.305: v1(42.58,137.02) 42.6,137.02 U43.P22
  BOTTOM w0.381: v1(49.24,132.83) 49.66,132.41 U43.F16 ; U43.H22 47.96,137.41 v1(48.4,136.97)
+G_SEN_PW: length 5.5
  BOTTOM w0.254: v1(216.07,53.07) U54.8 ; 216.07,57.39 U54.14
  BOTTOM w0.508: v1(216.65,59.45) C722.1 216.65,58.43 216.07,57.85 216.07,57.39 ; R754.2 v1(221.57,55.36) ; R760.2 217.38,51.04 v1(217,50.66)
  vias: v1(218.4,51.55) v1(218.53,57.64) v1(218.53,57.01)
+PCH_VCCDSW: length 6.4
  TOP w0.254: v1(134.83,117.71) 134.53,118.02 133.93,118.02 C240.1 133.5,117.4 132.76,116.65 v1(132.76,115.65) 132.56,115.84 132.06,115.84 C250.1
  BOTTOM w0.254: v1(132.76,115.65) 133.12,115.65 U45.AG20 U45.AG19
+SMDDR_VREF_DIMM: length 208.1
  TOP w0.305: U28.M8 v1(74.96,60.53) ; U31.M8 v1(120.19,60.51) ; v1(106.96,60.53) U30.M8 ; U29.M8 v1(88.16,60.53)
  TOP w0.508: C436.1 84.48,54.35 83.88,54.95 83.3,54.95 v1(83.27,54.97) ; v1(99.15,61.99) 98.26,61.99 97.86,61.59 C408.1 93.69,61.59 93.05,60.94 92.42,60.94 C411.1 92.4,60.94 91.65,60.94 v1(91.53,61.07) ; C437.1 74.43,54.52 v1(74.89,54.97) ; v1(114,52.56) 114.01,52.55 C466.1 ; v1(65.24,55.48) 64.35,55.48 64.09,55.23 64.09,54.86 R366.2 64.09,54.84 64.09,53.84 C439.2 C438.1 R365.1 62.63,55.09 62.24,55.48 59.4,55.48 58.99,55.89 R363.2
  TOP w0.762: C357.1 138.89,76.06 138.77,76.18 138.77,76.18 138.49,76.46 C339.1 137.63,74.68 v1(137.12,74.17) ; v1(123.66,60.94) 123.86,60.74 125.08,60.74 125.49,60.33 C412.1
  IN2 w0.508: v1(88.16,60.53) 88.71,61.07 90.26,61.07 90.38,60.94 91.4,60.94 v1(91.53,61.07) ; v1(123.66,60.94) 122.77,60.94 122.72,60.99 120.68,60.99 v1(120.19,60.51) ; 132.42,59.42 132.42,60.82 131.66,61.58 129.5,61.58 127.59,59.67 125.69,59.67 125.31,59.29
  IN2 w0.635: 125.31,55.36 125.56,55.1 128.23,55.1 129.37,56.24 131.53,56.24 132.29,57.01 132.29,57.64
  IN2 w0.762: 74.89,54.24 82.81,54.24 83.27,54.7 v1(83.27,54.97) ; 74.89,54.24 74.2,54.24 72.91,52.94 71.97,52.94 70.7,54.21 70.06,54.21 ; 74.89,54.24 v1(74.89,54.97) 74.89,57.13 74.66,57.36 74.66,60.23 v1(74.96,60.53) ; 106.13,52.82 113.75,52.82 v1(114,52.56) ; 106.13,52.82 106.03,52.92 106.03,55 v1(106.13,55.1) 106,55.23 106,59.93 106.6,60.53 v1(106.96,60.53) ; 106.13,52.82 97.11,52.82 96.78,52.49 94.19,52.49 ; 94.19,52.49 94.19,53.96 92.67,55.48 92.67,57.77 91.53,58.91 v1(91.53,61.07) ; 94.19,52.49 85.07,52.49 84.54,53.02 84.54,54.19 83.75,54.97 v1(83.27,54.97) ; 70.06,54.21 70.06,59.81 v1(69.36,60.52) ; 70.06,54.21 65.62,54.21 65.11,54.72 65.11,55.36 v1(65.24,55.48) ; v1(114,52.56) 114.64,52.56 115.4,51.8 122.77,51.8 124.04,53.07 124.04,54.09 125.31,55.36 125.31,59.29 v1(123.66,60.94) ; v1(114,52.56) 114,57.26 115.4,58.66 115.4,59.69 v1(114.57,60.53) ; v1(83.27,54.97) 83.27,56.5 83.91,57.13 83.91,59.19 v1(82.56,60.53) ; v1(137.12,74.17) 138.01,75.07 139.91,75.07 140.62,74.36 140.62,72.56 141.18,71.99 141.18,69.07 139.66,67.55 139.66,65.34 136.61,62.29 136.61,60.82 135.9,60.1 135.9,58.83 135.21,58.15 134.02,58.15
  BOTTOM w0.178: 100.05,61.33 101.35,61.33 101.75,60.93 U52.M8
  BOTTOM w0.254: JDIM1.126 136.28,74.48 136.59,74.17 v1(137.12,74.17)
  BOTTOM w0.305: U51.M8 v1(82.56,60.53) ; v1(69.36,60.52) 69.36,60.53 U50.M8 ; U53.M8 v1(114.57,60.53)
  BOTTOM w0.508: C741.1 105.62,54.59 v1(106.13,55.1) ; v1(99.15,61.99) 99.4,61.99 100.05,61.33
+SMDDR_VREF_DQ0: length 175.6
  TOP w0.254: U30.H1 100.53,64.13 99.78,64.88 98.66,64.88 ; v1(111.21,64.37) 113.92,64.37 U31.H1
  TOP w0.305: v1(78.7,64.78) 79.43,64.78 80.09,64.13 U29.H1 ; U28.H1 68.4,64.13 68.07,64.46 66.68,64.46 66.29,64.07 v1(65.49,64.07)
  TOP w0.508: v1(123.4,63.73) 123.54,63.86 C401.1 ; 63.33,64.25 63.72,64.64 C390.2 R327.2 R325.1 63.72,69.61 R322.2 ; 63.33,64.25 65.31,64.25 v1(65.49,64.07) ; 63.33,64.25 62.83,63.75 C406.1
  TOP w0.762: 98.66,64.88 97.9,64.12 C404.1 v1(94.7,64.12) 94.67,64.14 C403.1 91.83,64.14 v1(91.55,64.42)
  IN3 w0.762: v2(95.08,53.7) 94.6,54.19 92.13,54.19 92.01,54.06 89.8,54.06 88.22,52.49 85,52.49 83.65,53.83 79.59,53.83 ; 79.59,53.83 79.33,53.58 v2(79.33,52.54) ; 79.59,53.83 74.03,53.83 73.2,52.99 72.3,52.99 71.25,54.04 66.7,54.04 66.38,54.37 65.57,54.37 65.18,54.75 64.93,54.75 64.46,55.22 64.46,63.03 v1(65.49,64.07)
  BOTTOM w0.254: U51.H1 88.97,64.13 89.27,64.42 v1(91.55,64.42) ; 108.92,64.13 U52.H1
  BOTTOM w0.305: U50.H1 76.49,65.26 78.22,65.26 v1(78.7,64.78) ; v1(123.4,63.73) 122.33,64.8 121.17,64.8 120.57,64.21 U53.H1
  BOTTOM w0.508: v1(111.21,64.37) 109.17,64.37 108.92,64.13
  BOTTOM w0.762: v1(111.21,64.37) 111.21,63.1 110.58,62.47 110.58,59.8 111.32,59.06 C762.1 111.32,51.29 ; v1(123.4,63.73) 124.66,63.73 125.19,64.25 126.44,64.25 128.23,62.47 128.23,56.52 126.69,54.99 124.94,54.99 123.66,53.7 123.66,52.69 121.52,50.56 112.95,50.56 C765.1 111.58,51.03 111.32,51.29 ; 79.01,53.82 79.01,63.73 78.7,64.04 v1(78.7,64.78) ; 111.32,51.29 111.32,50.8 111.08,50.56 v3(98.54,50.56) 97.62,50.56 95.08,53.1 v2(95.08,53.7) 94.76,54.02 94.76,54.9 95.08,55.22 95.08,61.2 94.7,61.58 v1(94.7,64.12)
+SMDDR_VREF_DQ1:
  vias: v1(95.41,81.52) v1(95.74,82.99) v3(96.83,87.79)
+TPVDD:
  vias: v1(91.02,50.66)
+VGACORE: length 98.3
  TOP w0.254: v1(46.75,125.7) 46.75,125.38 46.58,125.21 C186.2
  TOP w0.381: C169.2 44.96,125.27 v1(44.61,125.62)
  TOP w0.508: C125.2 45.6,133.92 v1(45.6,134.2)
  IN1 w0.381: v2(59.39,96.76) 65.57,96.76 66.28,96.05 66.28,86.39 65.39,85.51 65.39,81.54 63.65,79.8 59.41,79.8 58.39,78.78 58.39,77.86 58.86,77.39 v1(58.86,76.87)
  IN2 w0.203: v1(58.86,76.87) 58.86,76.29 56.61,74.03 v1(56.61,69.84)
  BOTTOM w0.203: PR183.2 v1(56.61,69.84)
  BOTTOM w0.381: U43.K16 47,132.76 U43.L17 46,133.8 45.82,133.98 v1(45.6,134.2) 45.6,134.2 45.56,134.2 U43.M18 ; U43.V18 39,134.76 v1(39.5,134.26) 40,133.76 U43.U17 40.5,133.26 40.5,133.26 41,132.76 U43.T16 41.5,132.26 v1(41.5,132.26) 42,131.76 U43.R15 42.5,131.26 42.5,131.26 43,130.76 ; v1(39,125.7) 39,125.7 U43.V10 ; v1(38.36,130.9) 38.86,130.9 U43.V14 U43.U13 40.5,129.26 v1(40.5,129.26) 41,128.76 U43.T12 41.28,128.48 v1(41.28,128.26) 41.5,128.26 U43.R11 U43.P10 ; v1(47.63,134.76) U43.K18 ; U43.K12 46.88,128.76 v1(46.39,129.25) 46,129.64 U43.L13 U43.M14 45,130.76 44,131.76 U43.N15 v1(43.52,132.24) U43.P16 43,132.76 42,133.76 U43.R17 42,133.76 v1(41.5,134.26) 41,134.76 U43.T18 ; U43.P12 43,128.76 ; 43,128.76 44,127.76 U43.N11 44.07,127.76 45,126.83 U43.M10 45,126.01 v1(44.61,125.62) ; 43,128.76 v1(42.5,129.26) 42,129.76 U43.R13 41.82,129.76 v1(41.31,130.27) 41.31,130.45 U43.T14 U43.U15 40,131.76 v1(39.5,132.26) 39.5,132.26 U43.V16 38.62,133.14 v1(38.62,133.32) ; v1(41.2,125.76) 41.19,125.76 41.19,126.57 U43.T10 41,126.76 v1(40.5,127.26) 40.5,127.26 U43.U11 39.5,128.26 39.5,128.26 39,128.76 U43.V12 38.89,128.87 38.36,128.87 v1(38.24,129) ; 43.43,134.33 U43.N17 45,132.76 U43.M16 v1(45.5,132.26) 46,131.76 U43.L15 47,130.76 U43.K14 ; 43.43,134.33 v1(43.44,134.33) ; 43.43,134.33 U43.P18 ; 43,130.76 44,129.76 U43.N13 44,129.76 v1(44.5,129.26) 45,128.76 U43.M12 45.5,128.26 45.5,128.26 46,127.76 U43.L11 46.5,127.26 46.5,127.26 47,126.76 U43.K10 47,125.9 46.8,125.7 v1(46.75,125.7) ; 43,130.76 U43.P14
  vias: v1(47.81,129.94) v1(59.34,97.75) v2(42.22,96.22) v2(42.4,98.43) v2(43.34,98.79) v2(43.37,97.93) v2(43.39,97.06) v2(43.39,96.28) v2(44.54,98.79) v2(44.56,97.88) v2(44.59,97.01) v2(44.54,96.25) v2(45.81,98.79) v2(45.78,96.05) v2(45.83,97.93) v2(45.83,96.96) v2(46.95,98.82) v2(46.95,97.95) v2(46.95,96.96) v2(46.95,96.05) v2(48.12,98.82) v2(48.12,97.98) v2(48.09,96.96) v2(48.09,96.07) v2(48.07,95.01) v2(53.43,94.73) v2(54.31,94.73) v2(55.15,98.71) v2(55.18,97.8) v2(55.15,96.81) v2(55.2,95.74) v2(55.2,94.73) v2(56.12,98.71) v2(56.17,97.77) v2(56.14,96.81) v2(56.22,95.74) v2(56.22,94.73) v2(57.21,97.7) v2(57.24,96.76) v2(57.24,95.74) v2(57.24,94.73) v2(58.25,97.7) v2(58.25,96.76) v2(58.25,95.74) v2(58.25,94.73) v2(59.27,95.74) v2(59.27,94.73) v3(41.49,122.77) v3(49.31,96.25)
+VREF_CA_CPU: length 98.2
  TOP w0.508: v1(90.71,94.04) 92.92,96.25 92.92,102.97 94.08,104.12 v3(95.34,104.12) 98.26,104.12 99.78,105.65 103.72,105.65 105.5,107.43 108.29,107.43 110.32,109.46 111.98,109.46 112.47,109.95 112.47,110.97 113.01,111.52 113.94,111.52 v1(114.55,110.91) ; R358.2 58.99,58 v1(59.52,58.53)
  IN2 w0.508: v1(59.52,58.53) 60.66,59.67 60.66,64.27 60.44,64.5 60.44,69.22 62.19,70.98 62.19,72.7 63.38,73.9 64.09,73.9 64.86,74.66 64.86,75.93 65.49,76.56 82.25,76.56 88.2,82.51 88.2,90.56 89.37,91.73 90.94,91.73 91.65,92.44 91.65,93.46 91.07,94.04 v1(90.71,94.04)
  BOTTOM w0.254: U45.AP49 115.04,111.21 114.74,110.91 v1(114.55,110.91)
+VREFDQ_SA_M3: length 85
  TOP w0.508: R305.1 62.57,72.5 62.57,73.14 62.85,73.42 62.85,74.89 v3(63.71,75.75) 64.4,75.75 68.26,71.89 86.75,71.89 88.91,74.05 91.93,74.05 93.18,72.81 v1(96.58,72.81)
  IN2 w0.508: v1(96.58,72.81) 96.63,72.86 96.63,78.8 96.53,78.9 96.53,79.71 96.94,80.12 96.94,89.16 112.12,104.35 112.12,106.16 111.79,106.49 111.79,107.56 113.65,109.42 v1(113.65,110.23)
  BOTTOM w0.254: v1(113.65,110.23) 113.71,110.23 114.04,110.56 U45.AR51
+VREFDQ_SB_M3: length 32.7
  TOP w0.508: R268.1 94.99,91.9 95.28,92.18 96.34,92.18 97,91.52 100.39,91.52 100.92,92.06 v3(100.92,94.98) 100.92,95.49 106.51,101.08 v1(107.15,101.08)
  IN2 w0.508: v1(107.15,101.08) 107.15,101.2 110.83,104.89 110.83,107.85 112.76,109.78 112.76,110.6 113.04,110.88 v1(113.65,110.88)
  BOTTOM w0.254: v1(113.65,110.88) 113.97,111.21 U45.AP51
+WL_VDD: length 25
  TOP w0.508: R269.2 207.45,91.44 v1(207.45,92.05) ; v1(203.6,92.63) 203.42,92.63 203.03,93.02 R251.2 202.4,92.43 202.4,91.17 202.13,90.91 R265.2 ; R245.2 196.44,93.7 196.17,93.96 v1(196.17,94.22)
  IN2 w0.508: v1(207.45,92.05) 209.85,89.65 211.79,89.65 212.81,88.63 v1(212.81,82.28)
  BOTTOM w0.305: 218.78,90.99 219.31,90.46 CN12.72 221.04,90.46 221.24,90.66 221.24,91.37 221.07,91.55
  BOTTOM w0.508: R700.2 213.07,81.26 212.81,81.52 v1(212.81,82.28)
  vias: v1(218.42,72.63) v1(218.4,71.87) v1(220.76,92.67) v1(220.76,92.06)
A_LAD0_R: length 3.6
  BOTTOM w0.14: CN12.64 219.03,88.46 218.69,88.12 217.64,88.12 217.51,88 217.51,87.99 R696.2
A_LAD1_R: length 36
  BOTTOM w0.14: R694.1 215.08,89.11 216.53,89.11 R695.2 217.34,88.96 CN12.66 220.99,88.96 222.39,87.56 222.39,80.22 221.75,79.59 218.37,79.59 214.84,76.06 v1(213.7,76.06) 211.16,76.06 210.65,76.56 210.65,77.17 213.22,79.74 R706.1 R707.1
A_LAD2_R: length 16.5
  TOP w0.14: Q22.3 206.6,92.44 206.84,92.69 R252.1 207.99,92.69 208.37,92.31 208.37,91.63 208.63,91.36 R269.1 209.03,90.64 v1(210.02,90.64) v1(210.91,90.64)
  BOTTOM w0.14: CN12.68 219.4,89.46 218.93,89.93 217.94,89.93 217.59,90.28 R693.2 212.95,90.79 211.06,90.79 v1(210.91,90.64)
A_LAD3_R: length 19.8
  TOP w0.14: R251.1 203.41,93.85 203.54,93.97 R248.1 204.44,93.97 204.68,93.74 204.68,93.38 v1(204.73,93.33) 205.11,93.71 Q22.6
  BOTTOM w0.14: CN12.70 219.28,89.96 218.96,90.28 218.28,90.28 217.26,91.3 v1(215.73,91.3) R691.2 212.82,91.93 211.16,91.93 209.73,93.36 204.76,93.36 v1(204.73,93.33)
A_LFRAME#_R: length 5.1
  TOP w0.14: R790.2 224.86,89.39 224.86,89.57 225.86,90.57 226.28,90.57 v1(226.4,90.69) 226.6,90.48 227.05,90.48 R270.2
  BOTTOM w0.14: v1(226.4,90.69) 226.42,90.71 CN12.73
AC_PROTECT: length 114.8
  TOP w0.102: 149.44,67.17 U32.109
  TOP w0.14: PR90.1 60.44,65.37 61.04,65.37 v1(61.05,65.36) ; v1(147.96,64.78) 147.96,65.35 149.44,66.83 149.44,67.17
  IN2 w0.114: v1(147.96,64.78) 147.43,64.25 146.64,64.25 146.38,64.51 146.38,64.97 145.82,65.53 145.28,65.53 144.07,66.75 143.38,66.75 142.5,65.87 142.5,64.8 139.79,62.09 139.79,56.24 138.52,54.97 137.4,54.97 136.88,55.49 129.75,55.49 128.35,54.09 126.2,54.09 123.34,51.23 115.14,51.23 114.37,51.99 113.81,51.99 113.53,52.28 97.92,52.28 97.59,51.95 82.15,51.95 80.81,53.29 74.01,53.29 73.13,52.4 71.74,52.4 70.47,53.67 65.39,53.67 64.35,54.72 64.35,59.42 62.82,60.94 62.82,61.32 61.71,62.44 61.71,64.7 v1(61.05,65.36)
ACCEL_INTA: length 111.4
  IN1 w0.114: v1(143.82,114.99) 144.04,114.99 145.7,113.32 148.62,113.32 148.85,113.09 151.98,113.09 152.19,112.87 152.35,112.87 153.65,111.57 153.65,111.21 154.9,109.97 155.66,109.97 156.42,109.2 156.42,106.41 157.51,105.32 157.51,103.69 156.94,103.12 156.94,101.67 156.3,101.03 156.3,99.68 156.68,99.3 161.71,99.3 164.19,96.82 172.73,96.82 177.54,92.01 v1(178.42,92.01)
  BOTTOM w0.089: U45.AG3 143.52,115.29 v1(143.82,114.99)
  BOTTOM w0.14: D33.1 214.61,59.96 C721.2 214.72,60.56 213.19,62.09 213.19,65.85 207.43,71.61 203.03,71.61 201.94,72.71 201.94,80.84 200.83,81.94 200.83,84.73 196.81,88.76 192.87,88.76 190.97,90.66 v1(181.19,90.66) 179.84,92.01 v1(178.42,92.01)
ACCEL_INTA_R: length 3.2
  BOTTOM w0.14: U54.11 214.44,55.36 v1(214.33,55.46) 213.32,56.47 D33.2
ACIN: length 187.8
  TOP w0.14: v1(154.59,56.24) 154.87,56.53 U32.72 ; v1(44.17,81.58) 44.4,81.58 45.25,80.73 PR49.1 45.25,79.95 45.04,79.74 45.04,79.36 45.22,79.18 PQ13.3
  IN1 w0.114: v1(30.72,76.56) 31.26,76.02 31.26,74.04 31.77,73.53 31.77,69.82 30.21,68.26 30.21,67.04 30.71,66.53 30.71,65.37 30.1,64.75 30.1,61.16 30.86,60.39 30.86,58.6 30.19,57.93 30.19,49.97 32.04,48.12 36.41,48.12 38.15,49.86 49.63,49.86 50.07,50.3 52.37,50.3 55.48,53.41 60.76,53.41 61.91,52.26 63.71,52.26 63.91,52.06 65.04,52.06 65.7,51.4 67.46,51.4 68.04,50.82 70.73,50.82 72.19,49.36 77.2,49.36 77.81,49.96 81.78,49.96 82.13,49.61 89.18,49.61 90.05,50.48 96.74,50.48 97.21,50.01 109.11,50.01 111.13,47.98 118.27,47.98 119.83,49.54 128.41,49.54 131.16,52.29 133.16,52.29 v1(134.58,53.7)
  IN2 w0.114: v1(44.17,81.58) 42.07,79.47 34.11,79.47 31.2,76.56 v1(30.72,76.56)
  BOTTOM w0.14: v1(154.59,56.24) 154.59,55.68 153.93,55.02 146.35,55.02 145.93,54.59 141.06,54.59 139.8,55.85 139.8,56.63 139.42,57.01 135.85,57.01 135.09,56.24 135.09,54.21 v1(134.58,53.7)
ACPRESENT: length 169.4
  TOP w0.14: PR54.2 42.26,77.01 42.49,76.78 PR58.1 43.11,76.46 43.39,76.18 v1(43.65,76.18) ; R239.1 142.05,97.26 141.94,97.15 141.43,97.15 138.62,94.34 v3(138.62,91.93) 138.62,89.93 141.83,86.72 v1(143.72,86.72)
  IN1 w0.114: v1(43.65,76.18) 43.57,76.11 43.57,74.99 44.13,74.43 46.03,74.43 47.33,73.14 47.33,72.15 48.7,70.77 49.18,70.77 51.11,68.85 51.11,68.11 51.64,67.58 53.24,67.58 53.72,68.06 57.24,68.06 58.48,69.3 59.8,69.3 60.05,69.05 60.05,67.7 61.34,66.41 61.8,66.41 64.17,64.04 64.17,54.52 64.45,54.24 66.38,54.24 66.72,53.9 70.4,53.9 72.87,51.43 76.52,51.43 77.09,52 79.53,52 79.9,52.37 81.08,52.37 81.37,52.07 87.97,52.07 88.32,52.42 110.97,52.42 113.46,49.93 117.34,49.93 118.93,51.52 126.57,51.52 129.38,54.33 129.38,54.99 130.11,55.73 132.79,55.73 135.72,58.66 137.37,60.31 137.37,64.98 136.83,65.52 136.83,72.42 140.38,75.97 141.73,75.97 143.21,77.45 143.21,86.21 v1(143.72,86.72)
ACZ_SDIN0_R: length 3.8
  TOP w0.127: U34.8 230.84,39.52 230.33,40.03 229.33,40.03 v1(229.17,39.86) 229.04,39.73 R405.1
ADOGND: length 27.1
  TOP w0.203: U34.38 236.58,44.02 v1(236.74,44.18) ; v1(238.34,37.28) 238.34,37.7 238.13,37.92 U34.25
  TOP w0.381: C500.2 241.01,38.49 240.68,38.16 v1(240.68,37.97)
  TOP w0.508: R407.2 243.59,39.19 v1(243.94,39.19) ; C505.2 v1(243.29,35.04) ; v1(236.31,29.3) 235.78,29.3 R417.1 ; v1(236.18,23.61) 236.18,24.12 D23.2 ; C506.2 238.97,35.79 v1(238.64,36.12) ; C483.1 235.81,48.13 v1(236.31,48.62) ; v1(240.37,47.61) 240.09,47.89 C480.1 ; R424.2 v1(240.24,26.15) ; C515.1 v1(239.48,27.8) ; v1(241.12,47.73) 240.75,48.1 C478.2 ; R381.2 243.93,51.41 v1(243.93,50.78) ; R396.1 v1(241.77,46.85) ; v1(236.05,27.29) 235.68,26.92 C514.1 ; v1(239.86,23.73) 239.36,24.23 D24.2 ; R413.1 233.77,31.35 v1(234.3,31.35) ; R414.1 234.94,30.18 v1(235.44,30.18) ; v1(243.26,50.58) 243.69,50.16 R390.1 ; v1(236.18,12.81) 235.67,13.32 R427.1 ; v1(241.3,37.95) 241.99,37.25 C504.2 ; R411.2 v1(233.51,32.88) ; C488.2 v1(236.18,46.85) ; C479.2 236.81,49.62 v1(236.81,50.15) 236.82,50.16 R383.1 ; v1(244.05,37.58) 244.05,38.19 C501.2 ; v1(240.24,24.37) 240.61,24.37 D25.2 ; C507.2 v1(241.99,35.19) ; D26.2 v1(241.38,8.23) ; v1(240.12,46.72) 239.58,46.72 C486.2
  BOTTOM w0.508: C514.1 235.68,26.14 v1(236.18,25.64)
  vias: v1(236.31,49.26) v1(237.7,27.42) v1(241.26,24.62) v1(243.24,51.19)
ALERT: length 18.5
  BOTTOM w0.102: U43.F8 49.66,125.76 49.23,125.33 49.23,124.83 48.97,124.57 47.84,124.57 47.58,124.32 47.58,124.06 47.2,123.68 46.19,123.68 45.93,123.43 45.93,122.28 45.73,122.08 44.46,122.08 44.28,121.9 44.28,119.49 43.9,119.11
  BOTTOM w0.14: 43.9,119.11 42.3,117.51 42.3,116.62 41.36,115.68 v1(41.36,114.66) 41.36,114.04 R624.1
AMP_MUTE#: length 98.2
  TOP w0.14: v1(174.89,45.35) 184.2,45.35 191.09,38.46 217.89,38.46 221.57,42.15 223.73,42.15 224.88,43.29 224.88,44.87 v1(225.46,45.45) 225.48,45.47 D18.1 ; U32.108 149.84,66.81 148.88,65.85 v1(148.88,65.01)
  IN1 w0.114: v1(174.89,45.35) 173.91,46.34 172.42,46.34 169.5,49.26 165.69,49.26 161.67,53.29 161.67,54.89 159.99,56.56 159.48,56.56 156.71,59.34 156.71,61.37 155.88,62.2 153.44,62.2 153.09,62.54 152.61,62.54 151.42,63.74 149.72,63.74 149.31,64.14 149.31,64.58 v1(148.88,65.01)
