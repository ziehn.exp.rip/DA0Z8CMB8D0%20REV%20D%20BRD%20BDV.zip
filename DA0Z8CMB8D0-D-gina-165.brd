# Allegro board DA0Z8CMB8D0-D-gina-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_BS#2: length 142.7
  TOP w0.102: U29.M3 83.76,60.89 84.68,59.98 85.18,59.98 85.25,60.05 85.25,60.21 85,60.46 v1(84.78,60.46) ; v1(116.67,60.12) 116.71,60.16 116.71,60.6 116.66,60.65 116.48,60.65 116.42,60.59 116.42,60.45 116.34,60.37 116.28,60.37 116.06,60.59 116.06,60.66 116.27,60.88 116.27,60.99 116.09,61.17 115.96,61.17 115.77,60.98 U31.M3 ; v1(67.27,60.05) 67.24,60.03 65.91,60.03 65.8,59.93 65.36,59.93 65.24,59.8 R351.2 ; U28.M3 70.61,60.98 70.7,60.98 70.8,60.88 70.8,60.64 70.88,60.56 70.95,60.56 71.05,60.66 71.23,60.66 71.28,60.61 71.28,60.54 71.09,60.35 71.09,60.03 71.15,59.96 71.55,59.96 71.63,60.04 71.63,60.21 v1(71.58,60.26) ; U30.M3 102.56,60.95 102.75,61.15 103.11,61.15 103.16,61.1 103.16,60.99 102.97,60.81 102.97,60.7 103.08,60.59 103.19,60.59 103.43,60.84 103.54,60.84 103.74,60.63 103.74,60.49 v1(103.53,60.27)
  IN1 w0.178: v1(116.67,60.12) 116.17,60.12 115.13,59.08 115.13,58.8 114.8,58.47 112.8,58.47 112.44,58.82 112.44,58.97 110.98,60.44 109.77,60.44 108.25,58.91 106.48,58.91 106.13,59.26 106.13,60.03 106,60.15 104.59,60.15 104.49,60.05 103.75,60.05 v1(103.53,60.27) 102.03,60.27 100.87,59.12 98.97,59.12 98.38,58.53 92.89,58.53 92.53,58.89 87.61,58.89 86.12,60.38 85.8,60.38 85.58,60.16 85.18,60.16 84.87,60.46 v1(84.78,60.46) 84.69,60.46 83.13,58.9 83.13,58.8 82.74,58.4 81.13,58.4 79.99,59.55 77.38,59.55 76.89,59.06 75.19,59.06 73.98,60.28 72.59,60.28 72.44,60.13 72.02,60.13 71.89,60.26 v1(71.58,60.26) 70.34,60.26 70.16,60.07 68.54,60.07 68.46,59.99 67.33,59.99 v1(67.27,60.05)
  IN1 w0.203: v1(126.96,61.1) 126.65,60.79 125.38,60.79 124.27,59.67 123.28,59.67 122.79,59.19 121.7,59.19 121.38,58.87 119.5,58.87 118.17,60.21 117.79,60.21 117.66,60.08 116.71,60.08 v1(116.67,60.12)
  IN3 w0.076: v1(119.65,106.45) 120.25,105.85 120.25,104.24 120,103.99 120,102.19 120.35,101.84 120.35,101.69
  IN3 w0.152: v1(126.96,61.1) 126.96,63 125.58,64.38 125.58,72.2 124.19,73.59 124.19,74.53 121.88,76.84 121.88,80.01 121.17,80.73 121.17,83.22 119.69,84.7 119.69,99.55 120.35,100.21 120.35,101.69
  BOTTOM w0.102: U53.M3 118.96,60.93 118.19,60.16 117.83,60.16 117.77,60.1 116.7,60.1 v1(116.67,60.12) ; v1(103.53,60.27) 103.68,60.13 104.28,60.13 104.3,60.12 104.99,60.12 105.76,60.88 U52.M3 ; U51.M3 86.96,60.93 86.29,60.26 85.99,60.26 85.95,60.3 85.67,60.3 85.61,60.23 84.92,60.23 84.78,60.37 v1(84.78,60.46) ; U50.M3 73.58,60.93 73.49,60.84 73.49,60.64 73.1,60.25 72.6,60.25 72.53,60.17 71.66,60.17 v1(71.58,60.26) ; v1(119.65,106.45) 120.08,106.87 120.08,106.92 120.08,106.92 120.08,107.27 120.08,107.27 U45.AY41
M_A_CAS#: length 153.1
  TOP w0.102: v1(103.27,62) 103.27,62.26 103.34,62.34 103.77,62.34 103.84,62.42 103.84,62.67 103.77,62.75 103.01,62.75 102.93,62.67 102.93,62.42 102.85,62.34 102.75,62.34 U30.K3 ; v1(86.34,62.2) 86.34,62.42 86.27,62.49 85.71,62.49 85.66,62.44 83.85,62.44 U29.K3 ; v1(72.2,62.25) 72.2,62.01 72.12,61.93 71.64,61.93 71.56,62.01 71.56,62.19 71.48,62.26 71.31,62.26 71.23,62.19 71.23,62.01 71.15,61.93 70.93,61.93 70.85,62.01 70.85,62.43 70.75,62.53 U28.K3 ; U31.K3 116.08,62.21 118.23,62.21 v1(118.44,62.43)
  IN1 w0.203: v1(118.44,62.43) 119.44,63.42 122.07,63.42 123.17,64.52 133.48,64.52 134.07,65.11 v1(134.83,65.11)
  IN3 w0.076: v1(124.4,109.1) 125.28,108.22 125.28,100.45 126.17,99.56 126.17,99.02
  IN3 w0.14: v1(118.44,62.43) 118.28,62.26 116.44,62.26 115.88,61.71 113.65,61.71 112.63,62.72 110.07,62.72 109.26,61.92 104.71,61.92 104.37,62.26 103.53,62.26 v1(103.27,62) 102.97,62.29 102.79,62.29 102.63,62.13 100.02,62.13 99.59,62.56 98.81,62.56 98.69,62.43 98.69,62 98.56,61.87 98.36,61.87 98.23,62 98.23,62.43 98.1,62.56 97.9,62.56 97.77,62.43 97.77,62 97.65,61.87 97.44,61.87 97.32,62 97.32,62.11 97.19,62.24 96.99,62.24 96.86,62.11 96.86,62 96.73,61.87 93.9,61.87 93.81,61.96 90.88,61.96 90.85,62 90.82,62 90.81,62 90.46,62 90.45,62 89.52,62 89.39,62.13 89.39,62.19 89.26,62.32 88.96,62.32 88.83,62.19 88.83,62.13 88.71,62 88.4,62 88.27,62.13 88.27,62.19 88.15,62.32 87.84,62.32 87.72,62.19 87.72,62.13 87.59,62 87.28,62 87.16,62.13 87.16,62.19 87.03,62.32 86.47,62.32 v1(86.34,62.2) 86.22,62.32 85.06,62.32 84.74,62 84.09,62 83.93,61.83 79.69,61.83 79.56,61.71 79.56,61.35 79.43,61.22 77.35,61.22 77.22,61.35 77.22,61.52 77.1,61.65 75.22,61.65 74.9,61.98 72.47,61.98 v1(72.2,62.25) 72.09,62.35 68.93,62.35 68.59,62.7 66.99,62.7 v1(66.25,61.96)
  IN3 w0.152: v1(134.83,65.11) 135.37,65.64 135.37,72.12 135.67,72.43 135.67,73.54 135.19,74.02 135.19,75.57 133.71,77.05 133.71,78.13 132.92,78.92 132.92,82.74 132.25,83.41 131.87,83.41 130.92,84.36 130.3,84.99 130.3,85.77 128.38,87.69 128.38,88.8 126.17,91.01 126.17,99.02
  BOTTOM w0.102: v1(124.4,109.1) 124.55,109.1 U45.AU34 ; v1(66.25,61.96) 66.05,61.76 65.21,61.76 65.15,61.71 63.34,61.71 63.19,61.86 ; U50.K3 73.76,62.16 73.68,62.09 72.68,62.09 72.45,61.86 72.45,61.78 72.35,61.68 72.12,61.68 72.07,61.73 72.07,62.12 v1(72.2,62.25) ; U52.K3 105.76,62.22 105.53,62 v1(103.27,62) ; v1(118.44,62.43) 117.71,62.43 117.64,62.35 117.64,62.04 117.71,61.96 118.63,61.96 118.91,62.24 118.91,62.47 U53.K3 ; v1(86.34,62.2) 86.34,61.99 86.27,61.91 85.91,61.91 85.81,62.01 85.81,62.67 85.91,62.77 86.89,62.77 86.96,62.7 U51.K3
  BOTTOM w0.241: R738.2 63.19,61.86
M_A_CKE0: length 118.4
  TOP w0.102: U30.K9 107.5,62.39 108.52,62.39 108.59,62.32 108.59,61.78 108.72,61.66 108.92,61.66 109.05,61.78 v1(109.05,62.39) ; v1(77.94,62.67) 77.33,62.06 76.21,62.06 75.74,62.53 U28.K9 ; 122.39,62.47 122.22,62.47 v1(122,62.69) 122,63.2 121.92,63.28 121.6,63.28 121.52,63.2 121.52,62.37 121.45,62.29 121.19,62.29 121.12,62.37 121.12,62.45 121.04,62.53 U31.K9 ; U29.K9 88.56,62.81 88.83,63.08 90.48,63.08 90.64,62.93 90.64,62.6 v1(90.5,62.47)
  TOP w0.241: 122.39,62.47 123.43,62.47 123.78,62.82 R334.2
  IN1 w0.178: v1(77.94,62.67) 78.52,62.67 78.83,62.37 80.72,62.37 81.23,61.86 83.85,61.86 84.39,62.39 85.89,62.39 86.34,62.85 86.88,62.85 87,62.72 87,62.26 87.13,62.14 87.44,62.14 87.56,62.26 87.56,62.59 87.69,62.72 88.02,62.72 88.15,62.59 88.15,62.26 88.27,62.14 89.06,62.14 89.18,62.26 89.18,62.52 89.56,62.89 90.08,62.89 v1(90.5,62.47) 91.26,61.71 98.51,61.71 98.64,61.83 98.64,62.34 98.76,62.47 99.5,62.47 99.63,62.34 99.63,62.09 99.75,61.96 102.6,61.96 103.14,62.49 103.9,62.49 104.08,62.32 105.04,62.32 105.4,61.96 108.62,61.96 v1(109.05,62.39) 109.19,62.53 111.5,62.53 112.07,61.96 114.13,61.96 114.39,61.69 115.07,61.69 115.69,62.32 117.91,62.32 118.32,61.91 118.78,61.91 119.01,61.68 119.52,61.68 119.8,61.96 119.8,62.9 119.92,63.03 121.87,63.03 122,62.9 v1(122,62.69)
  IN3 w0.076: 118.7,101.08 118.82,101.19 118.82,101.2 119.25,101.63 119.25,103.82 118.78,104.29 118.78,106.46 117.69,107.55 117.69,108.68 v1(118.1,109.1)
  IN3 w0.152: 118.7,101.08 118.6,101.08 117.33,99.81 117.33,86.37 116.72,85.76 116.72,84.87 118.33,83.26 118.33,80.25 119.24,79.34 119.24,75.05 123.42,70.87 123.42,64.39 122,62.97 v1(122,62.69)
  BOTTOM w0.102: v1(118.1,109.1) 118.25,109.1 U45.AU43
M_A_CKE1: length 134.7
  IN3 w0.076: 118.98,100.75 118.98,101.13 119.41,101.56 119.41,103.88 118.98,104.32 118.98,106.92 v1(118.1,107.8)
  IN3 w0.14: v1(68.39,61.81) 68.54,61.66 70.21,61.66 70.34,61.53 70.34,61.15 70.47,61.02 72.17,61.02 72.44,61.29 72.95,61.29 73.28,60.96 73.28,60.58 74.41,59.45 75.35,59.45 75.47,59.57 75.47,59.85 75.6,59.98 80.53,59.98 80.65,60.11 80.65,60.74 v1(80.91,60.99) 80.98,61.07 84.16,61.07 84.39,61.3 85.03,61.3 85.1,61.23 85.1,61.23 85.2,61.13 85.59,61.13 85.8,61.34 86.16,61.34 86.2,61.3 89.87,61.3 90,61.17 90,60.65 90.13,60.52 90.43,60.52 90.56,60.65 90.56,60.92 90.69,61.05 90.99,61.05 91.12,60.92 91.12,60.69 91.25,60.56 91.83,60.56 91.96,60.69 91.96,61.06 92.08,61.19 92.31,61.19 92.54,60.96 92.77,60.96 93,61.19 93.28,61.19 93.51,60.96 93.73,60.96 93.96,61.19 94.19,61.19 94.42,60.96 94.65,60.96 94.88,61.19 95.13,61.19 95.36,60.96 95.56,60.96 95.79,61.19 96.05,61.19 96.27,60.96 96.5,60.96 96.73,61.19 97.91,61.19 98,61.1 v1(98,60.82) 98.64,60.18 100.56,60.18 101.07,60.69 102.8,60.69 103.16,61.05 104.33,61.05 104.51,61.23 108.01,61.23 108.14,61.1 108.14,60.77 108.26,60.64 108.96,60.64 109.36,61.05 111.54,61.05 v1(111.95,60.64)
  IN3 w0.152: 118.98,100.75 117.76,99.53 117.76,86.34 117.81,86.3 117.81,84.28 118.69,83.4 118.69,80.39 119.6,79.48 119.6,75.34 123.85,71.08 123.85,63.55 121.52,61.22 117.43,61.22 117.24,61.03 116.4,61.03 115.42,60.05 112.54,60.05 v1(111.95,60.64)
  BOTTOM w0.102: 113.62,62.34 113.81,62.53 U53.K9 ; v1(80.91,60.99) 81.19,60.99 81.64,61.45 81.64,61.63 80.91,62.37 80.91,62.77 81.26,63.13 81.87,63.13 82.16,62.84 U51.K9 ; v1(98,60.82) 98,61.81 98.89,62.7 99.93,62.7 100.1,62.53 U52.K9 ; U45.AW43 118.4,108.1 v1(118.1,107.8) ; U50.K9 69.35,62.53 69.43,62.45 69.43,62.14 69.37,62.08 68.73,62.08 68.61,62.19 68.61,62.75 68.39,62.98 68.03,62.98 67.88,62.82 67.88,62.7 68.28,62.29 68.28,61.91 v1(68.39,61.81) 68.26,61.68 67.17,61.68 67.04,61.55 65.54,61.55 65.06,61.07 R743.2
  BOTTOM w0.241: 113.62,62.34 113.42,62.14 112.86,62.14 112.43,62.57 112.12,62.57 111.95,62.39 v1(111.95,60.64)
M_A_CLK0: length 135.9
  TOP w0.102: U29.J7 86.76,63.13 86.68,63.13 86.62,63.18 86.62,63.99 86.42,64.19 86.19,64.19 v1(85.93,64.45) ; U30.J7 105.76,63.14 105.7,63.08 105.53,63.08 105.42,63.19 105.42,64.12 v1(104.99,64.55) ; v1(72.86,64.37) 72.88,64.37 73.43,63.83 73.43,63.15 73.49,63.08 73.75,63.08 73.83,63.16 73.83,63.25 U28.J7 ; U31.J7 118.97,63.21 118.87,63.11 118.7,63.11 118.63,63.18 118.63,63.94 118.07,64.5 v1(118.07,64.57)
  IN1 w0.203: v1(66.76,63.82) 66.92,63.66 67.14,63.66 67.65,64.17 68.27,64.17 69.17,63.27 70.33,63.27 70.65,63.58 70.65,64.58 71.1,65.03 71.83,65.03 72.61,64.25 72.73,64.25 v1(72.86,64.37) 72.88,64.37 73.21,64.04 73.99,64.04 74.77,63.26 75.63,63.26 76.54,64.17 79.21,64.17 79.71,63.66 81.95,63.66 82.33,63.28 83.56,63.28 84.03,63.75 84.03,64.7 84.41,65.08 85.11,65.08 85.75,64.45 v1(85.93,64.45) 86.06,64.32 86.59,64.32 86.83,64.08 87.76,64.08 88.35,64.68 90.59,64.68 91.47,63.79 93.56,63.79 93.71,63.64 94.88,63.64 95.03,63.79 101,63.79 101.51,63.28 102.33,63.28 102.65,63.6 102.65,64.63 103.08,65.06 104.05,65.06 104.71,64.4 104.83,64.4 v1(104.99,64.55) 105.05,64.55 105.67,63.93 105.67,63.55 105.94,63.28 107.02,63.28 107.35,63.61 113.24,63.61 113.57,63.28 115.05,63.28 115.99,64.22 115.99,64.63 116.43,65.07 117.09,65.07 117.64,64.52 118.02,64.52 v1(118.07,64.57)
  IN3 w0.191: v1(118.07,64.57) 118.68,64.57 119.16,64.09 120.35,64.09 120.63,64.37 120.63,64.7 121.62,65.69 121.62,70.14 120.21,71.56 119.19,71.56 118.79,71.95 118.79,72.97 118.5,73.26 117.48,73.26 117.1,73.64 117.1,78.5 116.19,79.41 116.19,82.88 114.89,84.17 114.89,86.5 115.53,87.13 115.53,89.19 115.4,89.32 115.12,89.32 114.82,89.62 114.82,90.28 115.12,90.59 115.4,90.59 115.53,90.71 115.53,91.12 115.4,91.25 114.69,91.25 114.39,91.55 114.39,92.21 114.69,92.52 115.25,92.52 115.38,92.64 115.38,93.05 115.25,93.18 114.69,93.18 114.39,93.48 114.39,97.37 114.89,97.88 114.89,101.35 117.46,103.92 118.35,103.92 118.83,103.44 v1(118.83,102.73)
  BOTTOM w0.076: v1(118.83,102.73) 118.59,102.97 118.59,103.09 119.46,103.96 121.48,103.96 122.11,104.59 122.11,108.85 122.23,108.98 122.32,108.98 122.4,108.9 U45.AV37
  BOTTOM w0.102: v1(66.76,63.82) 66.55,63.61 65.91,63.61 65.25,62.95 65.09,62.95 64.86,63.18 R731.2
M_A_CLK0#: length 136
  TOP w0.102: v1(85.99,63.81) 86.16,63.99 86.34,63.99 86.42,63.91 86.42,63.1 86.96,62.55 U29.K7 ; U31.K7 119.08,62.64 119.08,62.78 118.95,62.9 118.61,62.9 118.42,63.09 118.42,63.79 118.32,63.9 v1(118.1,63.9) ; v1(104.99,63.92) 105.14,63.92 105.22,63.84 105.22,63.1 105.44,62.87 105.83,62.87 105.9,62.8 105.9,62.67 U30.K7 ; v1(72.86,63.74) 73.14,63.74 73.22,63.65 73.22,63.06 73.41,62.87 73.82,62.87 73.92,62.77 73.92,62.67 73.78,62.53 U28.K7
  IN1 w0.203: v1(118.1,63.9) 117.78,64.21 117.52,64.21 116.96,64.77 116.56,64.77 116.29,64.5 116.29,64.09 115.17,62.98 113.45,62.98 113.12,63.31 107.48,63.31 107.15,62.98 105.81,62.98 105.37,63.42 105.37,63.8 105.25,63.92 v1(104.99,63.92) 104.81,64.09 104.58,64.09 103.92,64.76 103.21,64.76 102.96,64.5 102.96,63.47 102.46,62.97 101.38,62.97 100.87,63.48 95.16,63.48 95,63.33 93.58,63.33 93.43,63.48 91.35,63.48 90.46,64.37 88.48,64.37 87.88,63.78 86.7,63.78 86.46,64.02 86.19,64.02 v1(85.99,63.81) 85.92,63.81 85.43,64.31 85.43,64.33 84.98,64.78 84.54,64.78 84.34,64.58 84.34,63.62 83.69,62.98 82.2,62.98 81.82,63.36 79.59,63.36 79.08,63.86 76.67,63.86 75.75,62.95 74.65,62.95 73.86,63.74 v1(72.86,63.74) 72.65,63.95 72.48,63.95 71.7,64.73 71.23,64.73 70.95,64.45 70.95,63.46 70.46,62.96 69.04,62.96 68.14,63.86 67.78,63.86 67.27,63.36 66.92,63.36 v1(66.76,63.2)
  IN3 w0.191: v1(118.17,102.73) 118.17,102.88 118.3,103.01 118.4,103.01 118.53,103.13 118.53,103.31 118.22,103.62 117.59,103.62 115.2,101.23 115.2,97.75 114.69,97.24 114.69,93.61 114.82,93.48 115.38,93.48 115.68,93.18 115.68,92.52 115.38,92.21 114.82,92.21 114.69,92.08 114.69,91.68 114.82,91.55 115.53,91.55 115.83,91.25 115.83,90.59 115.53,90.28 115.25,90.28 115.12,90.15 115.12,89.75 115.25,89.62 115.53,89.62 115.83,89.32 115.83,87 115.2,86.37 115.2,84.3 116.49,83 116.49,79.54 117.41,78.62 117.41,73.77 117.61,73.57 118.63,73.57 119.1,73.1 119.1,72.08 119.31,71.87 120.33,71.87 121.93,70.27 121.93,65.57 120.94,64.58 120.94,64.25 120.48,63.79 119.03,63.79 118.56,64.27 118.42,64.27 118.29,64.14 118.29,64.04 118.15,63.9 v1(118.1,63.9)
  BOTTOM w0.076: U45.AU37 122.35,109.33 121.94,108.92 121.94,104.66 121.41,104.12 119.39,104.12 118.42,103.16 118.42,102.98 v1(118.17,102.73)
  BOTTOM w0.102: R739.2 64.86,62.53 65.08,62.75 65.34,62.75 66,63.41 66.55,63.41 v1(66.76,63.2)
M_A_CLK1: length 131.9
  IN3 w0.152: v1(66.23,65.47) 66.46,65.24 67.2,65.24 69.15,63.29 70.31,63.29 71.09,64.07 71.31,64.07 v1(71.51,64.27) 71.51,64.27 71.74,64.04 71.92,64.04 72.68,63.28 73.16,63.28 73.64,63.76 74.13,63.76 74.61,63.28 75.25,63.28 75.91,63.94 81.59,63.94 82.48,63.05 83.3,63.05 84.01,63.76 84.38,64.13 84.6,64.13 v1(84.79,64.32) 85,64.12 85.27,64.12 85.55,63.84 85.55,63.63 85.8,63.37 86.83,63.37 87.27,63.81 87.93,64.47 90.26,64.47 90.87,63.86 93.66,63.86 93.87,63.66 94.91,63.66 95.07,63.81 101.17,63.81 101.69,63.3 102.32,63.3 103.14,64.12 103.54,64.12 v1(103.72,64.3) 103.92,64.09 104.19,64.09 104.86,63.43 105.49,63.43 105.67,63.26 106.47,63.26 106.56,63.35 106.56,63.69 106.82,63.94 112.96,63.94 113.75,63.15 115.18,63.15 115.29,63.26 115.29,63.82 115.79,64.32 116.14,64.32 116.37,64.09 116.55,64.09 v1(116.75,64.29)
  IN3 w0.191: v1(118.37,101.63) 118.25,101.76 118.25,102.02 117.92,102.35 117.18,102.35 115.81,100.97 115.81,98.21 116.44,97.57 116.44,97.42 116.32,97.29 115.6,97.29 115.3,96.99 115.3,96.33 115.6,96.02 116.32,96.02 116.44,95.89 116.44,95.49 116.32,95.36 115.6,95.36 115.3,95.06 115.3,94.4 115.6,94.09 116.32,94.09 116.44,93.96 116.44,86.75 115.81,86.11 115.81,84.53 117.45,82.89 117.45,79.88 118.36,78.97 118.36,74.68 122.54,70.5 122.54,64.78 120.94,63.18 118.09,63.18 117.65,63.62 117.65,63.93 117.29,64.29 v1(116.75,64.29)
  BOTTOM w0.076: U45.AY36 123.23,107.62 123.15,107.69 123.06,107.69 122.93,107.57 122.93,104.27 120.72,102.05 118.19,102.05 118.11,101.97 118.11,101.9 v1(118.37,101.63)
  BOTTOM w0.102: U52.J7 102.83,63.05 102.95,63.05 103.03,63.14 103.03,63.66 103.67,64.3 v1(103.72,64.3) ; U53.J7 115.69,63.25 115.69,63.14 115.77,63.06 116.01,63.06 116.11,63.16 116.11,63.65 v1(116.75,64.29) ; v1(71.51,64.27) 71.29,64.05 71.13,64.05 70.9,63.82 70.9,63.16 70.77,63.03 70.67,63.03 70.56,63.14 U50.J7 ; v1(66.23,65.47) 65.94,65.19 65.32,65.19 R719.2 ; U51.J7 83.76,63.12 83.82,63.06 84.01,63.06 84.11,63.16 84.11,63.69 84.34,63.92 84.39,63.92 v1(84.79,64.32)
M_A_CLK1#: length 132
  IN3 w0.152: v1(116.75,63.65) 116.54,63.86 116.28,63.86 116.04,64.09 115.88,64.09 115.52,63.73 115.52,63.17 115.27,62.93 113.66,62.93 112.87,63.71 106.91,63.71 106.79,63.59 106.79,63.26 106.56,63.03 105.57,63.03 105.4,63.2 104.76,63.2 104.1,63.86 103.92,63.86 v1(103.73,63.67) 103.51,63.89 103.23,63.89 102.42,63.08 101.59,63.08 101.08,63.59 95.16,63.59 95.01,63.43 93.77,63.43 93.57,63.64 90.77,63.64 90.16,64.25 88.03,64.25 86.93,63.14 85.71,63.14 85.32,63.53 85.32,63.74 85.18,63.89 85,63.89 v1(84.82,63.71) 84.63,63.9 84.48,63.9 83.4,62.82 82.38,62.82 81.49,63.71 76.01,63.71 75.35,63.05 74.51,63.05 74.03,63.53 73.74,63.53 73.26,63.05 72.58,63.05 71.82,63.81 71.66,63.81 v1(71.51,63.66) 71.33,63.84 71.18,63.84 70.41,63.06 69.05,63.06 67.1,65.01 66.49,65.01 v1(66.23,64.75)
  IN3 w0.191: v1(116.75,63.65) 117.05,63.96 117.19,63.96 117.34,63.8 117.34,63.5 117.96,62.88 121.07,62.88 122.84,64.65 122.84,70.63 118.66,74.81 118.66,79.1 117.75,80.01 117.75,83.02 116.11,84.66 116.11,85.99 116.75,86.62 116.75,94.09 116.44,94.4 115.73,94.4 115.6,94.52 115.6,94.93 115.73,95.06 116.44,95.06 116.75,95.36 116.75,96.02 116.44,96.33 115.73,96.33 115.6,96.45 115.6,96.86 115.73,96.99 116.44,96.99 116.75,97.29 116.75,97.7 116.11,98.33 116.11,100.85 117.31,102.04 117.79,102.04 117.92,101.91 117.92,101.69 117.79,101.56 v1(117.61,101.56)
  BOTTOM w0.076: v1(117.61,101.56) 117.94,101.89 117.94,102.04 118.12,102.22 120.65,102.22 122.77,104.34 122.77,107.64 U45.AW36
  BOTTOM w0.102: U51.K7 83.7,62.59 83.7,62.78 83.78,62.86 84.09,62.86 84.31,63.08 84.31,63.6 84.42,63.71 v1(84.82,63.71) ; U52.K7 102.56,62.64 102.78,62.85 103.03,62.85 103.23,63.05 103.23,63.58 103.42,63.76 103.64,63.76 v1(103.73,63.67) ; v1(116.75,63.65) 116.4,63.65 116.32,63.57 116.32,63.08 116.1,62.86 115.72,62.86 115.63,62.77 115.63,62.62 115.72,62.53 U53.K7 ; U50.K7 70.56,62.76 70.62,62.82 70.85,62.82 71.1,63.08 71.1,63.74 71.22,63.85 71.32,63.85 v1(71.51,63.66) ; R725.2 65.35,64.98 65.99,64.98 v1(66.23,64.75)
M_A_CS#0: length 145.7
  TOP w0.102: U28.L2 69.38,61.35 68,61.35 67.67,61.68 67.14,61.68 v1(66.86,61.96) 66.46,61.55 65.41,61.55 ; v1(99.2,61.32) 99.81,61.93 100.11,61.93 100.29,61.76 100.29,61.63 100.59,61.33 101.36,61.33 U30.L2 ; U29.L2 82.61,61.38 81.31,61.38 81.03,61.66 80.27,61.66 v1(80.02,61.4) ; v1(112.61,61.45) 112.61,61.58 113.06,62.04 113.42,62.04 113.7,61.75 113.7,61.45 113.82,61.33 114.57,61.33 U31.L2
  TOP w0.241: R345.2 63.37,61.73 65.23,61.73 65.41,61.55
  IN1 w0.178: v1(112.61,61.45) 112.48,61.58 111.59,61.58 111.46,61.71 111.46,62.02 111.34,62.15 111.11,62.15 110.98,62.02 110.98,61.71 110.85,61.58 110.63,61.58 110.5,61.71 110.5,61.95 110.32,62.13 109.42,62.13 108.87,61.58 105.24,61.58 104.88,61.94 103.84,61.94 103.45,61.54 99.91,61.54 99.69,61.32 v1(99.2,61.32) 92.41,61.32 91.62,60.53 90.6,60.53 89.68,61.45 86.95,61.45 86.66,61.74 86.15,61.74 85.9,62 84.55,62 84.01,61.45 80.07,61.45 v1(80.02,61.4) 79.54,61.88 78.9,61.88 78.77,61.76 78.77,61.22 78.65,61.1 78.32,61.1 78.19,61.22 78.19,61.76 78.06,61.88 76.3,61.88 76.01,62.18 73.43,62.18 73.06,61.81 71.66,61.81 71.54,61.92 68.9,61.92 68.27,62.55 67.45,62.55 v1(66.86,61.96)
  IN1 w0.203: v1(135.06,64.5) 134.32,64.5 133.71,63.89 125.33,63.89 123.93,62.48 122.66,62.48 122.28,62.11 120.51,62.11 119.68,61.29 118.84,61.29 118.62,61.51 118.16,61.51 117.75,61.93 115.86,61.93 115.23,61.3 112.76,61.3 v1(112.61,61.45)
  IN3 w0.076: v1(124.66,110.95) 125.1,110.5 125.1,109.84 125.48,109.46 125.48,100.54 126.48,99.55 126.48,99.04
  IN3 w0.152: v1(135.06,64.5) 135.06,64.5 135.8,65.24 135.8,71.94 136.23,72.38 136.23,75.32 134.27,77.28 134.27,78.66 133.86,79.07 133.86,82.72 131.61,84.97 131.61,86.36 126.73,91.24 126.73,97.37 126.48,97.62 126.48,99.04
  BOTTOM w0.102: U45.AP33 124.92,111.21 v1(124.66,110.95)
M_A_CS#1: length 143
  TOP w0.102: v1(67.85,62.11) 67.54,62.42 66.18,62.42 66.1,62.34 R340.2
  IN1 w0.203: v1(121.22,61.66) 122.44,61.66 122.86,62.08 124.1,62.08 124.92,62.9 126.12,62.9 126.7,63.48 133.99,63.48 134.22,63.71 v1(134.93,63.71)
  IN3 w0.076: 126.77,99.04 126.77,99.56 125.69,100.64 125.69,110.15 v1(125.61,110.23)
  IN3 w0.14: v1(67.85,62.11) 67.98,62.23 68.57,62.23 68.79,62.01 71.43,62.01 71.8,61.63 74.64,61.63 v1(74.96,61.31) 76.13,61.31 76.57,60.87 80.15,60.87 80.73,61.45 84.03,61.45 84.24,61.66 84.88,61.66 85.2,61.98 85.55,61.98 85.76,61.77 86.71,61.77 86.83,61.66 90.56,61.66 v1(90.64,61.58) 93.71,61.58 93.76,61.53 98.64,61.53 98.76,61.4 98.76,61.02 98.89,60.89 99.48,60.89 99.63,61.05 99.63,61.66 99.75,61.78 100.06,61.78 100.19,61.66 100.19,61.3 100.31,61.17 100.52,61.17 100.9,61.55 103.51,61.55 103.87,61.92 104.23,61.92 104.57,61.57 108.17,61.57 v1(108.67,61.07) 109.17,61.57 109.4,61.57 110.21,62.38 112.49,62.38 113.51,61.36 116.03,61.36 116.58,61.92 118.89,61.92 119.16,61.66 120.48,61.66 120.61,61.78 120.61,62.37 120.74,62.49 121.09,62.49 121.22,62.37 v1(121.22,61.66)
  IN3 w0.152: v1(134.93,63.71) 136.23,65.01 136.23,71.74 137.63,73.14 137.63,75.8 134.22,79.21 134.22,82.99 131.96,85.25 131.96,86.51 127.09,91.39 127.09,97.52 126.77,97.84 126.77,99.04
  BOTTOM w0.102: v1(74.96,61.31) 74.27,61.31 74.16,61.42 74.16,61.8 74.05,61.91 74.05,62.06 74.17,62.18 74.77,62.18 74.91,62.04 74.91,61.86 74.79,61.73 U50.L2 ; U52.L2 106.56,61.43 106.66,61.32 107.88,61.32 108.04,61.17 108.04,60.94 108.26,60.72 108.52,60.72 108.67,60.87 v1(108.67,61.07) ; v1(125.61,110.23) 125.93,110.56 U45.AR32 ; U53.L2 119.77,61.35 119.84,61.27 120.1,61.27 120.18,61.35 120.18,62.04 120.28,62.14 121.17,62.14 121.27,62.04 121.27,61.71 v1(121.22,61.66) ; v1(90.64,61.58) 89.04,61.58 88.84,61.38 88.11,61.38 U51.L2
M_A_DQ0: length 72.2
  TOP w0.102: U30.G2 101.76,64.9 v1(101.35,64.5)
  IN3 w0.102: v1(101.35,64.5) 100.16,64.5 99.91,64.75
  IN3 w0.14: 99.91,64.75 98,64.75 92.47,70.29 92.47,72.81 89.44,75.84 89.44,84.56 91.22,86.34 91.22,91.5 92.1,92.38 92.6,92.38 93.05,92.82 93.05,111.11 98.13,116.19 102.21,116.19 v1(103.02,115.37)
  BOTTOM w0.076: U45.AH63 105.73,114.8 105.61,114.68 103.72,114.68 v1(103.02,115.37)
  BOTTOM w0.102: v1(101.35,64.5) 101.72,64.13 U52.H8
M_A_DQ1: length 72.9
  TOP w0.102: U30.H3 102.17,64.52 v1(102.17,64.53)
  IN3 w0.102: 98.51,65.52 100.54,65.52 101.15,64.9 101.79,64.9 v1(102.17,64.53)
  IN3 w0.14: v1(103.72,115.32) 103.33,114.94 101.8,114.94 100.9,115.83 98.27,115.83 93.4,110.96 93.4,92.41 92.86,91.87 92.35,91.87 91.58,91.09 91.58,86.19 89.8,84.41 89.8,75.98 92.82,72.96 92.82,70.44 97.11,66.15 97.88,66.15 98.51,65.52
  BOTTOM w0.076: v1(103.72,115.32) 104.2,114.84 105.55,114.84 105.79,115.09 106.27,115.09 106.44,115 106.64,114.8 U45.AH62
  BOTTOM w0.102: U30.H3 102.17,64.52 v1(102.17,64.53)
M_A_DQ2: length 71.3
  TOP w0.102: v1(105.36,66.13) U30.F7
  IN3 w0.102: v1(105.36,66.13) 105.36,66.33 103.74,67.95 100.99,67.95 100.72,68.23 100.72,68.6 99.74,69.58
  IN3 w0.14: v1(102.89,113.8) 101.68,112.59 99.05,112.59 97.08,110.62 97.08,107.15 96.22,106.29 96.22,86.57 96.12,86.47 96.09,86.45 94.73,86.45 94.6,86.32 94.6,86.12 94.73,85.99 96.07,85.99 96.19,85.86 96.19,85.66 96.07,85.53 94.73,85.53 94.6,85.4 94.6,85.2 94.73,85.07 95.13,85.07 95.26,84.95 95.26,84.74 95.13,84.62 94.52,84.62 94.4,84.49 94.4,83.86 93.65,83.12 92.85,83.12 92.65,82.92 92.65,78.43 95.27,75.8 95.99,75.8 96.76,75.03 96.76,73.3 97.87,72.2 97.87,70.9 99.19,69.58 99.74,69.58
  BOTTOM w0.076: U45.AK63 106.07,113.32 105.79,113.32 105.55,113.07 103.61,113.07 v1(102.89,113.8)
  BOTTOM w0.102: v1(105.36,66.13) 105.76,66.52 U52.E3
M_A_DQ3: length 72
  TOP w0.102: v1(106.96,64.53) U30.H8
  IN3 w0.102: 99.12,68.94 100.05,68 100.66,68 100.91,67.75 103.66,67.75 104.95,66.46 104.95,65.68 105.7,64.93 106.56,64.93 v1(106.96,64.53)
  IN3 w0.14: v1(102.25,113.8) 101.4,112.95 98.91,112.95 96.73,110.77 96.73,108.57 95.86,107.7 95.86,87.84 95.74,87.72 95.11,87.72 94.98,87.59 94.98,87.39 95.11,87.26 95.74,87.26 95.86,87.13 95.86,86.93 95.76,86.83 95.74,86.8 94.37,86.8 94.24,86.67 94.24,85.34 92.29,83.4 92.29,77.14 95.22,74.21 95.22,73.51 97.51,71.22 97.51,70.75 99.12,69.15 99.12,68.94
  BOTTOM w0.076: v1(102.25,113.8) 103.14,112.91 105.61,112.91 105.86,113.15 106.32,113.15 106.61,113.45 U45.AK62
  BOTTOM w0.102: v1(106.96,64.53) U52.G2
M_A_DQ4: length 73.1
  TOP w0.102: U30.E3 v1(102.96,66.13)
  IN3 w0.102: v1(102.96,66.13) 102.55,65.73 101.54,65.73 101.53,65.72 98.89,65.72 98.71,65.9
  IN3 w0.14: v1(104.37,115.32) 103.63,114.58 101.58,114.58 100.69,115.47 98.42,115.47 94.68,111.74 94.68,109.7 93.76,108.77 93.76,91.88 93.18,91.3 92.67,91.3 91.93,90.56 91.93,86.04 90.18,84.29 90.18,76.14 93.18,73.14 93.18,71.86 93.86,71.19 93.86,69.91 97.26,66.51 98.1,66.51 98.71,65.9
  BOTTOM w0.076: v1(104.37,115.32) 104.68,115.01 105.48,115.01 105.72,115.25 106.31,115.25 106.35,115.23 106.45,115.18 107.11,115.18 U45.AH61
  BOTTOM w0.102: v1(102.96,66.13) 102.56,65.74 U52.F7
M_A_DQ5: length 74.2
  TOP w0.102: v1(101.36,66.13) U30.F2
  IN3 w0.14: v1(101.36,66.13) 100.94,66.55 100.36,66.55 100.34,66.53 98.66,66.53 95.72,69.48 95.72,70.56 93.53,72.74 93.53,73.36 90.59,76.31 90.59,84.19 92.29,85.89 92.29,88.38 92.91,89 92.91,89.11 92.78,89.24 92.41,89.24 92.29,89.37 92.29,89.57 92.41,89.7 93.61,89.7 93.76,89.85 93.76,90.03 93.63,90.15 92.8,90.15 92.67,90.28 92.67,90.48 92.8,90.61 93.99,90.61 94.12,90.74 94.12,108.59 95.04,109.52 95.04,111.59 98.57,115.12 100.54,115.12 101.44,114.22 104.34,114.22 v1(104.72,113.84)
  BOTTOM w0.076: U45.AH60 108.15,114.03 107.94,113.83 107.7,113.83 107.69,113.84 107.31,113.84 107.29,113.83 107.1,113.83 107.09,113.84 106.95,113.9 106.74,113.9 106.59,113.83 106.46,113.83 106.35,113.88 106.3,113.9 106.01,113.9 105.75,113.65 105.65,113.65 105.41,113.4 105.16,113.4 v1(104.72,113.84)
  BOTTOM w0.102: U30.F2 v1(101.36,66.13)
M_A_DQ6: length 72.4
  TOP w0.102: v1(106.18,66.11) U30.F8
  IN3 w0.102: 99.59,70.98 99.64,70.93 100.15,70.93 100.57,70.51 100.57,69.07 100.92,68.72 100.92,68.31 101.08,68.16 103.83,68.16 105.2,66.79 105.5,66.79 v1(106.18,66.11)
  IN3 w0.14: 99.59,70.98 97.12,73.45 97.12,75.18 96.11,76.18 95.4,76.18 95.09,76.49 95.09,77.17 94.9,77.35 94.23,77.35 93.01,78.57 93.01,81.77 93.13,81.9 93.33,81.9 93.46,82.03 93.46,82.41 93.58,82.53 93.79,82.53 93.91,82.41 93.91,82.1 94.04,81.98 94.24,81.98 94.37,82.1 94.37,83.32 94.5,83.45 94.7,83.45 94.83,83.32 94.83,82.03 94.95,81.9 95.16,81.9 95.28,82.03 95.28,84.25 96.57,85.54 96.57,106.14 97.44,107 97.44,110.47 99.2,112.23 103.03,112.23 104.15,113.36 v1(104.15,113.59)
  BOTTOM w0.076: v1(104.15,113.59) 104.5,113.24 105.48,113.24 105.72,113.48 105.82,113.48 106.07,113.74 106.26,113.74 106.37,113.69 106.42,113.66 106.62,113.66 106.68,113.69 106.77,113.73 106.78,113.74 106.91,113.74 106.96,113.71 107.02,113.69 107.15,113.55 U45.AK61
  BOTTOM w0.102: U30.F8 v1(106.18,66.11)
M_A_DQ7: length 73.1
  TOP w0.102: U30.H7 v1(106.14,64.51)
  IN3 w0.102: 98.76,68.94 99.91,67.8 100.57,67.8 100.82,67.55 103.57,67.55 104.75,66.37 104.75,65.6 105.84,64.51 v1(106.14,64.51)
  IN3 w0.14: 98.76,68.94 98.76,69 97.16,70.6 97.16,71.08 94.87,73.36 94.87,74.06 91.94,76.99 91.94,83.54 93.89,85.49 93.89,87.13 94.02,87.26 94.5,87.26 94.62,87.39 94.62,87.59 94.5,87.72 94.02,87.72 93.89,87.84 93.89,88.05 94.02,88.17 95.38,88.17 95.51,88.3 95.51,107.85 96.37,108.72 96.37,110.91 98.76,113.3 101.12,113.3 v1(101.61,113.8)
  BOTTOM w0.076: v1(101.61,113.8) 102.4,113.01 102.8,113.01 103.08,112.74 105.68,112.74 105.93,112.99 106.39,112.99 106.55,113.15 106.97,113.15 107.09,113.28 107.36,113.28 107.38,113.26 107.62,113.26 107.91,113.55 U45.AK60
  BOTTOM w0.102: U30.H7 v1(106.14,64.51)
M_A_DQ8: length 77.7
  TOP w0.102: v1(69.34,64.51) U28.G2
  IN1 w0.102: 65.64,65.87 65.79,65.87 65.81,65.9 66.76,65.9 68.03,64.63 69.23,64.63 v1(69.34,64.51)
  IN1 w0.178: v1(102.08,111.26) 100.78,112.56 98.9,112.56 97.02,110.68 97.02,109.66 92.22,104.86 91.67,104.86 87.64,100.82 87.33,100.82 83.95,97.44 83.44,97.44 81.18,95.18 80.58,95.18 79.21,93.81 79.21,91.51 72.35,84.65 70.1,84.65 69.54,84.09 69.54,83.12 68.49,82.06 68.49,80.34 67.31,79.15 67.31,77.42 66.47,76.58 66.47,75.93 65.77,75.23 65.77,74.65 64.84,73.72 64.84,72.21 64.89,72.16 64.89,66.62 65.64,65.87
  BOTTOM w0.076: U45.AM63 106.07,112.24 105.92,112.24 105.92,112.24 102.46,112.24 v3(102.37,112.15) 102.08,111.86 v1(102.08,111.26)
  BOTTOM w0.102: U50.H8 69.73,64.13 v1(69.34,64.51)
M_A_DQ9: length 78.7
  TOP w0.102: U28.H3 70.17,64.52 v1(70.17,64.53)
  IN1 w0.102: 65.24,67.17 65.65,66.75 66.92,66.75 68.18,65.49 68.56,65.49 69.13,64.92 69.77,64.92 v1(70.17,64.53)
  IN1 w0.178: 65.24,67.17 65.24,73.56 66.16,74.49 66.16,75.07 66.86,75.77 66.86,76.42 67.7,77.25 67.7,78.99 68.88,80.17 68.88,80.76 69.01,80.88 69.12,80.88 69.25,81.01 69.25,81.21 69.12,81.34 69.01,81.34 68.88,81.47 68.88,81.9 69.94,82.95 69.94,83.75 70.44,84.26 72.51,84.26 79.75,91.5 79.75,93.65 80.88,94.78 81.33,94.78 83.61,97.05 84.12,97.05 86.38,99.31 87.2,99.31 87.71,99.82 87.72,99.82 87.92,100.02 87.92,100.55 91.83,104.46 92.38,104.46 97.42,109.5 97.42,110.52 99.06,112.16 100.55,112.16 101.46,111.26 v1(101.46,111.24)
  BOTTOM w0.076: v1(101.46,111.24) 101.46,111.95 102.13,112.62 102.57,112.62 102.78,112.4 105.82,112.4 106.08,112.66 106.32,112.66 106.61,112.37 U45.AM62
  BOTTOM w0.102: v1(70.17,64.53) 70.17,64.52 U28.H3
M_A_DQ10: length 76.4
  TOP w0.102: v1(74.16,64.53) U28.H8
  IN1 w0.102: v1(74.16,64.53) 72.95,65.73 72.95,66.44 71.64,67.75 69.02,67.75 68.51,68.26 68.51,70.72 68.84,71.05 68.84,71.16
  IN1 w0.178: v1(101.55,109.61) 101.55,109.57 100.69,108.71 100.39,108.71 100.26,108.58 100.26,108.39 100.39,108.26 100.52,108.26 100.59,108.19 100.59,108.05 94.33,101.8 94.33,101.09 90.28,97.04 89.42,97.04 88.66,96.28 87.14,96.28 82.85,91.99 82.85,90.53 75.33,83.01 75.33,82.01 74.2,80.88 73.98,80.88 73.83,81.04 73.65,81.04 73.45,80.84 73.45,80.66 73.61,80.5 73.61,80.32 73.42,80.12 73.24,80.12 73.06,80.3 72.88,80.3 72.68,80.1 72.68,79.92 72.87,79.73 72.87,79.55 72.67,79.35 72.49,79.35 72.31,79.54 72.13,79.54 71.93,79.35 71.93,79.17 72.1,79 72.1,78.78 71.94,78.62 71.72,78.62 71.58,78.76 71.4,78.76 71.2,78.57 71.2,78.39 71.36,78.22 71.36,78.04 71.17,77.85 70.99,77.85 70.9,77.94 70.52,77.94 70.39,77.81 70.39,76.74 70.52,76.62 70.72,76.62 70.85,76.49 70.85,76.23 70.72,76.11 70.52,76.11 69.66,75.25 69.66,75.07 69.85,74.88 70.03,74.88 70.28,75.13 70.46,75.13 70.66,74.92 70.66,74.74 68.84,72.92 68.84,71.16
  BOTTOM w0.076: U45.AP63 105.8,111.01 105.28,110.49 102.43,110.49 v1(101.55,109.61)
  BOTTOM w0.102: v1(74.16,64.53) 74.56,64.92 U50.G2
M_A_DQ11: length 77.3
  TOP w0.102: v1(73.36,66.13) U28.F7
  IN1 w0.102: 69.24,71.13 69.24,70.98 68.72,70.46 68.72,68.34 69.11,67.95 71.74,67.95 73.36,66.33 v1(73.36,66.13)
  IN1 w0.178: 69.24,71.13 69.24,72.7 71.64,75.11 71.64,75.29 71.48,75.45 71.3,75.45 71.14,75.29 70.96,75.29 70.8,75.45 70.8,75.62 74.09,78.91 74.09,79.09 73.94,79.24 73.76,79.24 71.38,76.87 71.2,76.87 71.07,77.01 71.07,77.19 76.27,82.39 76.27,83.39 83.24,90.36 83.24,91.83 87.3,95.89 88.83,95.89 89.58,96.64 90.44,96.64 94.75,100.95 94.75,101.66 100.99,107.89 100.99,108.43 101.53,108.98 101.66,108.98 101.79,109.1 101.79,109.2 v1(102.2,109.61)
  BOTTOM w0.076: U45.AP62 106.61,111.01 106.32,110.72 105.74,110.72 105.34,110.32 102.91,110.32 v1(102.2,109.61)
  BOTTOM w0.102: U50.E3 73.76,66.52 v1(73.36,66.13)
M_A_DQ12: length 78.8
  TOP w0.102: v1(70.95,66.11) 70.95,66.13 U28.E3
  IN1 w0.102: 66.56,70.6 66.3,70.34 66.3,67.69 68.3,65.69 68.78,65.69 68.84,65.75 69.95,65.75 69.97,65.73 70.58,65.73 v1(70.95,66.11)
  IN1 w0.178: 66.56,70.6 66.58,70.62 66.58,72.3 66.56,72.32 66.56,74.62 67.27,75.33 67.27,76.26 68.09,77.09 68.09,78.83 71,81.73 71,81.95 70.84,82.11 70.62,82.11 70.21,81.7 70.03,81.7 69.83,81.9 69.83,82.08 71.15,83.39 72.2,83.39 80.19,91.39 80.19,93.38 81.15,94.33 81.45,94.33 83.77,96.66 84.28,96.66 86.54,98.92 88.07,98.92 88.35,99.2 88.35,100.42 92,104.07 92.55,104.07 97.81,109.33 97.81,110.36 99.21,111.76 99.73,111.76 v1(100.23,111.26)
  BOTTOM w0.076: v1(100.23,111.26) 100.23,111.89 v3(100.54,112.2) 101.15,112.81 102.75,112.81 103,112.57 105.75,112.57 106.01,112.82 106.39,112.82 106.55,112.66 106.97,112.66 107.37,112.26 U45.AM61
  BOTTOM w0.102: U50.F7 70.57,65.73 v1(70.95,66.11)
M_A_DQ13: length 79.7
  TOP w0.102: v1(69.35,66.16) 69.76,65.76 U28.F2
  IN1 w0.102: 66.95,70.61 66.5,70.16 66.5,67.78 67.78,66.51 69.01,66.51 v1(69.35,66.16)
  IN1 w0.178: 66.95,70.61 66.95,73.7 67.66,74.42 67.66,76.1 68.49,76.93 68.49,78.6 71.85,81.96 71.85,82.14 71.65,82.34 71.47,82.34 71.41,82.28 71.23,82.28 71.03,82.48 71.03,82.66 71.32,82.94 72.31,82.94 74.04,84.68 74.31,84.68 80.66,91.03 80.66,92.99 83.93,96.26 84.44,96.26 86.7,98.52 88.23,98.52 88.74,99.04 88.74,100.26 92.16,103.68 93.49,103.68 93.66,103.84 93.66,103.97 93.43,104.2 93.43,104.38 93.64,104.59 93.82,104.59 94.04,104.38 94.22,104.38 94.42,104.58 94.42,104.76 94.24,104.94 94.24,105.16 94.4,105.32 94.62,105.32 94.79,105.15 95.01,105.15 95.17,105.3 95.17,105.52 94.99,105.7 94.99,105.92 95.15,106.07 95.37,106.07 95.54,105.9 95.76,105.9 95.92,106.06 95.92,106.28 95.75,106.45 95.75,106.67 95.9,106.83 96.13,106.83 96.3,106.66 96.52,106.66 97.23,107.37 97.23,107.59 97.03,107.78 97.03,108 97.19,108.16 97.41,108.16 97.64,107.93 97.8,107.93 98.01,108.15 98.01,108.33 97.79,108.56 97.79,108.75 98.2,109.17 98.2,110.19 99.27,111.26 v1(99.6,111.26)
  BOTTOM w0.076: v1(99.6,111.26) 100.04,110.82 105.14,110.82 105.79,111.47 106.3,111.47 106.46,111.4 106.59,111.4 106.74,111.47 106.95,111.47 107,111.45 107.09,111.41 107.1,111.4 107.94,111.4 108.15,111.6 U45.AM60
  BOTTOM w0.102: U28.F2 69.76,65.76 v1(69.35,66.16)
M_A_DQ14: length 78.2
  TOP w0.102: U28.H7 73.76,64.34 v1(73.21,64.88)
  IN1 w0.102: v1(73.21,64.88) 73.21,65.13 72.75,65.6 72.75,66.33 71.54,67.55 68.94,67.55 68.58,67.9 68,67.9 67.34,68.56 67.34,69.91 68.45,71.01 68.45,71.26
  IN1 w0.178: v1(100.88,109.61) 100.43,109.15 99.98,109.15 99.86,109.03 99.86,107.87 93.94,101.96 93.94,101.26 93.48,100.8 92.92,100.8 92.8,100.67 92.8,100.14 92.67,100.01 92.44,100.01 92.31,100.14 92.31,100.67 92.19,100.8 91.96,100.8 91.83,100.67 91.83,99.15 91.7,99.02 91.45,99.02 91.32,99.15 91.32,99.6 91.19,99.73 90.97,99.73 90.84,99.6 90.84,98.15 90.12,97.43 89.26,97.43 88.5,96.67 86.97,96.67 82.46,92.16 82.46,90.69 74.66,82.89 74.66,82 74.25,81.59 73.6,81.59 70,77.99 70,76.32 69.18,75.5 69.18,73.81 68.45,73.08 68.45,71.26
  BOTTOM w0.076: 100.96,109.68 101.93,110.65 105.21,110.65 105.86,111.31 106.26,111.31 106.37,111.26 106.42,111.23 106.62,111.23 106.68,111.26 106.77,111.3 106.78,111.31 106.91,111.31 107.02,111.26 107.26,111.01 U45.AP61
  BOTTOM w0.102: v1(73.21,64.88) 73.76,64.34 U28.H7
  BOTTOM w0.216: v1(100.88,109.61) 100.96,109.68
M_A_DQ15: length 78.3
  TOP w0.102: v1(74.18,66.11) U28.F8
  IN1 w0.102: v1(74.18,66.11) 73.35,66.94 73.06,66.94 71.84,68.16 69.19,68.16 68.92,68.43 68.92,70.32 69.63,71.03 69.63,71.15
  IN1 w0.178: 69.63,71.15 69.63,72.54 74.51,77.42 74.51,77.6 74.36,77.76 74.18,77.76 72.04,75.63 71.86,75.63 71.7,75.79 71.7,75.97 74,78.27 74.35,78.27 74.53,78.44 74.53,80.09 76.68,82.24 76.68,83.24 83.64,90.2 83.64,90.26 83.76,90.38 83.8,90.38 83.93,90.51 83.93,90.69 83.8,90.81 83.76,90.81 83.64,90.94 83.64,91.67 87.46,95.49 88.99,95.49 89.75,96.25 90.61,96.25 95.18,100.83 95.18,101.53 101.38,107.73 101.38,108.23 101.44,108.3 101.72,108.57 102.04,108.57 102.17,108.7 102.17,109 102.29,109.13 102.5,109.13 102.62,109 102.62,108.7 102.75,108.57 102.9,108.57 103.13,108.8 103.13,109.1 103.26,109.23 103.36,109.23 103.48,109.36 v1(103.48,109.61)
  BOTTOM w0.076: U45.AP60 108.11,110.98 107.88,110.98 107.62,110.72 107.38,110.72 107.37,110.73 106.98,110.73 106.97,110.72 106.55,110.72 106.39,110.56 105.81,110.56 105.41,110.16 104.03,110.16 v1(103.48,109.61)
  BOTTOM w0.102: U28.F8 v1(74.18,66.11)
M_A_DQ16: length 59.8
  TOP w0.102: U30.D7 106.16,67.72 v1(106.16,67.73)
  IN3 w0.14: v1(108.97,110.88) 108.84,111.01 107.77,111.01 105.11,108.35 103.89,108.35 101.59,106.05 100.72,106.05 99.6,104.93 99.6,98.92 100.11,98.41 100.11,89.19 100.24,89.06 101.52,89.06 101.64,88.93 101.64,83.45 101.52,83.32 100.52,83.32 100.39,83.19 100.39,82.79 100.62,82.56 100.62,82.15 99.94,81.47 99.94,79.64 100.06,79.51 100.49,79.51 100.62,79.38 100.62,78.5 100.85,78.27 101.51,78.27 101.63,78.14 101.63,77.3 101.51,77.17 100.49,77.17 100.36,77.05 100.36,76.84 100.49,76.72 102.26,76.72 102.39,76.59 102.39,72.99 104.52,70.85 104.57,70.85 105.03,70.39 105.03,69.74 105.44,69.33 105.44,68.44 v1(106.16,67.73)
  BOTTOM w0.102: U45.AP58 109.29,111.21 v1(108.97,110.88) ; v1(106.16,67.73) U52.C3
M_A_DQ17: length 59.4
  TOP w0.102: v1(106.16,68.54) 106.16,68.53 U30.C8
  IN3 w0.14: v1(106.16,68.54) 105.71,68.98 105.71,69.45 105.39,69.78 105.39,70.49 102.74,73.13 102.74,78.77 102.34,79.18 101.3,79.18 101.23,79.26 101.23,82.51 102,83.28 102,89.29 101.87,89.42 100.59,89.42 100.47,89.54 100.47,89.75 100.59,89.87 101.87,89.87 102,90 102,90.2 101.87,90.33 100.59,90.33 100.47,90.46 100.47,90.66 100.59,90.79 101.87,90.79 102,90.92 102,91.12 101.87,91.25 100.59,91.25 100.47,91.37 100.47,98.56 99.96,99.06 99.96,104.78 100.87,105.69 101.74,105.69 104.04,107.99 105.25,107.99 106.61,109.34 108.18,109.34 108.97,110.14 v1(108.97,110.23)
  BOTTOM w0.102: v1(106.16,68.54) 106.16,68.53 U30.C8 ; U45.AR58 109.29,110.56 v1(108.97,110.23)
M_A_DQ18: length 62.7
  TOP w0.102: v1(101.36,68.56) 101.36,68.53 U30.C2
  IN3 w0.14: v1(101.36,68.56) 101.36,68.7 100.85,69.21 100.85,70.67 97.66,73.86 97.66,75.41 96.5,76.57 96.5,84.69 97.2,85.39 97.2,106 97.99,106.78 97.99,110.25 99.43,111.69 103.97,111.69 106.87,114.59 110.12,114.59 110.42,114.28 110.42,112.69 v1(109.92,112.18)
  BOTTOM w0.102: U30.C2 101.76,68.17 v1(101.36,68.56) ; v1(109.92,112.18) 110.24,112.51 U45.AM57
M_A_DQ19: length 64.7
  TOP w0.102: U30.C3 102.56,67.88 102.48,67.8 102.24,67.8 102.16,67.88 v1(102.16,68.57)
  IN3 w0.102: v1(102.16,68.57) 101.74,69 101.74,69.54
  IN3 w0.14: v1(109.92,113.48) 109.27,114.13 106.91,114.13 106.06,113.28 106.06,112.36 104.51,110.81 99.05,110.81 98.34,110.1 98.34,106.63 97.56,105.85 97.56,98.06 98.03,97.59 98.03,97.44 97.91,97.32 97.69,97.32 97.56,97.19 97.56,96.99 97.69,96.86 97.91,96.86 98.03,96.73 98.03,96.53 97.91,96.4 97.69,96.4 97.56,96.28 97.56,96.07 97.69,95.95 97.91,95.95 98.03,95.82 98.03,95.61 97.91,95.49 97.69,95.49 97.56,95.36 97.56,95.16 97.69,95.03 97.91,95.03 98.03,94.9 98.03,94.7 97.91,94.57 97.69,94.57 97.56,94.45 97.56,94.24 97.69,94.12 97.91,94.12 98.03,93.99 98.03,85.72 96.85,84.54 96.85,76.72 98.02,75.56 98.02,74.34 101,71.35 101,70.98 101.09,70.89 101.09,70.19 101.74,69.54
  BOTTOM w0.102: U45.AK57 110.24,113.81 v1(109.92,113.48) ; v1(102.16,68.57) 102.16,67.73 U52.D7
M_A_DQ20: length 62.3
  TOP w0.102: U30.A2 v1(102.17,70.13)
  IN3 w0.14: v1(108.98,112.81) 108.36,113.42 107.21,113.42 106.77,112.98 106.77,112.07 104.8,110.1 99.41,110.1 99.05,109.75 99.05,106.34 98.27,105.55 98.27,98.36 98.75,97.88 98.75,87.84 98.87,87.72 100.17,87.72 100.29,87.59 100.29,87.39 100.17,87.26 98.87,87.26 98.75,87.13 98.75,86.93 98.87,86.8 100.17,86.8 100.29,86.67 100.29,84.79 100.17,84.67 98.21,84.67 98.08,84.54 98.08,76.5 98.73,75.85 98.73,74.63 102.45,70.91 102.45,70.42 v1(102.17,70.13)
  BOTTOM w0.102: v1(102.17,70.13) 102.56,69.74 U52.A7 ; v1(108.98,112.81) 109.33,113.16 U45.AL58
M_A_DQ21: length 63.5
  TOP w0.102: U30.A3 v1(102.17,69.34)
  IN3 w0.14: v1(108.97,113.48) 108.67,113.78 107.06,113.78 106.41,113.13 106.41,112.22 104.65,110.45 99.2,110.45 98.7,109.95 98.7,106.48 97.91,105.7 97.91,98.21 98.39,97.73 98.39,86.57 98.52,86.45 99.79,86.45 99.91,86.32 99.91,86.09 99.79,85.96 98.52,85.96 98.39,85.84 98.39,85.63 98.52,85.51 99.79,85.51 99.91,85.38 99.91,85.15 99.79,85.02 98.03,85.02 97.73,84.72 97.73,76.35 98.37,75.7 98.37,74.48 101.97,70.88 101.97,70.54 101.74,70.31 101.74,69.88 102.17,69.45 v1(102.17,69.34)
  BOTTOM w0.102: U45.AK58 109.29,113.81 v1(108.97,113.48) ; U52.B8 v1(102.17,69.34)
M_A_DQ22: length 60.4
  TOP w0.102: v1(106.16,69.33) U30.B8
  IN3 w0.14: v1(106.16,69.33) 106.16,69.42 105.74,69.84 105.74,70.64 103.1,73.28 103.1,78.92 102.35,79.67 102.35,91.47 102.23,91.6 100.95,91.6 100.82,91.73 100.82,91.93 100.95,92.06 102.23,92.06 102.35,92.19 102.35,92.39 102.23,92.52 100.95,92.52 100.82,92.64 100.82,92.85 100.95,92.97 102.23,92.97 102.35,93.1 102.35,93.3 102.23,93.43 100.95,93.43 100.82,93.56 100.82,93.76 100.95,93.89 102.23,93.89 102.35,94.01 102.35,94.22 102.23,94.34 100.95,94.34 100.82,94.47 100.82,98.7 100.31,99.21 100.31,104.63 101.02,105.34 101.89,105.34 104.19,107.64 105.4,107.64 106.76,108.99 108.68,108.99 v1(109.92,110.23)
  BOTTOM w0.102: v1(106.16,69.33) 106.56,69.72 U52.A2 ; U45.AR57 110.24,110.56 v1(109.92,110.23)
M_A_DQ23: length 62
  TOP w0.102: v1(106.18,70.15) U30.A7
  IN3 w0.14: v1(106.18,70.15) 106.18,70.8 103.45,73.53 103.45,79.07 102.71,79.81 102.71,94.57 102.58,94.7 101.31,94.7 101.18,94.83 101.18,95.03 101.31,95.16 102.58,95.16 102.71,95.28 102.71,95.49 102.58,95.61 101.31,95.61 101.18,95.74 101.18,95.95 101.31,96.07 102.58,96.07 102.71,96.2 102.71,96.4 102.58,96.53 101.31,96.53 101.18,96.66 101.18,96.86 101.31,96.99 102.58,96.99 102.71,97.11 102.71,97.32 102.58,97.44 101.31,97.44 101.18,97.57 101.18,97.77 101.31,97.9 101.66,97.9 101.79,98.03 101.79,98.23 101.66,98.36 101.31,98.36 101.18,98.49 101.18,98.85 100.67,99.36 100.67,104.48 101.17,104.98 102.03,104.98 104.33,107.28 105.55,107.28 106.33,108.06 108.42,108.06 110.35,109.99 110.35,111.1 v1(109.92,111.53)
  BOTTOM w0.102: U30.A7 v1(106.18,70.15) ; v1(109.92,111.53) 110.24,111.86 U45.AN57
M_A_DQ24: length 67.2
  TOP w0.102: U28.A3 v1(70.16,69.34)
  IN1 w0.178: v1(110.87,110.88) 110.4,110.41 110.4,110.07 109.8,109.47 109.53,109.47 109.41,109.6 109.41,109.64 109.28,109.76 108.92,109.76 108.8,109.64 108.8,109.6 108.65,109.45 107.76,109.45 107.6,109.6 107.6,110.6 107.48,110.73 107.27,110.73 107.15,110.6 107.15,109.71 107.02,109.58 106.84,109.58 106.71,109.71 106.71,109.92 106.59,110.04 106.36,110.04 106.23,109.92 106.23,109.71 106.1,109.58 105.88,109.58 101.64,105.34 100.94,105.34 97.92,102.32 97.92,101.62 91.18,94.88 90.32,94.88 89.56,94.12 88.13,94.12 85.68,91.67 85.68,90.3 80.55,85.17 80.55,84.18 75.9,79.52 75.9,76.87 70.89,71.86 70.89,70.06 v1(70.16,69.34)
  BOTTOM w0.102: U50.B8 v1(70.16,69.34) ; U45.AP55 111.2,111.21 v1(110.87,110.88)
M_A_DQ25: length 67.9
  TOP w0.102: U28.C3 70.56,67.88 70.48,67.8 70.23,67.8 70.16,67.88 v1(70.16,68.57)
  IN1 w0.102: 71.28,69.76 71.28,69.63 71.38,69.53 71.38,69.18 70.77,68.57 v1(70.16,68.57)
  IN1 w0.178: v1(110.87,110.23) 110.87,110.01 109.88,109.02 107.38,109.02 107.22,109.18 106.03,109.18 101.8,104.95 101.1,104.95 98.31,102.16 98.31,101.46 91.34,94.48 90.48,94.48 89.72,93.73 88.3,93.73 86.08,91.51 86.08,90.14 80.95,85.01 80.95,84.01 76.29,79.36 76.29,76.7 74.04,74.45 74.04,74.23 74.1,74.17 74.1,73.95 73.94,73.79 73.72,73.79 73.66,73.85 73.44,73.85 73.28,73.7 73.28,73.47 73.36,73.39 73.36,73.21 73.17,73.02 72.99,73.02 72.91,73.1 72.68,73.1 72.53,72.94 72.53,72.72 72.59,72.66 72.59,72.44 72.43,72.28 72.21,72.28 72.15,72.34 71.93,72.34 71.28,71.69 71.28,69.76
  BOTTOM w0.102: U50.D7 70.16,67.73 v1(70.16,68.57) ; v1(110.87,110.23) 111.2,110.56 U45.AR55
M_A_DQ26: length 69.6
  TOP w0.102: v1(74.16,69.33) U28.B8
  IN1 w0.076: v1(111.82,112.18) 112.43,111.58 112.43,109.92 109.99,107.48 107.56,107.48 107.15,107.06
  IN1 w0.102: 74.1,70.6 74.05,70.55 73.95,70.55 73.75,70.34 73.75,69.74 v1(74.16,69.33)
  IN1 w0.178: 74.1,70.6 74.2,70.7 74.74,70.7 74.84,70.8 74.84,71.33 75.15,71.65 76.02,71.65 76.15,71.78 76.15,72.05 77.17,73.08 77.17,73.59 79.28,75.7 79.28,78.5 79.41,78.62 79.59,78.62 79.71,78.5 79.71,76.56 79.84,76.44 80.02,76.44 80.15,76.56 80.15,79.16 83.64,82.65 83.64,84.01 84.48,84.85 84.48,85.28 88.38,89.18 88.38,90.57 89.24,91.44 91.52,91.44 100.6,100.51 100.6,101.21 101.45,102.07 102.15,102.07 107.15,107.06
  BOTTOM w0.102: U45.AM54 112.15,112.51 v1(111.82,112.18) ; U50.A2 74.56,69.72 v1(74.16,69.33)
M_A_DQ27: length 70.8
  TOP w0.102: v1(74.18,70.15) U28.A7
  IN1 w0.076: 107.48,106.84 107.94,107.3 110.07,107.3 112.61,109.84 112.61,111.74 112.23,112.12 112.23,113.08 v1(111.82,113.48)
  IN1 w0.102: v1(74.18,70.15) 74.57,69.76 75.4,69.76
  IN1 w0.178: 107.48,106.84 102.31,101.67 101.61,101.67 100.99,101.05 100.99,100.34 91.69,91.04 90.1,91.04 89.95,90.89 89.95,90.65 90.1,90.51 90.1,89.91 89.49,89.3 89.05,89.3 87.92,88.16 87.92,87.73 87.78,87.59 87.35,87.59 87.16,87.4 87.16,86.97 87.01,86.83 86.6,86.83 86.42,86.65 86.42,86.23 86.25,86.06 85.82,86.06 85.68,85.93 85.68,85.49 85.44,85.25 85.01,85.25 84.88,85.12 84.88,84.69 84.03,83.84 84.03,82.49 80.54,79 80.54,76.4 80.45,76.31 80.45,76.13 80.53,76.06 80.53,75.88 80.4,75.75 80.22,75.75 80.15,75.83 79.97,75.83 79.79,75.65 79.79,75.48 79.87,75.4 79.87,75.22 79.74,75.09 79.56,75.09 79.49,75.17 79.31,75.17 79.18,75.04 79.18,74.86 79.26,74.79 79.26,74.61 79.13,74.48 78.95,74.48 78.88,74.56 78.7,74.56 77.57,73.43 77.57,72.92 76.54,71.89 76.54,71.38 76.41,71.26 75.32,71.26 75.19,71.13 75.19,70.85 75.32,70.72 76.42,70.72 76.55,70.6 76.55,69.92 76.39,69.76 75.4,69.76
  BOTTOM w0.102: v1(111.82,113.48) 112.15,113.81 U45.AK54 ; U28.A7 v1(74.18,70.15)
M_A_DQ28: length 70.2
  TOP w0.102: v1(69.36,68.56) 69.36,68.53 U28.C2
  IN1 w0.102: v1(69.36,68.56) 69.75,69.2 69.75,70.41 69.94,70.6
  IN1 w0.178: 69.94,70.6 70.06,70.72 70.06,72.15 75.11,77.19 75.11,79.85 77.67,82.41 77.67,83.4 84.87,90.61 84.87,91.97 87.81,94.91 89.23,94.91 89.99,95.67 90.85,95.67 95.77,100.58 95.77,101.29 100.61,106.13 101.31,106.13 107.87,112.69 107.87,113.59 109.28,115 110.29,115 111.34,113.95 111.34,113.3 v1(110.87,112.83)
  BOTTOM w0.102: U45.AL55 111.2,113.16 v1(110.87,112.83) ; v1(69.36,68.56) 69.76,68.17 U28.C2
M_A_DQ29: length 70.1
  TOP w0.102: U28.A2 v1(70.16,70.13)
  IN1 w0.178: v1(110.87,113.48) 110.87,113.86 110.13,114.6 109.75,114.6 109.08,113.93 108.77,113.93 108.44,113.6 108.44,111.16 108.31,111.03 108.11,111.03 107.98,111.16 107.98,111.74 107.86,111.87 107.63,111.87 107.5,111.74 107.5,111.31 107.4,111.21 106.95,111.21 101.47,105.74 100.77,105.74 97.27,102.23 97.27,101.99 97.39,101.86 97.39,101.69 97.19,101.48 97.04,101.48 96.87,101.66 96.7,101.66 96.48,101.44 96.48,101.29 96.68,101.09 96.68,100.94 91.01,95.27 90.15,95.27 89.4,94.51 87.97,94.51 85.28,91.82 85.28,90.46 80.16,85.34 80.16,84.34 79.49,83.67 79.27,83.67 79.2,83.73 79.01,83.73 78.82,83.55 78.82,83.36 78.89,83.29 78.89,83.07 78.73,82.91 78.51,82.91 78.47,82.95 78.25,82.95 78.09,82.8 78.09,82.58 78.13,82.54 78.13,82.32 75.5,79.69 75.5,77.03 70.49,72.02 70.49,70.47 v1(70.16,70.13)
  BOTTOM w0.102: U50.A7 70.16,70.13 v1(70.16,70.13) ; U45.AK55 111.2,113.81 v1(110.87,113.48)
M_A_DQ30: length 67.9
  TOP w0.102: v1(74.17,67.73) 73.77,67.33 U28.D7
  IN1 w0.076: 106.52,107.55 106.8,107.83 109.84,107.83 111.86,109.85 v1(111.86,110.2)
  IN1 w0.102: 73.41,71.1 73.24,70.92 73.24,68.44 73.95,67.73 v1(74.17,67.73)
  IN1 w0.178: 106.52,107.55 101.82,102.85 101.12,102.85 99.81,101.54 99.81,100.83 91.2,92.22 88.91,92.22 87.58,90.89 87.58,89.49 83.69,85.61 83.69,85.18 82.49,83.97 82.49,83.8 82.62,83.68 82.71,83.68 82.84,83.55 82.84,83.32 82.71,83.19 82.26,83.19 80.92,81.85 80.92,81.67 81.14,81.45 81.14,81.27 81.01,81.14 80.83,81.14 80.61,81.37 80.43,81.37 80.31,81.24 80.31,81.06 80.53,80.84 80.53,80.66 80.4,80.53 80.22,80.53 80.01,80.75 79.83,80.75 79.65,80.57 79.65,80.39 79.84,80.2 79.84,79.97 79.46,79.59 79.26,79.59 78.71,79.04 78.15,79.04 77.86,78.75 77.86,78.55 77.99,78.42 78.29,78.42 78.42,78.29 78.42,78.06 78.29,77.94 77.99,77.94 77.86,77.81 77.86,75.55 73.41,71.1
  BOTTOM w0.102: U50.C3 73.77,68.13 v1(74.17,67.73) ; U45.AR54 112.21,110.56 v1(111.86,110.2)
M_A_DQ31: length 69.9
  TOP w0.102: v1(74.96,68.54) 74.56,68.13 U28.C8
  IN1 w0.076: 106.73,107.21 107.18,107.65 109.91,107.65 112.25,109.99 112.25,111.1 v1(111.82,111.53)
  IN1 w0.102: v1(74.96,68.54) 74.56,68.13 73.98,68.13 73.49,68.62 73.49,70.62 73.69,70.82
  IN1 w0.178: 106.73,107.21 101.99,102.46 101.29,102.46 100.2,101.37 100.2,100.67 91.36,91.83 89.08,91.83 87.98,90.74 87.98,89.34 84.09,85.45 84.09,85.01 83.24,84.17 83.24,82.82 82.97,82.54 82.79,82.54 82.56,82.76 82.38,82.76 82.26,82.64 82.26,82.46 82.48,82.23 82.48,82.05 82.35,81.93 82.18,81.93 81.95,82.15 81.77,82.15 81.65,82.02 81.65,81.85 81.87,81.62 81.87,81.44 79.51,79.08 79.31,79.08 78.85,78.62 78.85,77.86 78.33,77.34 78.33,76.69 78.46,76.56 78.75,76.56 78.88,76.44 78.88,76.11 78.75,75.98 78.46,75.98 78.33,75.85 78.33,75.3 76.59,73.56 76.59,73.49 76.72,73.37 76.72,73.19 76.55,73.02 76.37,73.02 76.22,73.17 76.04,73.17 75.87,73 75.87,72.82 76.02,72.67 76.02,72.49 75.85,72.32 75.67,72.32 75.5,72.5 75.37,72.5 73.69,70.82
  BOTTOM w0.102: U45.AN54 112.15,111.86 v1(111.82,111.53) ; v1(74.96,68.54) 74.56,68.13 U28.C8
M_A_DQ32: length 58.4
  TOP w0.102: v1(114.57,66.13) U31.F2
  IN3 w0.102: 112.38,66.51 114.19,66.51 v1(114.57,66.13)
  IN3 w0.14: v1(107.59,105.55) 107.31,105.83 106.6,105.83 106.42,105.64 105.09,105.64 103.26,103.81 103.26,99.1 106.13,96.23 106.13,84.39 106,84.26 104.99,84.26 104.86,84.13 104.86,83.93 104.99,83.8 106,83.8 106.13,83.68 106.13,83.47 106,83.35 104.45,83.35 104.32,83.22 104.32,83.02 104.45,82.89 106,82.89 106.13,82.76 106.13,75.31 106.61,74.83 106.61,73.42 110.26,69.77 110.26,68.62 112.38,66.51
  BOTTOM w0.076: U45.AY58 109.27,107.33 109.27,106.65 108.45,105.83 107.87,105.83 v1(107.59,105.55)
  BOTTOM w0.102: U31.F2 v1(114.57,66.13)
M_A_DQ33: length 59.4
  TOP w0.102: U31.E3 v1(116.16,66.13)
  IN3 w0.102: v1(116.16,66.13) 115.75,65.72 114.51,65.72 114.51,65.71 114.42,65.71 114.4,65.69 112.68,65.69 112.35,66.02
  IN3 w0.14: v1(107.64,106.25) 106.53,106.25 106.27,106 104.94,106 102.9,103.96 102.9,98.94 103.89,97.96 105.77,96.07 105.77,85.66 105.65,85.53 105.32,85.53 105.19,85.4 105.19,85.2 105.32,85.07 105.65,85.07 105.77,84.95 105.77,84.74 105.65,84.62 104.09,84.62 103.97,84.49 103.97,80.36 105.11,79.22 105.11,75.82 106.26,74.68 106.26,73.27 109.9,69.62 109.9,68.47 112.35,66.02
  BOTTOM w0.076: U45.AW58 109.09,107.8 109.09,106.71 108.38,106 107.9,106 v1(107.64,106.25)
  BOTTOM w0.102: U53.F7 115.77,65.74 v1(116.16,66.13)
M_A_DQ34: length 58.9
  TOP w0.102: v1(119.35,64.55) U31.H8
  IN3 w0.102: 112.73,68.06 112.79,68 113.97,68 114.22,67.75 116.69,67.75 117.25,67.19 117.89,67.19 118.14,66.94 118.14,65.97 119.35,64.77 v1(119.35,64.55)
  IN3 w0.14: 112.73,68.06 112.22,68.57 112.22,70.27 111.13,71.36 111.13,72.27 111.01,72.4 110.73,72.4 110.6,72.53 110.6,72.73 110.73,72.86 111.01,72.86 111.13,72.98 111.13,73.19 111.01,73.31 110.22,73.31 110.09,73.44 110.09,73.64 110.22,73.77 111.01,73.77 111.13,73.9 111.13,74.21 108.37,76.97 108.37,77.5 107.82,78.06 107.82,79.18 108.3,79.66 108.3,96.45 104.95,99.8 104.95,102.21 107.87,105.13 v1(109.05,105.13)
  BOTTOM w0.076: v1(109.05,105.13) 109.61,105.13 110.35,105.87 110.35,106 110.72,106.37 110.72,107.25 110.74,107.27 U45.AY56
  BOTTOM w0.102: v1(119.35,64.55) 119.72,64.93 U53.G2
