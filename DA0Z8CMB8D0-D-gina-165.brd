# Allegro board DA0Z8CMB8D0-D-gina-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VMA_WDQS7: length 20.2
  TOP w0.13: v1(50.3,148.52) 50.09,148.32 48.76,148.32 U12.C7
  IN3 w0.102: v1(41.8,142.96) 41.86,142.91 42.14,142.91 42.27,143.04 42.86,143.04 43.62,143.79 48.24,143.79 48.47,144.02 48.47,144.45 48.9,144.87 49.31,144.87 49.49,145.05 49.49,145.27 49.16,145.6 49.16,146.08 49.67,146.58 49.67,148.07 49.89,148.29 50.07,148.29 v1(50.3,148.52)
  BOTTOM w0.102: U43.T26 41.22,140.8 41.07,140.8 40.7,141.16 40.7,141.6 41.8,142.7 41.8,142.83 41.8,142.83 v1(41.8,142.96) ; v1(50.3,148.52) 50.94,147.88 51.05,147.88 51.13,147.96 51.13,148.14 51.37,148.38 51.45,148.38 U39.C7
VR_SVID_ALERT#: length 89.7
  TOP w0.191: PU1.32 146.24,152.27
  TOP w0.203: v1(143.21,153.81) 143.43,154.03 PR2.2 144.72,154.03 144.92,153.83 144.92,153.59 146.24,152.27
  IN3 w0.14: v1(99.4,141.79) 99.4,141.31 100.14,140.57 101.48,140.57 102.4,141.49 104.25,141.49 106.89,144.13 110.98,144.13 112.3,145.45 112.3,148.88 117.23,153.81 120,153.81 120.86,154.67 123.48,154.67 123.94,154.21 124.52,154.21 125.23,153.5 132.53,153.5 133.59,152.45 142.39,152.45 143.21,153.27 v1(143.21,153.81)
  BOTTOM w0.14: R565.2 101.33,122.11 100.75,121.52 R568.2 R578.2 99.6,120.95 98.73,120.95 97.49,122.18 97.49,122.64 96.8,123.33 96.8,125.36 93.9,128.26 93.9,129.77 93.26,130.41 93.26,137.42 96.67,140.83 98.43,140.83 v1(99.4,141.79)
VR_SVID_CLK: length 92.7
  TOP w0.191: PU1.31 147.03,152.86 145.86,154.03 PR3.2 145.63,153.58 v1(145.96,153.25)
  IN3 w0.14: v1(98.51,141.79) 98.51,141.28 99.86,139.94 101.69,139.94 102.65,140.89 104.5,140.89 107.03,143.42 111.13,143.42 112.94,145.22 112.94,148.65 117.48,153.2 120.23,153.2 121,153.96 123.25,153.96 123.63,153.58 124.29,153.58 124.98,152.89 132.29,152.89 133.33,151.85 142.64,151.85 144.03,153.25 v1(145.96,153.25)
  BOTTOM w0.14: v1(98.51,141.79) 98.15,141.44 96.44,141.44 92.16,137.16 92.16,130.67 93.3,129.52 93.3,128 95.84,125.46 95.84,123.89 96.13,123.6 96.13,122.7 97.42,121.41 97.42,120.41 97.88,119.95 99.7,119.95 99.7,119.96 101.18,119.96 R579.2
VR_SVID_DATA: length 83
  TOP w0.14: v1(142.57,153.81) 142.57,153.74 142.96,153.35 143.39,153.35 143.69,153.05 PR6.2
  TOP w0.191: PU1.1 145.74,151.67 145.42,151.98 145.42,152.56 144.94,153.04 144.08,153.04 PR6.2
  IN3 w0.14: v1(142.57,153.81) 142.57,153.55 142.07,153.04 133.83,153.04 132.77,154.11 125.48,154.11 124.75,154.85 124.27,154.85 123.77,155.35 120.69,155.35 119.77,154.42 116.93,154.42 111.67,149.16 111.67,145.68 110.75,144.76 106.68,144.76 104,142.08 102.15,142.08 101.27,141.21 100.62,141.21 100.29,141.54 v1(100.29,141.79)
  BOTTOM w0.14: v1(100.29,141.79) 98.71,140.22 96.91,140.22 93.86,137.17 93.86,130.65 94.5,130.02 94.5,129.35 97.4,126.45 97.4,123.59 98.32,122.67 R558.2
VREFC_VMA1: length 42.5
  IN2 w0.381: v1(68.97,123.66) 69.43,123.21 69.43,121.27 68.92,120.76 60.66,120.76 58.49,122.93 58.49,126.14 58.51,126.16 58.51,128.63 58.09,129.05 58.09,130.37 59.01,131.3 59.01,131.57 59.93,132.48 59.93,136.46 60.27,136.8 63.62,136.8 63.97,137.14 65.18,137.14 v1(65.54,137.51) 65.56,137.52 67.27,137.52 67.88,138.13 67.88,142.12 67.66,142.34 v1(67.22,142.34)
VREFC_VMA3: length 23.1
  TOP w0.203: U12.M8 47.45,155.8 47.05,155.41 45.94,155.41 44.25,153.71 43.62,153.71 v1(43.52,153.61)
  IN2 w0.381: v1(38.18,156.05) 38.29,155.94 38.82,155.94 38.95,156.07 42.5,156.07 ; 42.5,156.07 42.88,156.45 42.88,157.53 43.61,158.25 44.28,158.25 44.93,157.6 45.82,157.6 46.06,157.84 48.85,157.84 50.4,156.29 v1(50.4,156.02) ; 42.5,156.07 42.5,154.63 v1(43.52,153.61)
VREFD_VMA1: length 36.2
  TOP w0.305: U13.H1 64.33,137.72 v1(64.35,137.71)
  TOP w0.381: 65.61,125.46 65.09,125.98 v1(64.83,125.98) U16.H1
  TOP w0.508: 65.61,125.46 66,125.07 66,123.62 R122.1 C200.2 R123.2
  IN2 w0.381: v1(64.35,137.71) 63.85,138.21 63.66,138.21 63.2,138.67 63.2,139.68 62.77,140.12 58.93,140.12 58.12,140.93 58.12,146.23 58.94,147.05 62.19,147.05 63.39,145.85 v1(65.03,145.85)
  BOTTOM w0.381: U41.H1 64.33,145.1 64.57,145.34 ; U44.H1 64.65,133.2 v1(64.65,133.44) 64.65,133.92 63.46,135.11 63.46,136.56 64.35,137.45 v1(64.35,137.71)
  BOTTOM w0.508: v1(65.03,145.85) 64.57,145.39 64.57,145.34
VREFD_VMA3: length 46.7
  TOP w0.305: v1(43.06,151.86) 42.94,151.86 42.19,152.6 U11.H1
  TOP w0.381: v1(53.77,153.1) U12.H1
  IN2 w0.381: 36.79,154.42 35.09,154.42 v1(34.11,153.44) ; 39.07,153.15 41.77,153.15 v1(43.06,151.86) ; v1(45.87,152.88) 45.42,152.44 45.42,146.29 45.93,145.78 53.81,145.78 54.39,146.36 54.39,152.48 v1(53.77,153.1)
  BOTTOM w0.381: U38.H1 34.16,153.44 v1(34.11,153.44) ; v1(43.06,151.86) 43.58,151.34 44.89,151.34 45.42,151.88 45.42,152.44 v1(45.87,152.88) 45.92,152.82 45.92,152.73 46.21,152.44 46.69,152.44 46.79,152.53 46.8,152.53 U39.H1
  BOTTOM w0.508: v1(34.11,153.44) 32.05,153.44 v1(31.39,154.1) C569.2 R465.2 R461.1
VRON: length 129.8
  TOP w0.14: U32.69 155,55.33 154.52,54.85 151.47,54.85 150.53,55.79 v1(149.95,55.79) ; v1(142.45,149.01) 142.33,148.89 v1(142.33,148.19)
  TOP w0.203: v1(142.45,149.01) 142.52,149.08 143.07,149.08 PR9.1
  IN2 w0.114: v1(142.45,149.01) 143.91,147.56 145.12,147.56 145.6,148.04 146.53,148.04 146.74,147.82 150.55,147.82 150.76,148.03 150.76,149.39 151.22,149.84 152.23,149.84 152.56,149.51 152.56,142.35 153.88,141.03 153.88,131.4 159.85,125.43 159.85,123.94 160.08,123.71 160.08,116.73 159.6,116.25 159.6,114.41 159.88,114.13 159.88,111.54 160.44,110.98 160.44,110.42 161.02,109.84 162.36,109.84 165.47,106.73 165.47,97.78 161.76,94.07 161.76,87.28 160.84,86.37 160.84,82.18 158.42,79.76 158.42,76.27 156.62,74.47 156.62,71.56 154.86,69.79 154.86,68.8 153.5,67.44 153.5,64.45 151.52,62.47 151.52,60.84 152.39,59.97 152.39,59.12 152.13,58.86 150.66,58.86 150.15,58.35 150.15,55.99 v1(149.95,55.79)
  BOTTOM w0.14: v1(142.45,149.01) 142.52,149.08 R491.1
VRON_CPU: length 64.7
  TOP w0.14: v1(142.81,147.3) 143.11,147.61 PR11.1 ; v1(107.82,126.99) 107.82,127.07 v1(106.89,128) 105.5,129.4 103.46,129.4 102.83,130.03 102.83,132.37 v1(104.94,134.48)
  IN2 w0.114: v1(142.81,147.3) 140.14,149.97 130.69,149.97 129.78,150.89 126.17,150.89 124.42,152.64 119.34,152.64 116.93,150.22 116.93,144.64 108.04,135.75 106.51,135.75 105.24,134.48 v1(104.94,134.48)
  BOTTOM w0.076: v1(104.94,134.48) 104.94,134.78 105.02,134.87 R507.2
  BOTTOM w0.102: v1(107.82,126.99) 108.15,126.66 U45.F60
VSYNC: length 6.1
  TOP w0.127: U6.2 v1(99.53,158.99)
  BOTTOM w0.127: U40.3 102.57,156.07 101.15,157.49 100.77,157.49 99.53,158.73 v1(99.53,158.99)
WIGIG_RST#: length 119.3
  TOP w0.102: 142.64,67.04 U32.126
  TOP w0.14: v1(143.62,66.05) 142.64,67.03 142.64,67.04
  IN2 w0.114: v1(211.73,76.79) 211.03,77.5 211.03,79.94 209.55,81.42 209.55,82.13 206.65,85.04 202.26,85.04 197.02,90.27 194.9,90.27 194.12,89.49 167.83,89.49 164.21,85.87 164.21,78.54 157.69,72.02 157.69,70.32 156.85,69.47 156.85,69.22 155.56,67.94 155.56,67.45 155.14,67.03 155.14,63.7 154.01,62.57 152.71,62.57 152.43,62.29 152.43,60.49 152.61,60.31 152.61,59.04 152.22,58.65 150.82,58.65 150.4,58.23 150.4,55.61 150.15,55.36 149.48,55.36 149.18,55.66 149.18,56.63 147.34,58.47 142.39,58.47 141.82,59.04 141.82,61.32 143.85,63.36 143.85,65.82 v1(143.62,66.05)
  BOTTOM w0.14: v1(211.73,76.79) 212.1,77.16 212.1,77.38 212.81,78.09 214.34,78.09 R707.2
WIGIG_RX1+_WLAN: length 158.2
  IN3 w0.089: v1(230.21,89.67) 230.36,89.82 230.68,89.82 230.89,89.61 230.89,78.47 230.51,78.09 230.51,76.11 229.52,75.12 224.28,75.12 223.55,74.38 209.28,74.38 205.49,78.17 202.23,78.17 201.46,78.93 192.92,78.93 191.17,80.68 191.17,83.35 190.46,84.06 183.32,84.06 179.57,87.8 178.46,87.8 162.26,104 162.26,106.57 160.79,108.04 160.79,111.31 159.98,112.12 158.96,112.12 156.87,114.22 156.87,115.05 155.63,116.29 155.63,116.98 152.69,119.92 152.69,120.05 151.32,121.42 151.32,125.23 150.05,126.5 149.41,126.5 149.06,126.86 149.06,127.62 148.47,128.2 148.47,129.18 147.53,130.12 147.53,131.95 146.36,133.12 146.36,134.34 145.58,135.12 145.58,135.76 144.62,136.71 141.77,136.71 140.93,135.87 140.34,135.87 139.58,135.12 139.58,133.55 138.57,132.53 138.57,131.36 135.54,128.34 135.54,126.98 135.98,126.55 v1(135.98,126.48)
  BOTTOM w0.076: v1(135.98,126.48) 136.3,126.16 U45.G15
  BOTTOM w0.14: v1(230.21,89.67) 230.21,89.75 230.08,89.87 229.75,89.87 228.59,88.71 CN12.65
WIGIG_RX1-_WLAN: length 158.2
  IN3 w0.089: v1(230.21,90.31) 230.49,90.03 230.77,90.03 231.1,89.7 231.1,78.39 230.72,78 230.72,76.02 229.61,74.91 224.37,74.91 223.63,74.18 209.2,74.18 205.41,77.96 202.14,77.96 201.38,78.72 192.84,78.72 190.97,80.6 190.97,83.26 190.37,83.85 183.24,83.85 179.49,87.6 178.37,87.6 162.06,103.91 162.06,106.49 160.59,107.96 160.59,111.23 159.89,111.92 158.88,111.92 156.66,114.14 156.66,114.97 155.43,116.2 155.43,116.9 152.49,119.84 152.49,119.97 151.11,121.34 151.11,125.15 149.96,126.3 149.33,126.3 148.85,126.77 148.85,127.53 148.27,128.12 148.27,129.09 147.33,130.03 147.33,131.86 146.16,133.03 146.16,134.25 145.37,135.04 145.37,135.67 144.53,136.51 141.85,136.51 141.01,135.67 140.42,135.67 139.79,135.04 139.79,133.46 138.77,132.44 138.77,131.28 135.75,128.25 135.75,127.19 135.82,127.11 v1(135.98,127.11)
  BOTTOM w0.076: U45.F15 136.61,126.91 136.61,127.11 136.56,127.16 136.03,127.16 v1(135.98,127.11)
  BOTTOM w0.14: v1(230.21,90.31) 230.04,90.14 229.64,90.14 228.71,89.21 CN12.67
WIGIG_TX1+_WLAN: length 149.2
  IN1 w0.102: v1(229.32,86.34) 229.57,86.6 229.57,92.22 230.34,92.98 230.34,95.74 228.94,97.14 223.48,97.14 223.15,96.81 222.64,96.81 220.68,94.85 219.32,94.85 218.33,93.86 202.88,93.86 202.55,93.53 197.27,93.53 196.6,92.87 193.82,92.87 192.88,91.93 186.19,91.93 183.09,95.03 183.09,96.3 172.3,107.1 172.3,114.99 156.59,130.69 147.07,130.69 145.7,132.06 144.43,132.06 143.49,133 139.05,133 138.36,132.32 136.2,132.32 135.85,131.96 126.26,131.96 124.14,134.08 123.38,134.08 122.64,134.82 122.64,135.72 122.49,135.87 v1(122.26,135.87)
  BOTTOM w0.14: C624.2 122.39,135.5 122.39,135.75 v1(122.26,135.87) ; v1(229.32,86.34) 229.49,86.51 229.49,87.07 229.11,87.44 228.77,87.44 228.54,87.21 CN12.59
WIGIG_TX1-_WLAN: length 149.2
  IN1 w0.102: v1(229.96,86.34) 229.78,86.52 229.78,92.14 230.54,92.9 230.54,95.83 229.02,97.34 223.39,97.34 223.06,97.01 222.56,97.01 220.6,95.06 219.24,95.06 218.25,94.07 202.79,94.07 202.46,93.74 197.18,93.74 196.52,93.07 193.73,93.07 192.79,92.14 186.28,92.14 183.3,95.12 183.3,96.39 172.5,107.18 172.5,115.07 156.68,130.9 147.16,130.9 145.79,132.27 144.52,132.27 143.58,133.21 138.96,133.21 138.28,132.52 136.12,132.52 135.76,132.17 126.35,132.17 124.23,134.29 123.47,134.29 122.84,134.91 122.84,135.7 v1(123.02,135.87)
  BOTTOM w0.14: C625.2 123.15,135.75 v1(123.02,135.87) ; CN12.61 229.22,87.71 229.75,87.18 229.75,86.55 v1(229.96,86.34)
WIGIG_TX3+: length 7.5
  BOTTOM w0.076: U45.A31 126.64,130.07 126.69,130.13 126.69,131.11 124.63,133.17 123.57,133.17 122.77,133.97 122.77,134.45 122.67,134.55 122.22,134.55 C624.1
WIGIG_TX3-: length 7.5
  BOTTOM w0.076: U45.B31 126.48,129.68 126.86,130.06 126.86,130.18 126.86,131.17 124.7,133.33 124.56,133.33 123.64,133.33 122.94,134.03 122.94,134.26 C625.1
WK_GPIO27: length 20.2
  IN3 w0.089: v1(146.87,98.76) 146.44,99.19 145.76,99.19 144.43,100.52 144.03,100.52 143.58,100.97 143.58,101.4 141.78,103.2 141.78,105.74 142.2,106.16 142.2,107.43 141.56,108.06 141.56,109.71 141.98,110.12 141.98,112.13 142.45,112.61 v1(142.45,112.76)
  BOTTOM w0.102: U45.AN5 141.92,112.08 142.45,112.61 v1(142.45,112.76)
  BOTTOM w0.14: R688.1 R686.1 146.87,98.17 v1(146.87,98.76)
WLAN_CLK_SCLK: length 2.1
  BOTTOM w0.14: TP148.1 218.24,87.46 CN12.60
WLAN_CLK_SDATA: length 2.4
  BOTTOM w0.14: TP149.1 219.01,86.96 CN12.58
WLAN_LED1#: length 2.7
  BOTTOM w0.14: TP152.1 217.95,73.96 CN12.6
WLAN_RST: length 6.8
  BOTTOM w0.14: CN12.52 219.29,85.46 219.13,85.3 219.13,83.65 v1(218.65,83.17) 218.27,82.79 R704.1 R703.1 R702.1
WLAN_WAKE#: length 71.7
  TOP w0.14: R259.2 198.75,91.67 v1(198.89,91.53) 198.89,90.99 199.73,90.15 202.28,90.15 R266.2 ; v1(153.6,70.98) 153.6,71.03 153.26,71.37 R316.2
  IN2 w0.114: v1(162.9,79.74) 162.9,81.44 162.26,82.08 162.26,86.34 162.77,86.85 163.66,86.85 167.62,90.81 193.4,90.81 194.4,91.8 198.61,91.8 v1(198.89,91.53)
  BOTTOM w0.14: v1(153.6,70.98) 153.63,71 154.09,71 154.54,70.55 155.23,70.55 155.79,71.1 161.92,71.1 163.04,72.22 163.04,73.8 162.02,74.81 162.02,78.91 162.85,79.74 v1(162.9,79.74)
WRST#: length 6.4
  TOP w0.14: U32.14 139.44,60.93 138.37,59.86 v1(138.26,59.86) 138.11,59.86 137.37,59.12 C416.1 R353.1 135.85,59.05 135.17,59.72 D16.2
X-TX0N: length 6.2
  TOP w0.127: L5.1 139.99,158.08 140.19,158.28 140.42,158.28 140.88,158.73 140.88,159.34 140.98,159.45 v1(141.34,159.45) 141.34,160.03 141.41,160.1 142.54,161.24 142.87,161.24 143.14,160.97 U4.5
X-TX0P: length 6.2
  TOP w0.127: L5.4 139.97,158.88 140.14,158.71 140.24,158.71 140.45,158.91 140.45,159.52 140.65,159.73 v1(140.65,160.53) 141.23,160.53 142.36,161.67 U4.6
X-TX1N: length 5.7
  TOP w0.127: L7.1 139.82,155.92 140.05,156.14 140.5,156.14 140.82,156.47 v1(141.34,156.47) 141.34,157.18 141.82,157.66 141.82,158.52 142.24,158.94 142.36,158.94 142.45,158.85 U7.7
X-TX1P: length 5.6
  TOP w0.127: U7.8 142.23,159.55 141.39,158.7 141.39,157.84 141.05,157.5 v1(140.56,157.5) 140.56,156.82 140.32,156.57 140.05,156.57 139.9,156.72 L7.4
X-TX2N: length 7.3
  BOTTOM w0.127: U35.8 143.34,160.97 143.21,161.1 142.89,161.1 141.89,160.11 140.9,160.11 140.67,159.88 140.67,159.42 140.78,159.32 v1(141.06,159.32) 140.62,158.89 140.62,158.61 139.59,157.57 L23.4
X-TX2P: length 7.3
  BOTTOM w0.127: U35.7 143.36,161.67 143.21,161.53 142.71,161.53 141.72,160.54 140.72,160.54 140.24,160.06 140.24,159.5 140.06,159.32 v1(139.76,159.32) 140.17,158.91 140.17,158.76 139.63,158.23 139.26,158.23 L23.1
X-TX3N: length 6.7
  BOTTOM w0.127: L26.4 139.54,155.54 139.76,155.76 140.05,155.76 v1(140.31,155.51) 140.31,155.8 140.55,156.04 141.08,156.04 141.46,156.42 141.46,157.74 141.84,158.13 141.84,158.26 142.27,158.7 142.53,158.95 142.97,158.95 U36.6
X-TX3P: length 6.6
  BOTTOM w0.127: U36.5 142.91,159.38 142.35,159.38 141.97,159 141.41,158.44 141.41,158.3 141.03,157.92 141.03,156.6 140.9,156.47 140.64,156.47 v1(140.31,156.8) 140.31,156.61 139.89,156.19 139.68,156.19 139.54,156.34 L26.1
XDP_BPM#0: length 5.1
  TOP w0.14: v1(104.38,125.26) 104.38,125.94 TP19.1
  BOTTOM w0.076: U45.J60 107.85,124.81 107.38,124.81 107.34,124.85 106.55,124.85 106.39,124.68 105.88,124.68 104.9,124.68 104.38,125.21 v1(104.38,125.26)
XDP_BPM#1: length 1.5
  TOP w0.14: v1(107.85,125.52) 107.85,126.01 TP17.1
  BOTTOM w0.102: U45.H60 108.15,125.82 v1(107.85,125.52)
XDP_BPM#2: length 6
  BOTTOM w0.076: 103.72,126.6 104.58,126.6 105.35,125.83 105.36,125.83 105.36,125.82 105.85,125.82 105.93,125.75 106.07,125.6 106.32,125.6 106.49,125.77 106.49,125.95 106.72,126.18 107.24,126.18 U45.H61
  BOTTOM w0.14: 103.72,126.6 TP118.1
XDP_BPM#3: length 6.9
  BOTTOM w0.076: 103.21,126.09 103.34,126.09 103.62,126.37 104.57,126.37 105.28,125.66 105.29,125.66 105.29,125.66 105.78,125.66 105.86,125.58 106.01,125.43 106.39,125.43 106.4,125.44 106.4,125.44 U45.H62
  BOTTOM w0.14: 103.21,126.09 101.3,126.09 TP119.1
XDP_BPM#4: length 1.4
  TOP w0.14: v1(109.19,124.77) 109.31,124.89 TP21.1
  BOTTOM w0.102: v1(109.19,124.77) 108.85,124.43 U45.K59
XDP_BPM#5: length 6.3
  BOTTOM w0.076: U45.H63 106.1,125.99 105.42,125.99 104.3,127.11 103.72,127.11
  BOTTOM w0.14: 103.72,127.11 100.77,127.11 TP117.1
XDP_BPM#6: length 1.7
  TOP w0.14: v1(107.85,124.02) 107.12,124.75 TP23.1
  BOTTOM w0.102: v1(107.85,124.02) 108.15,124.32 U45.K60
XDP_BPM#7: length 1.5
  TOP w0.14: v1(107.2,125.52) 107.2,125.92 TP16.1
  BOTTOM w0.102: U45.J61 107.2,125.4 v1(107.2,125.52)
XDP_DBRESET_N: length 2.1
  TOP w0.14: R195.1 R196.1 86.27,105.64 TP84.1
XDP_PRDY#: length 3.2
  TOP w0.14: v1(104.99,125.36) 104.99,125.59 TP20.1
  BOTTOM w0.076: U45.J62 106.61,125.14 106.32,124.85 105.81,124.85 105.81,124.85 105.37,124.85 104.99,125.23 v1(104.99,125.36)
XDP_PREQ#: length 3.8
  TOP w0.14: v1(105.07,124.09) 105.07,123.92 TP30.1
  BOTTOM w0.076: U45.K62 106.4,123.95 106.4,123.95 106.39,123.94 106.07,123.94 105.84,123.71 105.77,123.71 105.45,123.71 105.06,124.09 v1(105.07,124.09)
XDP_RST_R_N: length 1.5
  TOP w0.14: R215.2 36.03,102.34 TP85.1
XDP_TCK0: length 22.3
  TOP w0.14: TP62.1 98.36,116.21 v1(97.75,116.82) 96.99,117.58 R152.2
  IN2 w0.114: v1(107.81,127.82) 107.39,127.82 106.51,126.93 106.51,120.25 105.82,119.56 100.13,119.56 97.75,117.18 v1(97.75,116.82)
  BOTTOM w0.102: v1(107.81,127.82) 108.15,127.48 U45.E60
  BOTTOM w0.14: R597.1 97.88,116.95 v1(97.75,116.82)
XDP_TCK1: length 9.9
  BOTTOM w0.076: U45.AE62 106.63,115.93 106.42,115.93 106.29,115.87 106.26,115.86 106,115.86 105.87,115.99 103.92,115.99 103.59,116.32 101.94,116.32 101.53,116.72 ; TP139.1 99.55,115.88 99.53,115.91
  BOTTOM w0.089: 101.53,116.72 101.07,117.18 100.52,117.18 100.29,116.95 100.29,116.11 TP139.1
  BOTTOM w0.14: 99.53,115.91 99.18,115.91 R602.2
XDP_TDI: length 35.9
  TOP w0.14: v1(104.37,116.97) 103.89,117.46 103.46,117.46 103,117 103,116.77 102.52,116.29 100.14,116.29 TP64.1 99.27,115.43 97.62,115.43 94.7,118.35 93.18,118.35 92.67,117.84 R151.2 ; v1(95.03,122.23) 95.46,122.67 95.94,122.67 96.48,123.2 96.48,123.72 97.06,124.3 97.06,124.89 96.37,125.58 U17.5
  BOTTOM w0.076: 100.29,118.22 100.58,117.93 100.96,117.93 101.3,117.59 103.55,117.59 104.17,116.97 v1(104.37,116.97) 104.83,116.52 105.92,116.52 106.01,116.61 106.32,116.61 106.49,116.78 106.49,116.95 106.72,117.19 107.24,117.19 U45.AD61
  BOTTOM w0.14: 100.29,118.22 99.58,118.22 99.28,118.51 98.27,118.51 95.03,121.75 v1(95.03,122.23)
XDP_TDI_CPU: length 13
  TOP w0.14: U17.6 95.54,126.71 v1(96.02,127.2)
  IN3 w0.089: v1(96.02,127.2) 97.59,128.76 102.62,128.76 v1(103.34,128.05)
  BOTTOM w0.076: U45.F63 105.48,126.64 104.07,128.05 103.89,128.05
  BOTTOM w0.14: v1(103.34,128.05) 103.89,128.05
XDP_TDO: length 18.2
  TOP w0.14: R166.1 87.72,115.93 TP65.1 88.98,116.56 R162.1 87.66,116.75 v1(87.08,117.33) ; U17.2 v1(95.54,123.35)
  BOTTOM w0.14: v1(87.08,117.33) 86.7,117.71 86.7,120 87.59,120.89 88.35,120.89 90.05,122.58 94.08,122.58 94.13,122.54 94.73,122.54 v1(95.54,123.35)
XDP_TDO_CPU: length 14.8
  TOP w0.14: v1(96.35,126.6) 96.73,126.98 R103.2 97.94,127.44 101.98,127.44 v1(102.6,128.06) ; U17.3 96.33,124.58 v1(96.38,124.63)
  IN2 w0.114: v1(96.35,126.6) 96.35,124.66 v1(96.38,124.63)
  BOTTOM w0.076: U45.F62 106.61,126.64 106.32,126.35 105.54,126.35 104.27,127.62 103.72,127.62
  BOTTOM w0.14: v1(102.6,128.06) 103.04,127.62 103.72,127.62
XDP_TMS: length 34.4
  TOP w0.14: v1(87.81,117.39) 87.78,117.41 89.58,117.41 89.76,117.59 R150.2 90.17,117.84 90.64,117.37 92.57,117.37 93.3,118.11 94.6,118.11 97.53,115.17 100.67,115.17 TP68.1 101.55,116.05 102.99,116.05 103.6,116.65 v1(103.6,116.97) ; v1(90.26,125.84) 91.41,125.84 91.65,126.08 U17.9
  IN2 w0.114: v1(90.26,125.84) 90.18,125.84 87.34,123 87.34,117.86 v1(87.81,117.39)
  BOTTOM w0.076: v1(103.6,116.97) 104.22,116.35 105.99,116.35 106.07,116.44 106.39,116.44 106.4,116.45 106.4,116.45 U45.AD62
XDP_TMS_CPU: length 15.9
  TOP w0.14: U17.8 93.06,126.97 93.8,127.71 100.76,127.71 v1(100.95,127.9) 101.58,128.53 v1(105.19,128.53)
  BOTTOM w0.076: v1(105.19,128.53) 105.77,128.53 105.88,128.43 106.46,128.43 106.56,128.33 106.97,128.33 107.32,127.98 107.32,127.67 107.5,127.5 U45.E61
XDP_TRST#: length 61.1
  TOP w0.14: v1(86.57,116.06) 86.57,115.55 88.6,113.52 92.39,113.52 97.34,108.57 101.95,108.57 v1(102.46,108.06) ; U17.11 91.5,125.08 91.12,124.7 90.89,124.7 90.61,124.42 v1(90.61,124.2)
  IN2 w0.114: v1(86.57,116.06) 87.33,116.06 88.38,117.1 90.92,117.1 91.4,117.59 91.4,118.09 90.38,119.11 90.38,123.97 v1(90.61,124.2)
  IN3 w0.089: v1(90.61,124.2) 91.11,124.7 91.19,124.7 93.96,127.47 95.34,127.47 96.86,128.99 104.12,128.99 105.7,127.42 108.06,127.42 v1(108.46,127.82)
  BOTTOM w0.076: U45.AU62 106.51,109.07 106,109.07 104.86,107.93
  BOTTOM w0.102: U45.E59 108.8,127.48 v1(108.46,127.82)
  BOTTOM w0.14: v1(102.46,108.06) R644.2 104.35,107.43 104.86,107.93
XDP_TRST_N: length 6.5
  TOP w0.14: v1(91.22,124.19) 91.61,124.58 U17.12
  BOTTOM w0.14: TP121.1 89.57,125.28 90.73,125.28 91.22,124.79 v1(91.22,124.19)
XTAL24_IN: length 11.2
  BOTTOM w0.076: C630.1 128.87,133.71 129.31,133.27 129.31,133.26 129.45,133.12 129.45,131.81 130.11,131.15 130.11,130.44 130.24,130.31 130.24,130.2 U45.A25
  BOTTOM w0.14: C630.1 129.37,134.21 129.37,135.59 R501.1 128.23,135.72 v1(128.02,135.92) 127.59,136.36 127.59,137.77 Y3.3
XTAL24_OUT: length 9.1
  BOTTOM w0.076: U45.B25 130.11,129.66 130.54,130.09 130.54,130.25 130.27,130.51 130.27,131.23 129.61,131.89 129.61,133.19 C631.1
  BOTTOM w0.14: C631.1 129.63,134.21 129.63,135.33 R501.2 130.11,135.81 130.11,136.49 Y3.1
XTAL_SSIN: length 16.8
  BOTTOM w0.102: 55.46,125.18 54.04,126.59 54.04,127.07 53.7,127.41 U43.A10
  BOTTOM w0.14: R634.1 58,113.66 58,114.41 v1(58.25,114.66) 58.25,115.68 57.92,116.01 57.92,116.62 58.12,116.82 58.12,117.97 57.22,118.87 57.22,122.65 55.59,124.29 55.59,125.05 55.46,125.18
N03288: length 9.6
  TOP w0.14: PQ9.4 34.89,88.89 34.88,88.89 v1(34.88,88.76)
  TOP w0.254: PQ9.4 34.12,90.38 33.63,89.89 PR43.2 32.47,89.89 32.38,89.8 PC31.2 30.69,88.78 30.69,88.24 PR45.1 31.2,87.4 PQ11.6
N05582: length 5.1
  TOP w0.14: v1(34.5,58.58) 35.14,59.22 PR100.1
  TOP w0.203: PR95.2 36.91,61.2 37.06,61.04 PQ22.4 35.87,60.27 PR100.1
N05646: length 4.5
  TOP w0.14: PQ11.3 29.87,83.3 v3(29.52,82.94)
  TOP w0.508: PQ11.2 30.77,85.33 31.02,85.07 31.02,84.58 30.77,84.33 PQ11.3
N05670: length 48.6
  TOP w0.14: v1(30.57,64.63) 29.68,64.63 29.45,64.4 29.45,61.81 30.61,60.64 31.97,60.64 32.44,61.12 33.54,61.12 v1(33.87,61.45) 34.25,61.45 35.01,62.21 35.01,64.24 PQ20.2 ; PQ11.5 31.89,85.33 30.69,86.52 30.69,87.48 30.44,87.73 PR44.1 29.94,87.73 29.68,87.99 29.68,89.39 30.06,89.77 v1(30.48,89.77)
  IN1 w0.114: v1(30.57,64.63) 30.93,64.99 30.93,66.62 30.43,67.13 30.43,68.17 31.99,69.73 31.99,73.62 31.48,74.13 31.48,76.41 29.93,77.96 29.93,87.67 31.23,88.97 31.23,89.49 30.95,89.77 v1(30.48,89.77)
N05802: length 3.8
  BOTTOM w0.14: PR207.1 52.03,58.91 52.16,58.78 53.81,58.78 54.31,58.28 54.61,58.28 PR208.2
  vias: v2(43.65,59.55) v2(45.17,59.55) v2(46.69,59.55) v2(48.22,59.55) v2(49.06,58.68) v3(46.19,57.69)
N06510: length 2.7
  TOP w0.14: PR93.2 v3(43.86,62.59)
  TOP w0.381: PR93.2 45.52,62.59 45.55,62.56 PC63.1
N90670: length 4.9
  TOP w0.14: v1(30.59,63.99) 30.06,63.99 v1(29.93,64.12)
  TOP w0.305: v1(30.59,63.99) 30.66,63.92 PC59.1 31.23,64.59 31.26,64.62 PR87.1
  BOTTOM w0.305: v1(30.59,63.99) 30.42,63.82 PJ2.3
N243495: length 14.2
  TOP w0.14: v1(45.17,73.64) 45.17,73.52 45.04,73.39 43.77,73.39 43.01,74.15 40.21,74.15 39.97,74.39
  IN1 w0.127: v1(49.62,69.07) 49.36,68.82 49.23,68.82 49.11,68.94 49.11,69.45 46.45,72.11 46.45,72.9 45.96,73.39 45.42,73.39 v1(45.17,73.64)
  BOTTOM w0.14: v1(49.62,69.07) 49.74,68.94 50.23,68.94 PR188.2
  vias: v1(40.17,79.18)
N1295644: length 3.2
  TOP w0.14: v1(43.83,94.16) 43.84,94.17 PC27.1
  TOP w0.381: PC27.1 44.94,94.14 44.94,94.04 46.19,92.8 PR41.2
N1295718: length 2.4
  TOP w0.14: v1(57.8,93.78) 57.82,93.76 PC30.1
  TOP w0.508: PC30.1 57.82,91.4 PR42.2
N1295854: length 3
  TOP w0.508: PR50.2 57.44,81.21 56.57,82.08 v1(56.09,82.08) 56.04,82.03 PC36.2
N1295864: length 2.6
  TOP w0.14: PR56.2 48.93,77.46 v1(48.22,76.74)
  TOP w0.254: PC40.2 PR56.2
N1295902: length 2.2
  TOP w0.305: PR75.1 56.07,70.3 v1(56.07,69.55) 55.86,69.55 55.48,69.17 PC49.2
N1296006: length 5.7
  TOP w0.254: PC46.1 55.08,70.03 v1(55.27,69.85)
  TOP w0.381: PR78.1 PC46.1
  BOTTOM w0.254: v1(55.27,69.85) 55.24,69.87 55.24,70.76 55.66,71.18 PR183.1 v1(56.93,71.18) 57.62,70.49 PR185.2
N1354566: length 2.3
  BOTTOM w0.14: PR180.1 49.11,69.52 49.01,69.41 v3(49.01,69.4)
  BOTTOM w0.381: PR180.1 PR181.2
N1354570: length 6.5
  TOP w0.14: v1(51.37,69.25) 51.37,69.56 v1(51.02,69.9)
  TOP w0.381: PC45.1 PR76.1 PR77.2 51.5,70.38 v1(51.02,69.9)
  BOTTOM w0.254: PR184.2 52.21,70.71 51.98,70.48 PR77.2 51.1,70.48 50.97,70.35 50.97,70 51.02,69.95 v1(51.02,69.9)
N6957176: length 5.5
  TOP w0.14: v1(174.28,65.01) PQ19.3
  TOP w0.381: PR79.2 173.57,69.15 174.28,68.44 PQ19.3
N6957188: length 3.7
  TOP w0.14: PR120.2 v1(212.3,47.23)
  TOP w0.508: PQ27.3 210.65,45.58 PR120.2
N6993431: length 16
  TOP w0.14: v1(10.88,139.18) 10.88,140.16 PR25.1 PR26.2 12.19,142.49 PQ1.3 13.5,142.78 PQ2.2 14.69,141.97 v1(15.33,142.6) ; PQ3.2 v1(18.88,138.29)
  IN3 w0.089: v1(15.33,142.6) 17.48,140.45 17.48,139.68 v1(18.88,138.29)
N7038240: length 2.4
  TOP w0.14: v1(14.92,123.2) 15.18,122.94 PR30.1
  TOP w0.381: PC17.1 16.52,122.96 16.49,122.94 PR30.1
N7038508: length 2.4
  TOP w0.14: PR29.2 v3(12.24,131.85)
  TOP w0.508: PR29.2 11.2,133.12 PC14.1
N7165711: length 2.2
  TOP w0.14: PC1.2 151.33,155.78 v1(151.7,156.14)
  TOP w0.203: PR1.2 PC1.2
N7169591: length 1
  TOP w0.14: PR91.2 192.52,63.26 v1(192.49,63.23)
N7169727: length 2.7
  TOP w0.14: PR83.2 v1(181.31,68.69)
  TOP w0.508: PC51.1 180.88,67.65 180.93,67.6 PR83.2
N7169889: length 3.6
  TOP w0.208: PU5.7 195.42,65.64 v1(194.73,66.33)
  TOP w0.381: PR85.2 194.32,66.74 v1(194.73,66.33)
  BOTTOM w0.208: v1(194.73,66.33) 194.58,66.33 PR199.1
N7170033: length 4.8
  TOP w0.14: v1(207.35,62.47) 207.2,62.32 PD7.3
  TOP w0.381: PC61.1 204.99,62.49 206.33,61.15 PD7.3
N7170041: length 5
  TOP w0.14: v1(206.08,64.63) PC61.2
  TOP w0.381: PC61.2 PC60.2 203.64,65.36 PR86.2
N7170053: length 4.6
  TOP w0.14: PC71.2 205.95,57.9 v1(206.08,57.77)
  TOP w0.381: PC71.2 PD6.1 206.1,59.6 PD7.2
N7170185: length 2.9
  TOP w0.14: PC60.1 202.83,63.15 v1(202.65,62.98)
  TOP w0.381: PD6.3 203.64,62.24 PC60.1
N7170201: length 2.7
  TOP w0.14: v1(207.27,54.77) PC76.1
  TOP w0.762: PC76.1 206.21,56.32 PR106.2
N7170291: length 1.6
  TOP w0.14: 202.32,64.09 v1(201.18,62.95)
N7226956: length 9.6
  TOP w0.254: v1(60.33,70.27) 60.33,70.34 59.96,70.71 PQ15.3
  IN1 w0.254: v1(60.33,70.27) 58.81,70.27 58.17,70.9 55.58,70.9 v1(54.6,69.93)
  BOTTOM w0.254: PR184.1 53.55,70.64 53.55,70.09 v1(53.83,69.81) 54.49,69.81 v1(54.6,69.93)
N7226960: length 3.3
  TOP w0.14: v1(62.19,76.31) 61.5,75.62 PR64.1
  TOP w0.381: PR64.1 61.5,74.66 60.98,74.14 PQ15.2
N7318719: length 17.8
  TOP w0.254: PQ42.2 74.76,77.07 73.87,77.96 PQ14.3 71.84,78.72 72.47,79.35 PR52.2 PR51.1 71.01,80.06 69.94,81.13 v1(69.71,81.13)
  BOTTOM w0.254: PQ43.2 71.84,76.95 69.97,76.95 69.15,77.77 69.15,80.56 v1(69.71,81.13)
N7318835: length 8.1
  TOP w0.254: PC39.2 68.22,78.66 68.54,78.34 68.54,76.95 68.19,76.95 PR60.2 PR67.1 68.96,75.38 v3(69.05,75.29) 69.55,75.29 69.77,75.08 70.7,75.08 70.82,75.2 PQ14.2
N7318863: length 4
  BOTTOM w0.14: v1(72.22,80.63) 71.59,80.63 PR162.2
  BOTTOM w0.508: PR162.2 70.82,79.74 71.84,78.72 PQ43.3
N7320221: length 4.4
  TOP w0.14: PQ28.3 139.33,42.99 v1(139.66,42.66)
  TOP w0.381: PQ28.3 PR123.2
N16379436: length 9.4
  TOP w0.14: CN2.13 82.89,164.19 84.92,164.19 85.43,163.69 85.43,162.67 v3(84.54,161.78) 83.65,160.89 C44.1
N16382763: length 4.8
  TOP w0.14: CN2.14 82.71,161.82 v3(82.62,161.74) 82.36,161.48 82.36,159.32 82.51,159.17 C43.1
N16778199: length 2.4
  TOP w0.14: PR105.2 v3(178.72,57.01)
  TOP w0.762: PC66.1 178.7,58.05 PR105.2
N16780395: length 1
  TOP w0.14: v1(192.62,53.07) 192.62,53.98 PR108.2
N16789555: length 2.9
  BOTTOM w0.14: PR216.2 134.68,43.02 v3(134.68,43.44)
  BOTTOM w0.254: PU10.13 133.76,42.79 PR216.2
N16789557: length 2.2
  BOTTOM w0.14: PC150.2 135.58,40.21 v3(135.8,39.99)
  BOTTOM w0.254: 136.6,41.12 PC150.2
N16789582: length 5.5
  TOP w0.254: PR116.1 134.16,48.73 v1(134.46,48.42)
  BOTTOM w0.14: v1(133.69,50.78) 133.69,49.5 PC142.2
  BOTTOM w0.254: PC142.2 134.46,48.73 v1(134.46,48.42) 134.44,48.4 133.84,48.4 133.26,47.81 PU10.7
N16789596: length 3.4
  BOTTOM w0.14: PC150.1 134.11,40.74 134.51,40.34 v1(134.51,40.01)
  BOTTOM w0.254: PR216.1 135.58,42.26 134.44,41.12 PC150.1
N16789602: length 3.9
  BOTTOM w0.254: PC143.1 136.54,48.17 v1(136.1,47.74) 135.98,47.61 135.98,46.85 135.48,46.35 PU10.9
N16789606: length 3
  BOTTOM w0.254: PR215.1 135.34,48.29 v1(134.83,47.77) 134.79,47.74 133.94,47.74 133.76,47.55 PU10.8
N16789612: length 2.5
  TOP w0.14: PC81.1 v1(132.04,48.99)
  TOP w0.381: PC81.1 133.11,48.99 133.91,49.79 PR116.2
N16789664: length 5.8
  TOP w0.254: PC85.2 130.64,42.02 v1(130.51,41.89)
  BOTTOM w0.254: v1(130.51,41.89) 131.45,41.89 PR218.1 131.49,41.92 131.89,42.33 131.89,42.44 132.76,43.3 PU10.15
N16824426: length 5.1
  TOP w0.14: v1(44.79,105.01) 43.51,105.01 R201.2 R199.2 42.62,105.27 U21.2
N16824795: length 5.2
  TOP w0.14: v1(29.93,62.82) 30.11,62.65 v1(30.62,62.65)
  TOP w0.305: v1(30.62,62.65) 30.69,62.72 PC62.1 31.21,62.03 31.2,62.02 PR96.1
  BOTTOM w0.305: PJ2.4 29.79,61.82 v1(30.62,62.65)
N16824800: length 3.8
  TOP w0.14: v1(29.8,60.56) 30.18,60.19 v1(30.44,60.19)
  TOP w0.305: PR98.1 v1(30.44,60.19)
  BOTTOM w0.305: PJ2.5 30.07,59.82 v1(30.44,60.19)
N16857822: length 4.2
  TOP w0.305: PR100.2 v1(35.14,61.45) 35.14,61.72 36.14,62.72 PQ20.3
N16870904: length 4.2
  TOP w0.14: v1(58.25,58.61) 58.58,58.94 PR102.1
  TOP w0.254: PQ21.3 60.07,61.49 58.58,60.01 PR102.1
N16876480: length 1.1
  TOP w0.14: v1(188.43,74.91) 188.48,74.96 PC42.1
N16876574: length 2.4
  TOP w0.14: PR53.2 v1(173.74,80.17)
  TOP w0.762: PC37.1 174.84,80.27 PR53.2
N16928869: length 34
  TOP w0.254: PR55.1 47.16,78 46.63,78.53 PQ13.2 PQ13.5 42.96,78.53 42.82,78.67 42.82,79.27 v1(43.37,79.82) 43.9,80.35 v1(44.15,80.35)
  IN1 w0.254: v1(57.34,66.94) 57.34,67.37 56.97,67.74 53.81,67.74 53.36,67.29 51.52,67.29 50.82,67.99 50.82,68.73 49.13,70.42 48.65,70.42 47.04,72.03 47.04,73.02 45.93,74.13 43.67,74.13 43.01,74.79 43.01,79.41 43.95,80.35 v1(44.15,80.35)
  BOTTOM w0.254: PU9.5 57.11,66.12 57.41,66.42 57.41,66.86 v1(57.34,66.94)
N16928948: length 5.3
  TOP w0.14: PQ13.6 43.06,77.88 42.88,77.71 42.88,77.45 43.01,77.33 43.65,77.33 43.89,77.08 PR58.2 43.89,76.72 v1(44.69,75.93) 44.92,75.93 45.45,76.47 PR59.1
N16929910: length 3.8
  BOTTOM w0.14: v1(165.69,109.2) 165.44,109.46 PR160.2
  BOTTOM w0.508: PQ33.3 164.43,108.32 PR160.2
N16930588: length 6.5
  TOP w0.14: PR36.1 PC20.2 26.63,106.92 26.88,107.17 PQ7.2 ; PR36.1 PR37.2 ; PR36.1 28.53,105.78 28.53,105.39 28.15,105.01 v1(28.15,104.63)
N16965635: length 13.3
  TOP w0.14: PQ1.2 10.45,143.19 9.55,142.29 9.55,139.37 11.65,137.26 v1(13.67,137.26) PR27.1 PC13.2 PR28.2
N16965655: length 3.7
  TOP w0.14: PQ2.3 17.61,141.46 PR23.2 18.62,142.74 v1(18.5,142.86)
N16965660: length 11.3
  TOP w0.14: PQ6.2 PQ7.3 29.68,110.09 30.46,109.31 PQ8.2 30.46,106.52 PR38.1 PR39.2 31.2,105.91 31.2,105.29 v1(31.89,104.61)
N16965669: length 5.9
  TOP w0.14: PQ8.3 32.72,110.09 33.23,109.58 33.23,108.57 v1(33.74,108.06) 33.23,107.55 PR40.2
N16991480: length 4.7
  TOP w0.381: v1(50,65.26) 50,64.37 50.47,63.89 PD5.1
  BOTTOM w0.381: PR201.1 PC125.2 50.09,65.17 v1(50,65.26)
N17028529: length 31.7
  TOP w0.381: PD1.1 v3(42.48,84.11) 42.48,83.93 PR48.2 44,83.14 v1(44.03,83.17)
  IN1 w0.381: v1(45.28,74.86) 46.11,74.86 47.47,73.5 47.47,73.5 47.71,73.26 47.71,72.27 48.66,71.32 49.27,71.32 50.12,70.47 53.17,70.47 54.36,69.28 55.56,69.28 55.99,69.71 55.99,70.11 56.35,70.47 57.36,70.47 58.1,69.73 v1(59.14,69.73)
  IN2 w0.381: v1(44.03,83.17) 44.15,83.17 45.59,81.73 45.59,75.17 v1(45.28,74.86)
  BOTTOM w0.381: PR189.1 59.46,69.41 v1(59.14,69.73)
N17036761: length 11.4
  TOP w0.381: PR48.1 43.45,81.67 43.98,82.2 v1(44.17,82.2) 44.49,82.2 v3(44.94,81.75) ; v1(45.04,75.42) 45.04,75.42 46.01,75.42 PR73.1
  IN2 w0.381: v1(44.17,82.2) 44.33,82.2 45.04,81.48 v1(45.04,75.42)
N17045614: length 2.1
  BOTTOM w0.254: PU9.8 58.17,64.39 v1(58.45,64.68) 59.25,64.68 PR200.2
N17046311: length 2.2
  BOTTOM w0.254: PU9.9 58.02,63.89 v1(58.51,63.41) 58.85,63.41 59.01,63.57 PR202.2
N17177387: length 3.6
  BOTTOM w0.14: PU9.13 55.74,62.14 56.43,61.45 57.34,61.45 57.46,61.32 57.46,61.02 57.29,60.85 PR206.2
N17177693: length 3.4
  BOTTOM w0.14: PR205.2 57.84,60.86 57.72,60.99 57.72,61.48 57.44,61.76 56.56,61.76 56.24,62.08 PU9.12
N19138106: length 30.4
  TOP w0.102: v1(49.18,137.84) 49.42,137.84 49.79,138.22 50.83,138.22 51.14,137.91
  TOP w0.14: 51.14,137.91 51.39,137.65 51.99,137.65 52.86,136.78 52.86,134.37 53.67,133.57 53.67,132.04 54.46,131.25 54.46,128.94 54.16,128.64 54.16,126.85 56.44,124.57 56.44,119.78 56.83,119.39 56.83,116.85 v1(57.49,116.19) 57.81,115.87 58.96,115.87 R174.2
  BOTTOM w0.102: U43.F22 49.6,137.42 v1(49.18,137.84)
N19138109: length 30.8
  TOP w0.102: v1(47.51,137.82) 47.95,137.38 51.89,137.38
  TOP w0.14: R173.2 58.06,115.63 57.43,115.63 56.4,116.66 v1(56.4,117.2) 56.57,117.38 56.57,119.19 56.2,119.56 56.2,124.47 53.91,126.75 53.91,128.74 54.22,129.04 54.22,131.15 53.43,131.94 53.43,133.47 52.62,134.27 52.62,136.65 51.89,137.38
  BOTTOM w0.102: v1(47.51,137.82) 47.22,137.52 U43.J22
N21262847: length 13.5
  BOTTOM w0.102: 45.27,119.11 45.93,119.77 45.93,121.9 46.06,122.03 46.44,122.03 46.77,122.36 46.77,122.6 47.04,122.87 48.93,122.87 49.23,123.17 49.23,123.8 U43.F6
  BOTTOM w0.14: 45.27,119.11 44.4,118.23 43.91,118.23 42.78,117.1 v1(42.78,116.87) 42.78,116.62 42.25,116.09 R604.2
N21263014: length 2.7
  TOP w0.14: TP13.1 50.19,127.75 v1(50.08,127.86)
  BOTTOM w0.102: U43.E10 v1(50.08,127.86)
N21263017: length 1.8
  TOP w0.14: v1(49.26,127.04) 50.08,126.22 TP18.1
  BOTTOM w0.102: U43.F10 v1(49.26,127.04)
N21996152: length 12.5
  TOP w0.14: v1(42.76,108.06) 42.88,107.93 v1(43.65,107.93) 43.93,107.93 44.8,108.81 R183.2 ; v1(42.25,101.71) 41.74,101.2 41.11,101.2 40.63,101.68 U22.4
  BOTTOM w0.14: v1(42.76,108.06) 41.49,106.79 41.49,104.76 41.74,104.5 41.74,102.6 42.25,102.09 v1(42.25,101.71)
N47973729: length 17.2
  BOTTOM w0.14: PR156.2 PC102.2 86.5,113.98 v3(88.1,113.98) 91.73,113.98 92.03,114.28 92.03,115.34 91.92,115.45 91.92,120.65 PR152.1 90.53,120.76 89.61,119.83 PU8.8
N47973733: length 5.7
  BOTTOM w0.14: PQ36.1 98.38,101.2 97.52,100.34 PD8.1 v3(98.81,99.68) PR161.1
N47973739: length 31.1
  BOTTOM w0.14: PQ36.3 98.38,104.38 97.11,103.11 97.11,101.84 96.61,101.33 95.21,101.33 94.95,101.58 94.95,103.11 95.42,103.57 95.42,105.18 95.06,105.54 94.21,105.54 v3(92.29,103.62) 90.45,101.78 88.53,101.78 88.22,102.09 88.22,107.46 84.82,110.87 PR156.1
N47973743: length 6.4
  BOTTOM w0.14: PQ37.3 101.99,103.59 101.61,103.21 101.02,103.21 100.42,102.6 PQ36.2 v3(100.42,100.82) 100.92,100.82 101.66,100.09 PR161.2
N47973784: length 22.6
  BOTTOM w0.14: PU8.1 95.07,120.39 94.7,120.76 PR152.2 93.28,119.72 92.16,118.6 92.16,115.55 92.29,115.43 92.29,114.03 v3(92.41,113.9) 93.68,112.63 PC103.2 93.28,111.59 93.16,111.47 93.16,109.18 89.37,105.39 PQ34.2
N47973813: length 8.7
  BOTTOM w0.254: PR157.1 95.76,109.79 95.79,109.79 v1(96.07,109.51) 95.84,109.28 95.84,105.01 95.72,104.89 PQ35.3
N57484549: length 6.6
  TOP w0.191: PU1.3 145.24,150.87 144.9,151.2 v1(144.85,151.2)
  BOTTOM w0.14: v1(144.85,151.2) 145.2,151.55 145.2,152.79 144.26,153.73 144.26,154.03 v3(143.98,154.31) 143.62,154.67 PR130.2
N58590962: length 2.3
  BOTTOM w0.14: PC93.2 141.49,152.74 v1(141.69,152.94)
  BOTTOM w0.508: PR134.1 PC93.2
N58590994: length 4.7
  TOP w0.14: v1(131.58,147.68) 131.96,147.3 v1(131.96,147.15) 131.68,146.87 PR13.1
  BOTTOM w0.14: v1(131.96,147.15) 131.96,146.21 131.65,145.9 PL1.4
N58590998: length 5.4
  TOP w0.14: v1(132.55,148.52) 132.62,148.45 v1(132.62,147.15) 132.85,146.92 132.85,146.53 PR12.1
  BOTTOM w0.14: v1(132.62,147.15) 132.62,146.08 132.8,145.9 PL1.3
N58591014: length 2.4
  BOTTOM w0.14: v1(133.31,139.81) 132.8,140.32 PR151.2 PR150.2
N58591351: length 2.6
  TOP w0.762: PC8.1 136.25,149.13 136.23,149.11 PR10.2 134.86,149.11 v3(134.53,149.44)
N99212489: length 1.4
  TOP w0.14: TP80.1 125.96,111.24 v1(125.61,110.88)
  BOTTOM w0.102: U45.AP32 125.93,111.21 v1(125.61,110.88)
N100073348: length 5.8
  TOP w0.14: v1(200.11,90.66) 199.73,90.66 199.46,90.93 Q21.1 198.81,92.45 R259.1 ; R246.2 R259.1 ; R259.1 R258.1
N100359802: length 2.1
  TOP w0.14: U25.4 226.5,70.43 226.53,70.47 R318.1 226.53,71.86 v1(226.53,71.87)
N100359806: length 3.8
  TOP w0.14: U25.8 224.13,68.32 223.86,68.06 R326.1 R328.1 v1(223.86,67.04)
N100631500: length 15.5
  TOP w0.14: U23.2 99.02,92.95 98.51,93.45 98.51,94.68 101.33,97.5 v1(101.33,104.5)
  BOTTOM w0.14: R649.1 101.68,104.85 v1(101.33,104.5)
N100631544: length 63
  TOP w0.508: v1(90.79,90.41) 90.79,89.16 89.62,87.99 Q25.1
  IN1 w0.508: v1(94.7,75.68) 95.13,75.68 98.13,72.68 133.41,72.68 v1(133.61,72.88)
  IN2 w0.508: v1(90.79,90.41) 92.92,88.27 92.92,77.45 v1(94.7,75.68)
  BOTTOM w0.508: R710.1 133.99,72.5 v1(133.61,72.88) 133.23,72.5 R709.1
N101127130: length 5.9
  TOP w0.14: R277.1 148.81,87.73 149.16,87.39 C307.2 R278.1 ; R277.1 v1(148.17,86.72) ; R277.1 147.79,87.73 147.03,86.98 Q23.2
N101127328: length 4.8
  TOP w0.14: v1(153.07,85.45) 153.07,86.78 152.74,87.11 Q24.3 152.23,87.99 151.37,88.86 R278.2
N101265975: length 6.4
  TOP w0.14: v1(100.06,132.27) 99.78,132.55 97.05,132.55 96.48,131.98 Q9.2 96.48,130.92 95.85,130.29 R95.2
N101265981: length 2.8
  TOP w0.14: v1(94.12,129.65) 94.24,129.78 R95.1 95.07,130.29 94.7,130.67 Q8.1
N101538019: length 53.5
  TOP w0.14: v1(90.13,124.7) 90.64,125.21 90.76,125.21 91.14,125.58 U17.10 ; v1(90.13,124.7) 90.13,124.06 90.51,123.68 91.53,123.68 91.92,124.08 U17.13 ; v1(90.13,124.7) 89.35,124.7 88.58,123.93 88.58,122.92 88.86,122.64 94.34,122.64 94.56,122.86 U17.1 94.93,123.35 95.36,122.92 95.71,122.92 96.24,123.45 96.24,123.82 96.82,124.4 96.82,124.79 96.53,125.08 U17.4 ; U15.4 82.11,129.73 v1(81.93,129.91) 81.37,130.47 v1(81.37,131.81) 81.37,132.7 81.62,132.95 R90.2
  IN2 w0.114: v1(90.13,124.7) 90.81,124.7 94.57,128.46 94.57,133.05 v1(95.84,134.32)
  IN3 w0.089: v1(95.84,134.32) 91.63,134.32 86.7,129.4 82.44,129.4 v1(81.93,129.91)
N101575958: length 2.9
  BOTTOM w0.14: CN14.2 151.78,61.38 v1(151.98,61.58) 152.43,62.04 152.43,62.69 R736.1
N101575960: length 2.8
  BOTTOM w0.14: R735.1 151.08,62.7 151.29,62.48 151.29,62.01 150.78,61.5 CN14.4
N101575962: length 3.2
  BOTTOM w0.14: CN14.6 149.78,61.45 ; 149.78,61.45 149.82,61.49 149.82,62.16 149.08,62.9 R733.1 ; 149.78,61.45 v1(149.78,61.5)
N101575964: length 3.2
  BOTTOM w0.14: R730.1 147.78,62.48 148.42,61.83 v1(148.42,61.58) 148.28,61.44 CN14.9
N101575966: length 3.1
  BOTTOM w0.14: CN14.11 v1(147.28,62.24) 147.28,62.76 R729.1
N101575968: length 3.1
  BOTTOM w0.14: CN14.13 146.28,61.09 146.01,61.36 v1(146.01,61.96) 146.01,62.34 145.74,62.6 R728.1
N101575970: length 3.6
  BOTTOM w0.14: R727.1 144.1,62.78 v1(144.1,62.47) 144.1,62.2 145.28,61.03 CN14.15
N101575974: length 2.7
  BOTTOM w0.14: R734.1 149.81,62.73 150.28,62.26 CN14.5
N101626067: length 2.5
  BOTTOM w0.14: v1(184.99,79.99) R705.2 183.6,80.88 Q40.2
N101626411: length 5.5
  BOTTOM w0.14: v3(12.05,155.94) 12.66,156.55 Q35.2 12.66,160 12.02,160.64 R446.2
N101844959: length 3.6
  TOP w0.14: v1(42.24,103.76) 42.63,103.37 R216.1 R217.1
  BOTTOM w0.14: v1(42.24,103.76) 43.28,103.76 43.46,103.94 U46.3
N102027952: length 3.4
  TOP w0.14: v1(93.32,90.42) R268.2
  TOP w0.508: R279.1 94.03,88.63 94.37,88.98 C304.2 94.37,89.65 94.25,89.76 R268.2
N102027954: length 2.4
  TOP w0.14: C304.1 v1(96.12,89.26)
  TOP w0.508: C304.1 95.15,89.59 95.65,90.09 R272.2
N102030206: length 3.3
  TOP w0.14: v3(53.93,60.18) 53.93,60.08 54.95,59.06 R357.2
  TOP w0.508: C419.1 R357.2
N102030208: length 3.7
  TOP w0.14: R363.1 v3(57.51,55.36)
  TOP w0.508: R363.1 R358.1 56.85,57.77 56.85,57.76 C419.2
N102031602: length 2.8
  TOP w0.14: R304.2 63.9,73.12 v3(64.88,74.1)
  TOP w0.508: C368.1 R304.2
N102031606: length 4
  TOP w0.508: C368.2 63.83,71.03 62.59,71.03 R305.2 62.16,71 v1(61.43,70.27) 61.98,69.71 R322.1
N102339557: length 4.2
  BOTTOM w0.14: R766.2 R770.2 v1(111.59,46.08) U55.7
N102398732: length 114.8
  TOP w0.14: U24.37 213.98,80.81 213.27,80.1 v1(213.27,79.94) 212.43,79.1 212.43,76.54 211.49,75.6 v1(210.67,75.6)
  IN2 w0.114: v1(210.67,75.6) 210.31,75.96 210.31,79.32 207.98,81.65 207.98,81.92 205.72,84.18 201.91,84.18 197.56,88.54 167.81,88.54 164.85,85.58 164.85,76.36 163.92,75.42 162.14,75.42 158.34,71.62 158.34,69.16 156.58,67.4 156.58,66.48 155.79,65.69 155.79,63.43 154.86,62.51 154.86,61.36 v1(154.39,60.89)
  BOTTOM w0.14: v1(154.39,60.89) 154.39,60.74 152.49,58.83 150.76,58.83 149.93,58 143.87,58 143.43,58.45 140.63,58.45 138.91,60.17 138.91,61.05 R740.1 R732.1 R724.1
N102398784: length 3.2
  TOP w0.102: 213.06,91.9 213.98,90.98 U24.12
  TOP w0.14: 213.06,91.9 v1(213.06,91.93) 212.66,92.34 R253.2
N102398859:
  vias: v1(217.76,68.56)
N102401187: length 5.8
  TOP w0.14: v1(240.47,45.96) C490.2 240.27,44.94 239.12,43.8 v1(239.12,43.67) ; v1(239.12,42.2) 238.97,42.05 238.59,42.05 238.46,41.92 U34.35
  IN2 w0.114: v1(239.12,42.2) v1(239.12,43.67)
N102401192: length 4.2
  TOP w0.14: v1(241.39,41.49) 240.98,41.89 240.65,41.89 C496.1
  TOP w0.203: U34.34 238.46,41.52 238.54,41.59 239.1,41.59
  TOP w0.381: 239.1,41.59 239.33,41.59 C496.1
N102401200: length 3.5
  TOP w0.14: C490.1 239,44.21 238.41,43.62 v1(238.34,43.62) 237.96,43.62 237.78,43.8 237.22,43.8 236.98,43.56 U34.37
N102401219: length 3.4
  TOP w0.14: C504.1 239.99,37.19 v1(239.61,37.58) 239.61,37.83 238.72,38.72 U34.27
N102401227: length 9.4
  TOP w0.14: U34.28 238.7,39.12 239.23,38.59 C500.1 240.23,38.71 240.62,39.1 241.66,39.1 C501.1 242.3,38.29 C505.1 242.66,36.66 v1(242.66,34.91)
N102401293: length 6.7
  TOP w0.14: v1(226.12,40.12) 226.12,40.42 226.83,41.13 C497.1 227.9,40.5 229.57,40.5 229.81,40.26 230.43,40.26 230.77,39.92 U34.7
N102401296: length 2.8
  TOP w0.14: U34.15 233.38,35.9 233.69,35.59 233.69,35.42 v1(233.69,35.42) 233.51,35.24 R411.1
N102401352: length 3.8
  TOP w0.203: 236.81,44.94 236.18,44.31 U34.39
  TOP w0.381: 236.81,44.94 v1(237.19,45.32) 237.73,45.86 C486.1
N102411350:
  vias: v1(74.25,156.07)
N102411428: length 2.8
  BOTTOM w0.14: D28.1 88.1,152.54 87.8,152.25 R474.2 v3(87.33,151.22)
N102411440: length 3.3
  TOP w0.14: v3(90.33,152.87) 90.01,152.54 D2.1 88.13,152.54 87.83,152.25 R50.2
N102412865: length 5
  TOP w0.14: v1(93.42,49.38) R389.2 92.4,49.38 91.62,50.16 R388.2 90.62,49.38 R387.1 R386.1
N102412910: length 7.1
  TOP w0.14: Q32.2 71.59,47.23 71.08,46.72 70.06,46.72 69.8,46.98 R394.2 68.97,47.23 v1(68.84,47.35) 68.84,47.53 69,47.69 69.38,47.69 69.55,47.86 69.55,48.37 70.29,49.11 Q31.3
N102456718: length 4.9
  TOP w0.14: v1(34.88,78.34) 34.25,78.98 v1(33.74,78.98) R289.2
  BOTTOM w0.14: v1(34.88,78.34) 34.89,78.34 CN11.9
N102475350: length 7.3
  TOP w0.14: R294.2 214.33,76.15 Q27.3 212.33,73.03 212.05,72.75 R308.2 R309.2 213.94,72.13 v1(214.21,71.87)
N102714628: length 12.7
  TOP w0.508: R31.2 10.43,156.89 v1(10.43,158.02) 10.43,158.66 11.54,159.78 11.54,162.57 11.31,162.8 11.31,166.08 10.78,166.61 9.64,166.61 9.35,166.89 LED1.3
N102714638: length 12
  TOP w0.508: LED1.4 10.74,167.51 11.92,166.33 11.92,163.15 12.18,162.9 12.18,159.39 v1(11.52,158.73) R32.2
N102714670: length 4.8
  TOP w0.14: v1(22.82,165.72) v1(22.82,166.35)
  TOP w0.508: LED2.3 23.97,167.51 v1(22.82,166.35)
  BOTTOM w0.508: R432.2 v1(22.82,166.35)
N102714672: length 5.3
  TOP w0.508: LED2.4 26.75,166.86 26.5,166.61 24.09,166.61 v1(23.83,166.35)
  BOTTOM w0.14: R433.2 v1(24.71,165.73)
  BOTTOM w0.508: v1(23.83,166.35) R433.2
N102802469: length 1.9
  TOP w0.14: R348.1 136.13,60.18 135.11,61.2 C409.2
N102803185: length 3.1
  TOP w0.14: R317.2 154.21,70.11 154.39,69.94 v1(154.39,69.58) 154.39,69.53 153.84,68.98 U32.98
N102803215: length 3
  TOP w0.14: U32.99 153.44,69.26 v1(153.12,69.58) 153.12,70.09 152.99,70.21 R316.1
N102803358: length 3.2
  TOP w0.14: U32.12 138.59,61.73 v1(138.21,61.35) 137.41,61.35 C410.1
N103095748:
  vias: v1(144.26,157.07) v1(144.87,164.83) v1(144.87,163.94) v1(144.99,157.08) v1(145.63,163.05) v1(145.63,161.65) v1(145.63,160.13) v1(145.63,158.61) v3(145.65,165.08)
N103354651: length 5.8
  TOP w0.14: v1(214.2,61.58) R338.2 C405.2 214.2,64.24 214.59,64.63 Q28.2 212.95,65.52 R330.1
N103544523: length 3.6
  TOP w0.14: v1(243.8,48.37) R390.2
  TOP w0.508: R390.2 243.79,49.39 R391.2 242.66,49.89 242.46,50.1 U33.5
N103592822: length 2.8
  TOP w0.14: TP76.1 143.85,114.54 143.62,114.54 v1(143.17,114.99)
  BOTTOM w0.076: v1(143.17,114.99) 142.87,115.29 U45.AG4
N103592936: length 16.2
  IN2 w0.114: v1(151.09,101.93) 151.09,102.05 150.72,102.42 148.15,102.42 147.5,103.07 146.85,103.07 v1(146.29,103.64)
  BOTTOM w0.14: v1(151.09,101.93) 151.43,101.58 151.98,101.58 152.99,100.57 R673.2 153.87,101.08 156.17,101.08 156.55,101.46 156.55,101.58 v1(157.06,102.09) 157.18,102.22 157.68,102.22 R656.2 R653.1 ; R661.1 146.01,103.39 146.26,103.64 v1(146.29,103.64)
N104221226: length 6.7
  BOTTOM w0.14: CN7.28 58.55,103.84 58.44,103.73 57.81,103.73 56.93,102.85 55.71,102.85 v1(55.08,102.22) 54.81,102.22 R670.1
N104265063: length 2.6
  TOP w0.305: v1(214.54,80.12) 214.98,80.56 U24.39
  TOP w0.508: v1(214.54,80.12) 214.54,79.79 214.21,79.46 R292.1
N104772550: length 9.7
  TOP w0.14: Q33.3 150.43,42.4 151.09,43.06 Q34.2 154.54,43.06 155.15,43.67 C492.1 155.4,43.44 155.8,43.04 156.55,43.04 156.69,43.17 R399.1 158.06,43.17 v1(158.33,42.91)
N104772583: length 3.9
  TOP w0.14: v1(145.89,41.26) R401.1 C493.1 147.66,43.42
N105679711: length 3.6
  TOP w0.14: v1(240.12,41.49) 240.36,41.24 R403.1 240,40.27 238.51,40.27 238.46,40.32 U34.31
N105679807: length 2.6
  TOP w0.14: R406.1 239.53,39.61 v1(239.35,39.79) 239.22,39.92 U34.30
N107600611: length 20.4
  IN2 w0.508: v1(110.06,156.82) 108.79,156.82 107.65,155.69 103.59,155.69 101.69,157.59 100.54,157.59 v1(100.03,157.08)
  BOTTOM w0.203: U40.13 107.44,154.46 108.04,155.05 108.04,155.56 ; U40.48 100.37,154.46 100.29,154.54 100.29,154.92 100.03,155.18
  BOTTOM w0.508: 108.04,155.56 108.04,156.07 108.42,156.45 C564.2 L25.2 v1(110.06,156.82) ; 100.03,155.18 99.41,155.8 C567.1 C565.2 v1(100.03,157.08)
N107600701: length 2.2
  BOTTOM w0.203: U40.35 102.17,148.55 101.69,148.07 ; U40.36 101.77,148.53 101.56,148.32
  vias: v1(100.67,147.94)
N107600890: length 2.9
  BOTTOM w0.14: U40.23 107.8,150.46 108.42,149.84 v1(108.54,149.84) 109.3,149.84 R488.2
N107600892: length 2.8
  BOTTOM w0.14: U40.21 v1(108.54,151.26) 109.19,150.61 R483.2
N107600911: length 4.8
  BOTTOM w0.14: TP104.1 96.86,151.11 99.15,151.11 99.69,151.66 U40.41
N107600921: length 5
  BOTTOM w0.14: U40.47 100.38,154.06 98.88,155.56 TP103.1
N107600925: length 3.4
  BOTTOM w0.14: U40.37 100.25,150.06 100.03,149.84 100.03,149.34 v1(99.65,148.95) 98.77,148.95 R489.2
N107600984: length 3.4
  BOTTOM w0.127: v1(99.4,153.27) 99.03,153.27 R475.2
  BOTTOM w0.14: v1(99.4,153.27) 99.4,152.71 99.65,152.46 U40.43
N107600986: length 2.7
  BOTTOM w0.127: R481.2 99.02,151.62 v1(99.4,152)
  BOTTOM w0.14: U40.42 99.45,152.06 v1(99.4,152)
N107673215: length 3
  BOTTOM w0.14: CN12.8 218.72,74.46 TP151.1
N107719715: length 2.9
  BOTTOM w0.14: U54.7 216.57,52.39 R759.2 216.23,52.05 v1(215.35,52.05)
N107748212: length 3.3
  BOTTOM w0.14: R775.1 171.6,44.05 v1(170.86,44.79) 170.08,44.01 U56.6
N107748371: length 7.3
  BOTTOM w0.14: C770.1 171.08,46.08 v1(170.9,46.26)
  BOTTOM w0.406: U56.5 169.99,44.66 170.27,44.94 170.27,45.07 170.65,45.45 170.9,45.45
  BOTTOM w0.508: 170.9,45.45 171.53,45.45 C775.2 C770.1 R767.2 R765.2
N107748376: length 4.1
  BOTTOM w0.14: U56.9 170.73,42.06 v1(170.9,41.89) 171.79,41 R781.2 R784.2
N107748380: length 3.9
  BOTTOM w0.14: U56.7 170.74,43.36 v1(170.9,43.52) 171.42,43.52 R778.2 R780.1
N107748411: length 3.7
  BOTTOM w0.14: v1(160.21,47.74) 160.75,47.19 R769.2 161.63,46.72 161.74,46.61 U56.27
N107748554: length 4.6
  BOTTOM w0.14: U56.15 163.06,38.72 R787.1 160.24,39.23 159.72,39.23 159.42,38.92 v1(158.96,38.92)
N107786893: length 2.6
  BOTTOM w0.14: TP154.1 162.48,47.26 U56.28
N107797019: length 8.1
  BOTTOM w0.076: 113.05,133.89 113.05,132.25 114.51,130.79 114.51,129.5 115.07,128.95 U45.C49
  BOTTOM w0.14: TP109.1 113.05,134.54 113.05,133.89
N107797035: length 7.3
  BOTTOM w0.076: U45.B50 114.26,129.34 114.26,130.67 112.73,132.19 112.73,135.11
  BOTTOM w0.14: 112.73,135.11 TP108.1
N107797045: length 4.8
  BOTTOM w0.076: TP114.1 111.15,134.16 111.15,132.38 112.48,131.05 112.48,130.15 U45.A53
N107797061: length 6
  BOTTOM w0.076: TP113.1 110.96,133.33 110.96,132.32 112.26,131.01 112.26,129.72 U45.B53
N108089770: length 0.7
  BOTTOM w0.076: U45.C17 135.13,128.67 U45.D17
N108089885: length 5.9
  TOP w0.14: TP4.1 137.5,133.05 v1(137.37,133.18)
  BOTTOM w0.076: U45.C15 136.12,129.11 136.12,129.19 136,129.31 136,129.54 136.34,129.88 136.34,130.93 136.86,131.46 136.86,132.67 v1(137.37,133.18)
N108089886: length 3.2
  TOP w0.14: TP14.1 141.87,127.11 141.4,126.65 141.4,125.74 v1(140.86,125.21)
  BOTTOM w0.076: v1(140.86,125.21) 140.92,125.16 140.92,125.16 141.22,124.85 U45.J6
N108089887: length 4.9
  TOP w0.14: v1(140.86,125.86) 140.85,125.86 141.16,126.17 141.16,126.75 141.3,126.88 141.3,128.39 141.06,128.63 141.06,129.14 TP9.1
  BOTTOM w0.102: v1(140.86,125.86) 140.92,125.86 U45.H6
N108089888: length 4.2
  TOP w0.14: TP6.1 137.75,131.33 v1(137.52,131.56)
  BOTTOM w0.076: v1(137.52,131.56) 137.25,131.56 136.5,130.81 136.5,129.82 136.17,129.48 136.17,129.38 136.25,129.29 136.39,129.29 U45.B14
N108090887: length 6.1
  TOP w0.14: Q22.1 205.29,91.69 R267.1 R266.1 ; Q22.1 205.3,90.42 v1(205.44,90.28) ; Q22.1 205.3,92.45 205.13,92.62 204.5,92.62 204.05,93.07 R248.2
N108498600: length 3.2
  TOP w0.14: v1(148.41,142.35) PR22.2
  TOP w0.254: PR17.1 148.55,145.14 148.55,144.39 PR20.1 PR22.2
N108831390: length 7.5
  TOP w0.14: R189.1 R184.1 R181.2 R177.2 37.16,110.72 37.55,111.11 38.06,111.11 v1(38.44,111.49) 38.44,111.74 38.06,112.12 Q14.3
N108831783: length 10.6
  TOP w0.14: R167.1 34.38,115.68 v1(34.63,115.93) ; R167.1 32.84,116.46 R163.1 ; R167.1 33.62,115.18 Q13.3 33.49,113.27 34.12,113.27 34.69,112.7 R178.2 35.02,110.47 35.26,110.23 R180.1
N108845535: length 11.1
  TOP w0.14: R64.1 12.07,146.62 Q5.2 13.14,148.17 14.3,149.33 v1(15.96,149.33) C70.1 17.23,148.7 16.98,148.45 Q6.3
N108845564: length 5.3
  TOP w0.14: v1(18.5,144.13) 17.87,143.49 16.84,143.49 R71.1 C85.1 16.33,145.15 Q6.2
N109256954: length 2.8
  TOP w0.14: TP157.1 134.6,126.96 v1(135.09,126.48)
  BOTTOM w0.076: U45.G17 135.41,126.16 v1(135.09,126.48)
N109256956: length 3.6
  TOP w0.14: v1(126.27,130.82) TP158.1
  BOTTOM w0.076: v1(126.27,130.82) 126.18,130.73 126.18,130 126.24,129.88 126.24,129.66 126.21,129.57 126.18,129.51 126.18,129.38 126.21,129.27 126.42,129.07 126.6,129.07 126.77,128.9 U45.C30
