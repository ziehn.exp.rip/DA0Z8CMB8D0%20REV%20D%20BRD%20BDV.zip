# Allegro board DA0Z8CMB8D0-D-gina-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_CMD10: length 117.1
  TOP w0.102: U12.P3 51.03,158.04 v1(51.03,158.54) ; U11.P3 39.76,157.37 39.26,157.37 39.15,157.47 39.15,157.67 39.28,157.79 v1(39.39,157.79) ; 51.65,142.35 51.14,142.35 50.94,142.16 50.18,142.16 49.62,141.59 49.62,140.57 50.45,139.74 50.45,139.25 50.26,139.06 49.75,139.06 49.35,138.66 v1(49.19,138.66) ; U16.P3 69.13,128.49 69.35,128.71 69.95,128.71 v1(70.02,128.65) ; U13.P3 69.46,139.95 69.68,140.17 69.68,140.32 69.53,140.47 v1(69.32,140.47)
  TOP w0.178: R53.2 R42.1 68.96,154.13 v1(69.35,154.52) ; 51.65,142.35 54.62,142.35 57.57,145.29 57.57,145.98 60.58,148.99 v1(60.58,149.79)
  IN1 w0.14: v1(69.32,140.47) 70.34,139.96 70.76,139.54 70.76,139.03 71.11,138.68 71.11,137.4 70.54,136.53 70.54,134.52 v1(70.55,134.51) ; v1(69.35,154.52) 67.44,152.61 65.67,152.61 65.46,152.82 64.7,152.82 64.03,152.14 64.03,151.34 62.48,149.79 v1(60.58,149.79) ; v1(51.03,158.54) 51.2,158.54 51.34,158.68 51.34,158.84 51.17,159 50.82,159 50.43,158.61 45.78,158.61 45.43,158.97 45.29,158.97 v1(45.21,159.05)
  IN3 w0.102: v1(39.39,157.79) 39.74,158.14 39.74,158.81 39.96,159.04 42.66,159.04 43.06,158.63 43.8,158.63 44.2,159.04 45.2,159.04 v1(45.21,159.05) 49.54,160.11 49.67,160.24 49.67,160.61 49.91,160.85 51.34,160.85 52.54,160.43 53.56,159.41 54.64,159.41 54.77,159.34 54.95,159.16 55.63,158.38 55.84,158.18 56.84,156.11 58.56,153.07 58.56,152.51 59.27,151.49 60.16,150.33 v1(60.58,149.79) 62.19,149.51 64.01,149.06 66.25,148.25 66.78,148.01 66.85,147.97 69.95,146.31 70.49,145.39 70.61,144.88 70.69,144.69 70.75,144.43 70.76,142.54 70.72,140.6 70.72,140.27 71.13,139.5 71.27,139.14 71.46,138.28 71.46,137.69 71.29,137.28 70.97,136.54 70.55,135.54 70.54,135.5 70.54,134.52 v1(70.55,134.51) 70.55,134.31 70.09,133.85 70.09,129.96 70.21,129.83 70.21,129.7 70.11,129.6 70.11,129.47 70.24,129.35 70.56,129.35 70.68,129.22 70.68,129.14 70.59,129.04 70.21,129.04 70.09,128.92 70.09,128.72 v1(70.02,128.65)
  BOTTOM w0.102: U11.P3 39.76,157.37 39.26,157.37 39.15,157.47 39.15,157.67 39.27,157.79 v1(39.39,157.79) ; U12.P3 51.03,158.04 v1(51.03,158.54) ; v1(49.19,138.66) U43.G23 ; U16.P3 69.13,128.49 69.35,128.71 69.95,128.71 v1(70.02,128.65) ; U13.P3 69.46,139.95 69.68,140.17 69.68,140.32 69.53,140.47 v1(69.32,140.47)
FBA_CMD11: length 108.8
  TOP w0.102: v1(65.41,142.15) 65.54,142.03 65.54,141.21 65.13,140.81 U13.J3 ; U11.J3 38.9,153.4 38.49,153.81 37.72,153.81 v1(37.6,153.68) ; v1(49.21,139.48) 48.85,139.83 48.85,141.73 49.73,142.6 ; U16.J3 64.81,128.41 64.81,129.15 65.31,129.66 65.31,129.94 v1(65.47,130.09) ; v1(49.63,153.71) 50.13,153.71 50.73,153.1 51.37,153.1 U12.J3
  TOP w0.178: v1(57.09,147.43) 56.8,147.14 56.8,145.61 54.41,143.21 50.34,143.21 49.73,142.6
  IN1 w0.14: v1(49.63,153.71) 49.32,153.4 48.62,153.4 48.5,153.53 48.5,153.93 48.2,154.22 44.75,154.22 44.41,153.88 44.18,153.88 44.08,153.98 v1(44.08,154.19) ; v1(65.41,142.15) 65.57,142 65.57,141.33 65.52,141.28 65.52,140.12 65.97,139.67 65.97,135.87 v1(65.9,135.8) 65.9,135.68 65.44,135.22 65.44,135.03 66.01,134.47 66.01,131.47 65.19,130.65 65.19,130.3 65.39,130.09 v1(65.47,130.09) ; v1(60.59,158.08) 60.54,158.03 60.54,157.26 60.89,156.91 60.89,156.02 61.14,155.77 61.14,155.52 60.42,154.81 60.42,151.71 58.2,148.93 v1(57.09,147.43)
  IN3 w0.102: v1(65.9,135.8) 65.56,136.13 65.56,136.84 64.92,137.49 64.92,137.94 64.47,138.39 64.47,140.42 63.36,141.54 63.36,141.94 62.16,143.14 62.16,143.14 61.92,143.37 61.92,144.54 61.23,145.23 58.28,146.8 57.77,146.8 57.64,146.67 57.64,146.49 57.51,146.36 57.22,146.36 57.09,146.49 v1(57.09,147.43) 53.32,151.19 53.32,152.46 53.15,152.64 52.16,152.64 51.04,153.76 51.04,153.96 50.73,154.27 50.12,154.27 50,154.14 49.39,154.14 49.24,154.3 45.5,154.3 45.4,154.19 v1(44.08,154.19) 43.52,154.03 42.76,154.01 42.38,154.01 41.28,154.24 40.17,154.24 38.95,153.81 37.72,153.81 v1(37.6,153.68)
  BOTTOM w0.102: U43.G24 49.21,139.47 v1(49.21,139.48) ; 49.26,153.58 49.26,152.92 49.13,152.8 48.93,152.8 48.8,152.92 48.8,153.33 48.73,153.4 U39.J3 ; U41.J3 65.13,142.86 64.86,142.59 64.53,142.59 64.4,142.46 64.4,142.28 64.53,142.15 v1(65.41,142.15) ; U44.J3 65.13,131.08 64.96,130.9 64.64,130.9 64.53,130.79 64.53,130.63 64.64,130.52 65.34,130.52 65.47,130.39 v1(65.47,130.09) ; U38.J3 37.12,153.4 37.22,153.31 37.22,152.83 37.31,152.75 37.49,152.75 37.6,152.86 v1(37.6,153.68)
  BOTTOM w0.178: R458.1 R457.2 61.09,158.58 v1(60.59,158.08) ; 49.26,153.58 49.39,153.71 v1(49.63,153.71)
FBA_CMD12: length 121.4
  TOP w0.102: U16.T7 v1(72.7,131.58) ; U13.T7 v1(72.7,143.45) ; U12.T7 v1(48.17,160.97) ; U11.T7 v1(36.3,160.97)
  TOP w0.178: v1(65.92,153.25) 66.44,153.25 R41.1 R52.2
  IN1 w0.14: v1(72.7,143.45) 73.26,141.38 73.4,140.95 73.48,140.78 73.48,137.51 73.11,136.51 v1(73.11,135.86) ; v1(43.9,161.69) 44,161.79 44.16,161.79 44.33,161.61 44.56,161.61 44.69,161.74 44.88,161.74 45.01,161.61 45.2,161.61 45.49,161.9 45.64,161.9 45.73,161.81 45.73,161.52 45.83,161.41 46.01,161.41 46.11,161.52 46.11,162.04 46.21,162.14 46.39,162.14 46.49,162.04 46.49,161.52 46.59,161.41 46.77,161.41 46.87,161.52 46.87,162.04 46.97,162.14 47.17,162.14 47.27,162.04 47.27,161.45 47.9,160.82 48.02,160.82 v1(48.17,160.97) ; v1(62.32,152.17) 63.57,152.17 64.65,153.25 v1(65.92,153.25)
  IN3 w0.102: v1(72.7,131.58) 72.83,131.45 72.83,131.21 72.72,131.1 72.07,131.1 71.94,131.23 71.94,131.69 72.29,132.04 72.73,132.04 72.83,132.14 72.83,132.58 72.91,132.66 72.91,133.21 73.01,133.32 73.13,133.32 73.23,133.42 73.23,133.59 73.13,133.7 73.01,133.7 72.91,133.8 72.91,133.98 73.01,134.08 73.13,134.08 73.23,134.18 73.23,134.36 73.13,134.46 73.01,134.46 72.91,134.56 72.91,134.74 73.01,134.84 73.13,134.84 73.23,134.94 73.23,135.73 v1(73.11,135.86) 73.11,136.45 73.14,136.53 73.34,137.25 73.43,137.58 73.68,138.45 73.72,139.12 73.94,140.66 73.85,140.77 73.74,140.79 73.66,140.89 73.68,141.03 73.79,141.11 73.9,141.1 74.01,141.18 74.05,141.48 74.05,141.82 74.05,141.82 74,142.05 74,142.84 74.01,143.51 73.95,143.74 72.91,146.27 72.88,146.31 72.88,146.32 72.81,146.44 71.69,148.33 70.27,149.54 67.74,151.45 66.79,151.83 64.67,151.83 64.33,152.17 v1(62.32,152.17) 60.27,155.38 60.16,155.69 59.39,157.59 58.51,158.61 56.09,160.89 55.92,161.04 51.59,163.09 49.46,163.95 48.96,163.95 47.78,163.47 46.68,162.37 45.83,162.37 45.27,161.81 44.59,161.81 v1(43.9,161.69) 43.88,161.71 43.25,161.71 42.92,161.38 38.67,161.38 v1(36.3,160.97)
  BOTTOM w0.102: U16.T7 v1(72.7,131.58) ; v1(36.3,160.97) U11.T7 ; v1(72.7,143.45) 71.23,143.23 U13.T7 ; U12.T7 v1(48.17,160.97)
  BOTTOM w0.178: v1(62.32,152.17) 61.24,151.09 61.24,149.67 59.51,147.94 58.79,147.94 56.85,146 56.85,145.74 54.54,143.42 51.32,143.42 49.6,141.7 U43.F27
FBA_CMD13: length 106.6
  TOP w0.102: U11.N2 v1(40.2,157) ; U12.N2 52.43,156.6 v1(52.07,156.96) ; U13.N2 68.33,139.19 v1(68.69,139.55) ; U16.N2 v1(68.73,127.68)
  TOP w0.178: v1(65.29,152.24) 65.51,152.46 65.88,152.46 R51.2 65.94,152.74 65.64,152.74 65.41,152.98 R49.1
  IN1 w0.14: v1(52.07,156.96) 51.01,157.21 50.33,157.21 49.23,157.49 45.32,157.49 45.13,157.69 v1(43.99,157.69) 42.98,157.69 42.5,157.21 42.5,156.45 41.81,155.76 40.88,155.76 40.75,155.88 40.75,156.4 40.62,156.52 40.42,156.52 40.29,156.4 40.29,155.88 40.17,155.76 39.89,155.76 39.54,156.11 39.54,156.34 v1(40.2,157) ; v1(59.32,149.06) 61.12,149.06 61.49,149.43 62.61,149.43 65.29,152.11 v1(65.29,152.24)
  IN3 w0.102: v1(68.73,127.68) 68.95,128.63 69.12,132.38 69.17,133.45 69.17,134.35 69.37,135.05 v1(69.4,135.86) ; v1(68.69,139.55) 68.69,139.84 68.92,140.06 69.1,140.06 69.22,139.94 69.22,139.84 69.13,139.75 69.13,139.22 69.2,139.15 69.71,139.15 69.96,138.89 69.96,138.46 69.81,138.31 69.22,138.31 69.1,138.19 69.1,137.61 69.22,137.48 69.57,137.48 69.66,137.39 69.66,137.25 69.55,137.14 69.11,137.14 69.01,137.04 69.01,136.89 69.08,136.81 69.42,136.81 69.5,136.73 69.5,136.56 69.42,136.48 69.17,136.48 69.09,136.41 69.09,136.29 69.4,135.98 v1(69.4,135.86) ; v1(69.4,135.86) 69.63,136.09 69.97,136.79 69.97,138.02 70.29,138.33 70.29,138.92 70.14,139.28 69.94,139.75 69.89,139.86 69.79,140.06 69.79,140.17 69.78,140.18 69.79,140.19 69.79,141.25 69.71,141.48 69.35,141.65 69.19,142.12 69.36,142.48 68.83,143.99 68.77,144.44 68.65,144.52 68.39,144.49 68.28,144.58 68.26,144.73 68.34,144.84 68.61,144.88 68.69,144.99 68.65,145.32 68.65,145.43 68.61,145.56 68.4,145.75 67.89,145.97 67.45,146.27 67.41,146.29 67.41,146.29 66.3,147.16 65.94,147.31 65.34,147.58 64.68,147.8 64.06,147.8 63.47,147.79 63.35,147.8 63.35,147.8 63.19,147.81 62.24,147.87 61.75,147.9 61.15,147.93 60.59,148.17 v1(59.32,149.06) 58.34,150.58 57.59,151.56 57.2,151.94 57,152.7 57,153.32 56.95,153.52 56.29,155.12 54.37,156.98 53.37,156.98 53.08,157.27 53.08,157.77 52.6,158.25 52.6,158.65 52.25,159 50.91,159 50.35,158.44 48.65,158.44 45.85,157.99 45.18,157.73 45.05,157.69 v1(43.99,157.69)
  BOTTOM w0.102: U11.N2 v1(40.2,157) ; U13.N2 68.73,139.55 v1(68.69,139.55) ; v1(52.07,156.96) 52.43,156.6 U12.N2 ; U16.N2 v1(68.73,127.68)
  BOTTOM w0.178: U43.G25 49.19,140.25 49.19,142.05 50.94,143.8 54.38,143.8 56.47,145.89 56.47,146.16 57.62,147.3 57.62,147.78 58.9,149.06 v1(59.32,149.06)
FBA_CMD14: length 110.9
  TOP w0.102: v1(39.35,159.3) 39.43,159.37 39.65,159.37 39.8,159.23 U11.T3 ; U13.T3 70.73,140.26 70.9,140.43 v1(71.13,140.43) ; v1(71.32,128.51) 70.89,128.08 U16.T3 ; v1(52,159.43) 52.05,159.38 52.05,159.11 51.95,159 U12.T3
  TOP w0.178: v1(61.73,156.83) 62.37,157.47 R10.1 R9.2
  IN1 w0.14: v1(52,159.43) 51.57,159.86 50.87,159.86 49.92,159.4 46.14,159.4 45.66,159.73 45.51,159.82 v1(45.02,159.91) ; v1(60.77,151.23) 61.48,151.93 61.48,154.78 62.37,155.66 62.37,156.52 62.06,156.83 v1(61.73,156.83) ; v1(71.13,140.43) 71.13,140.62 71.26,140.75 71.45,140.75 71.57,140.61 71.57,139.19 71.85,138.91 71.85,137.3 71.41,136.38 71.31,136.28 71.31,135.34 71.41,135.25 71.41,134.88 71.28,134.75 71.28,134.46 v1(71.38,134.36)
  IN3 w0.102: v1(39.35,159.3) 39.75,159.7 40.06,159.7 40.19,159.57 40.19,159.45 40.29,159.35 40.5,159.35 40.6,159.45 40.6,159.91 40.78,160.09 41.31,160.09 41.46,159.93 41.46,159.5 41.62,159.35 43.8,159.35 44.36,159.91 v1(45.02,159.91) 45.02,160.06 45.14,160.18 45.37,160.18 45.42,160.13 45.42,160 45.54,159.88 45.71,159.88 45.83,160 45.83,160.51 46.02,160.7 46.83,160.7 46.95,160.82 46.95,161.04 47.06,161.15 47.22,161.15 47.33,161.04 47.33,160.43 47.44,160.32 47.6,160.32 47.71,160.43 47.71,161.32 47.84,161.45 48.27,161.45 48.45,161.27 48.62,161.27 48.81,161.46 50.09,161.46 50.39,161.76 50.78,161.76 51.08,161.46 51.58,161.46 52.87,161.01 53.25,160.84 55.04,159.94 56.73,158.3 57.8,155.76 58.38,155.55 58.58,155.31 59.68,152.7 v1(60.77,151.23) 61.71,150.36 61.93,150.22 63.94,150.12 66.49,149.5 68.5,148.64 69.67,147.48 71.33,146.27 71.53,145.99 71.74,145.41 71.75,145.28 71.6,143.37 71.56,141.72 71.62,141.55 71.71,141.01 71.79,140.79 71.84,140.65 72.16,140.46 72.28,140.39 72.41,140.19 72.41,140.19 72.41,139.22 72.06,137.58 72,137.39 71.77,136.83 71.66,136.53 71.61,136.4 71.43,135.75 71.43,135.21 71.38,135.01 v1(71.38,134.36) 71.38,134.13 70.7,133.44 70.7,130.27 71.32,129.64 71.32,128.52 v1(71.32,128.51)
  BOTTOM w0.102: v1(52,159.43) 52.05,159.38 52.05,159.11 51.95,159 U12.T3 ; v1(71.13,140.43) 70.9,140.43 70.73,140.26 U13.T3 ; U11.T3 39.8,159.23 39.65,159.37 39.43,159.37 v1(39.35,159.3) ; U16.T3 70.89,128.08 v1(71.32,128.51)
  BOTTOM w0.178: v1(60.77,151.23) 58.99,149.44 58.74,149.44 57.23,147.93 56.79,147.93 56.09,147.23 56.09,146.05 54.22,144.18 50.55,144.18 48.8,142.42 U43.G27
FBA_CMD15: length 109.9
  TOP w0.102: U12.K3 51.35,154.2 51.27,154.12 51.27,153.45 51.15,153.33 50.98,153.33 50.86,153.45 50.86,153.79 50.78,153.86 v1(50.56,153.86) ; v1(38.59,154.27) 38.61,154.29 39,154.29 39.1,154.19 39.1,153.67 39.17,153.61 39.31,153.61 39.41,153.7 39.41,154.12 39.49,154.2 U11.K3 ; v1(65.97,141.06) 65.97,140.88 65.85,140.76 65.46,140.76 65.34,140.63 65.34,140.54 65.46,140.41 65.99,140.41 66.11,140.29 66.11,140.13 U13.K3 ; U16.K3 65.93,128.28 65.75,128.46 65.39,128.46 65.26,128.59 65.26,128.77 65.39,128.9 65.75,128.9 65.87,129.02 v1(65.87,129.44)
  IN1 w0.14: v1(65.87,129.44) 65.9,129.47 65.9,129.94 66,130.03 66,130.29 65.79,130.49 65.79,130.77 66.36,131.33 66.36,134.6 66.14,134.82 66.14,135.02 v1(66.36,135.25) 66.28,135.33 66.28,135.57 66.36,135.65 66.36,136.13 66.31,136.18 66.31,136.49 66.46,136.64 66.46,136.87 66.31,137.02 66.31,137.25 66.46,137.4 66.46,137.65 66.31,137.8 66.31,139.82 65.87,140.25 65.87,140.96 v1(65.97,141.06) ; v1(50.56,153.86) 50.28,154.14 48.78,154.14 48.35,154.57 44.58,154.57 v1(44.51,154.64) ; v1(57.07,148.42) 57.07,149.35 59.7,151.98 59.7,157.09 v1(59.95,157.34)
  IN3 w0.102: v1(66.36,135.25) 66.36,135.92 65.99,136.3 65.99,137.64 65.59,138.03 65.26,138.03 64.78,138.52 64.78,140.55 63.66,141.66 63.66,142.27 62.75,143.19 62.75,143.72 62.44,144.03 62.44,144.88 62.01,145.31 61.71,145.53 57.87,147.43 v1(57.07,148.42) 56.52,148.42 54.24,150.71 54.24,151.19 54.11,151.32 53.76,151.32 53.63,151.44 53.63,151.6 53.76,151.72 54.11,151.72 54.24,151.85 54.24,152.51 54.11,152.64 53.58,152.64 53.24,152.98 53.24,153.28 53.12,153.41 52.94,153.41 52.62,153.08 52.14,153.08 51.34,153.88 51.34,154.09 50.98,154.45 50.98,154.45 50.85,154.58 50.3,154.58 49.85,155.03 49.58,155.03 49.15,154.6 44.54,154.6 v1(44.51,154.64) 43.78,154.64 43.51,154.37 43.06,154.37 42.96,154.47 42.6,154.47 42.5,154.37 42.25,154.37 41.85,154.77 40.71,154.77 39.27,154.27 v1(38.59,154.27)
  BOTTOM w0.102: v1(65.97,141.06) 65.69,141.34 65.69,141.86 65.93,142.1 U41.K3 ; v1(38.59,154.27) 38.41,154.09 37.4,154.09 37.18,153.86 36.94,153.86 U38.K3 ; U44.K3 65.93,131.28 65.67,131.28 65.54,131.16 65.54,130.72 65.87,130.39 v1(65.87,129.44) ; U39.K3 48.53,154.14 50.4,154.14 50.56,153.99 v1(50.56,153.86)
  BOTTOM w0.178: v1(59.95,157.34) 59.95,158.15 60.28,158.48 R442.2 R441.1 ; U43.G26 48.41,141.05 48.41,142.67 50.3,144.56 54.06,144.56 55.71,146.21 55.71,147.94 56.19,148.42 v1(57.07,148.42)
FBA_CMD16: length 74.2
  TOP w0.102: U11.K1 41.25,154.36 41.04,154.36 40.79,154.61 39.57,154.61 39.43,154.75 38.46,154.75 38.34,154.87 38.34,155.25 38.47,155.39 v1(38.59,155.39) ; v1(50.33,155.18) 50.15,155.01 50.15,154.72 50.26,154.61 53.13,154.61 53.27,154.47 U12.K1
  TOP w0.178: R34.1 57.11,155.23 55.1,155.23 v1(54.85,154.97) 54.31,154.44 54.31,151.62 53.67,150.98 53.67,146.79 53.3,146.41 48.98,146.41 48.02,145.46 46.14,145.46 45.96,145.27 45.96,144.99 46.16,144.79 46.62,144.79 46.82,144.59 46.82,144.41 46.62,144.21 46.29,144.21 46.08,144 46.08,143.52 45.69,143.13 44.55,143.13 44.38,142.96 44.38,142.6 44.56,142.43 44.92,142.43 45.07,142.27 45.07,141.67 44.23,140.82 v1(44.23,139.47)
  IN1 w0.14: v1(44.48,156.38) 44.89,156.38 45.33,155.94 46.79,155.94 46.97,156.12 47.59,156.12 47.92,156.45 48.68,156.45 49.68,155.45 50.06,155.45 v1(50.33,155.18)
  IN3 w0.102: v1(38.59,155.39) 38.59,155.84 38.66,155.91 39.49,155.91 39.72,155.68 42.75,155.68 43.1,156.03 43.43,156.03 43.77,156.38 v1(44.48,156.38) 44.76,156.1 46.35,156.1 46.74,156.5 47.74,156.5 47.84,156.4 47.84,156.19 47.96,156.07 48.17,156.07 48.29,156.19 48.29,156.76 49.06,157.52 51.08,157.52 51.53,157.07 51.53,156.52 52.02,156.03 52.6,156.03 52.81,155.81 53.25,155.81 53.46,156.03 53.97,156.03 54.44,155.56 54.44,155.33 54.26,155.15 54.26,154.91 54.58,154.59 54.72,154.59 54.85,154.72 v1(54.85,154.97)
  BOTTOM w0.102: U38.K1 35.69,154.57 37.4,154.57 37.81,154.98 38.18,154.98 v1(38.59,155.39) ; U43.M24 v1(44.23,139.47) ; U39.K1 47.58,154.57 49.13,154.57 49.29,154.73 49.39,154.83 49.55,154.99 49.55,155.16 49.72,155.33 50.18,155.33 v1(50.33,155.18)
FBA_CMD17: length 81.9
  TOP w0.102: v1(45.35,163.87) 45.91,164.18 46.24,164.18 49.41,163.67 50.56,162.53 52.86,159.44 52.86,155.54 52.74,155.2 U12.L2 ; U11.L2 41.28,154.67 41.54,154.67 v1(43.32,154.78)
  IN1 w0.102: 45.42,139.23 45.26,139.06 44.79,139.06 v1(44.26,138.67)
  IN1 w0.14: v1(45.35,163.87) 46.46,164.98 48.95,164.98 50.3,163.64 52.05,163.64 52.26,163.43 52.26,163.15 52.05,162.95 50.77,162.95 50.58,162.76 50.58,162.5 50.77,162.32 52.56,162.32 52.76,162.11 52.76,161.83 52.56,161.63 51.17,161.63 50.99,161.45 50.99,161.2 51.17,161.02 53.71,161.02 53.91,160.83 53.91,160.55 53.71,160.36 52.88,160.36 52.69,160.17 52.69,159.9 52.88,159.71 54.76,159.71 55.3,159.17 55.3,158.73 55.1,158.53 53.73,158.53 53.55,158.35 53.55,158.1 53.73,157.92 55.1,157.92 55.3,157.72 55.3,156.38 54.34,155.41 54.34,151.11 53.96,150.73 53.96,147.35 48.52,141.92 47.61,141.92 47.28,141.59 46.57,141.59 46.11,141.13 46.11,140.16 45.88,139.68 45.42,139.23
  BOTTOM w0.102: U43.M23 44.64,138.29 v1(44.26,138.67)
  BOTTOM w0.178: v1(45.35,163.87) 45.05,164.1 44.43,164.21 44.09,164.24 43.82,164.24 42.7,163.12 42.7,155.4 v1(43.32,154.78)
FBA_CMD18: length 84.3
  TOP w0.178: v1(39.7,160.26) 39.7,160.63 43.33,164.26 44.21,164.26 44.59,163.88 v1(44.59,163.41)
  IN1 w0.14: v1(44.59,163.41) 44.59,164.23 45.88,165.52 50.99,165.52 52.59,163.92 56.02,163.92 56.22,163.71 56.22,163.43 56.02,163.23 53.17,163.23 52.97,163.03 52.97,162.72 53.17,162.52 56.02,162.52 56.22,162.32 56.22,162.04 56.02,161.83 54.24,161.83 54.03,161.63 54.03,161.3 54.24,161.1 56.02,161.1 56.22,160.89 56.22,160.64 56.02,160.44 55.4,160.44 55.2,160.24 55.2,159.97 55.4,159.78 56.02,159.78 56.22,159.57 56.22,152.08 54.45,150.31 54.45,147.22 v1(46.71,139.48)
  BOTTOM w0.102: v1(39.7,160.26) 39.4,160.26 38.62,159.48 38.62,158.71 36.97,156.43 36.71,156.18 35.7,156.18 35.44,155.92 35.44,155.36 U38.L2 ; U39.L2 47.35,155 46.92,154.57 45.4,154.57 44.92,155.06 44.92,157.59 44.22,158.29 43.52,158.29 43.37,158.44 43.37,158.68 43.52,158.84 43.87,158.84 44.03,158.99 44.03,159.24 43.87,159.39 43.54,159.39 43.39,159.55 43.39,160.31 44.59,161.5 44.88,161.5 45.02,161.64 45.02,161.84 44.88,161.99 44.67,161.99 44.54,162.12 44.54,162.31 44.67,162.44 44.84,162.44 44.97,162.57 44.97,162.75 44.84,162.87 44.68,162.87 44.59,162.96 v1(44.59,163.41) ; U43.K24 46.32,139.09 v1(46.71,139.48)
FBA_CMD19: length 75.9
  TOP w0.102: v1(49.69,154.56) 49.82,154.44 49.82,154.26 49.69,154.14 49.13,154.14 48.71,154.56 47.5,154.56 47.14,154.2 U12.K9 ; v1(38,154.55) 37.71,154.55 37.6,154.44 37.6,154.22 37.49,154.11 37.19,154.11 36.71,154.59 35.71,154.59 35.41,154.29 35.09,154.29 U11.K9
  TOP w0.178: v1(46.71,138.66) 46.38,138.66 46.16,138.44 46.16,137.79 45.97,137.6 45.71,137.6 45.53,137.79 v1(45.53,138.27) 45.53,138.82 46.03,139.33 46.03,139.96 45.47,140.52 45.47,142.37 47.23,144.12 47.23,144.79 47.51,145.07 48.17,145.07 49.14,146.03 53.46,146.03 54.06,146.64 54.06,150.76 54.77,151.47 54.77,152.14 v1(55.13,152.49) 56.53,152.49 57.24,153.2 57.24,153.97 R47.2
  IN1 w0.14: v1(43.89,155.07) 44.74,155.07 44.9,154.91 48.51,154.91 48.94,154.49 49.18,154.49 49.34,154.64 49.61,154.64 v1(49.69,154.56)
  IN3 w0.102: v1(38,154.55) 38.13,154.67 39.46,154.67 39.72,154.78 40.34,155.07 43.01,155.07 43.15,155.21 43.76,155.21 v1(43.89,155.07) 44.66,155.07 44.83,154.91 45.05,154.91 45.25,155.1 45.47,155.1 45.67,154.91 45.94,154.91 46.14,155.11 46.33,155.11 46.54,154.91 46.73,154.91 46.82,155 46.82,155.28 46.93,155.39 47.09,155.39 47.2,155.28 47.2,155.03 47.33,154.91 47.62,154.91 47.82,155.11 48.01,155.11 48.21,154.91 48.5,154.91 48.6,155 48.6,155.2 49.2,155.8 49.37,155.8 49.49,155.68 49.49,155.43 49.59,155.33 49.9,155.33 50.18,155.61 50.57,155.61 50.77,155.81 50.93,155.81 51.4,155.35 51.4,154.46 51.64,154.22 51.9,154.22 52.03,154.35 52.03,154.48 52.15,154.6 52.33,154.6 52.46,154.48 52.46,154.35 52.59,154.22 52.74,154.22 52.87,154.35 52.87,154.58 52.99,154.7 53.18,154.7 53.58,154.3 53.58,154.19 53.27,153.88 53.27,153.68 53.4,153.55 53.58,153.55 53.86,153.83 54.05,153.83 54.57,153.31 54.57,151.39 54.67,151.29 55.03,151.29 55.13,151.39 v1(55.13,152.49)
  BOTTOM w0.102: v1(49.69,154.56) 52.52,154.56 U39.K9 ; U43.K23 46.72,138.66 v1(46.71,138.66) ; U38.K9 40.68,154.57 39.17,154.57 38.97,154.77 38.41,154.77 38.19,154.55 v1(38,154.55)
FBA_CMD20: length 154.5
  TOP w0.102: v1(38.31,162.98) 38.31,162.42 38.59,162.14 39.25,162.14 39.53,161.86 39.53,161.32 39.3,161.09 39.3,160.07 39.55,159.82 U11.T2 ; v1(49.15,163.24) 49.15,163.13 49.68,162.6 49.93,162.6 50.27,162.27 52.39,159.66 U12.T2 ; v1(75.02,142.47) 73.98,141.32 72.35,140.46 71.89,140.46 71.75,140.39 U13.T2 ; U16.T2 71.21,127.28 73.2,129.27 73.62,129.27 74.91,130.57 v1(74.91,130.62)
  TOP w0.178: v1(75.02,142.47) 75.02,141.62 74.58,141.18 74.58,138.19 75.05,137.72 v1(76.39,137.05) ; v1(38.31,162.98) 40.57,162.98 41.05,163.23 41.78,163.96 43.06,164.69 v1(44.37,164.69)
  IN3 w0.102: v1(76.39,137.05) 76.4,137.52 76.4,137.75 76.41,138.41 76.43,139.54 76.48,142.4 76.48,142.65 76.39,143.25 75.17,146.6 74.53,147.63 73.26,149.64 71.51,151.82 71,152.36 70.24,153 68.28,154.29 66.7,155.69 v1(65.27,156.75) 62.71,159.34 60.26,161.09 56.75,163.59 56.47,163.72 56.47,163.72 55.98,163.95 55.68,164.09 55.68,164.09 55.08,164.36 54.4,164.67 54.39,164.67 54.11,164.79 54.01,164.84 52.79,165.16 50.21,165.84 48.27,165.84 v1(44.37,164.69)
  BOTTOM w0.102: U41.T2 71.19,144.41 73.62,144.41 74.46,143.57 74.46,143.03 v1(75.02,142.47) ; U38.T2 35.62,159.67 35.61,159.94 35.75,161.22 35.81,161.38 36.44,162.21 36.63,162.4 37.27,162.62 37.95,162.62 v1(38.31,162.98) ; U44.T2 73.42,132.52 74.05,132.52 74.58,131.99 74.58,130.95 v1(74.91,130.62) ; U39.T2 47.67,159.09 47.41,159.35 47.41,160.44 47.13,160.72 47.13,161.73 48.14,162.75 48.66,162.75 v1(49.15,163.24)
  BOTTOM w0.178: v1(74.91,130.62) 76.34,136.08 v1(76.39,137.05) ; v1(49.15,163.24) 48.57,163.43 47.56,163.77 47.4,163.69 47.18,163.03 47.02,162.95 46.85,163.01 46.77,163.17 46.82,163.32 46.99,163.83 46.99,163.83 46.91,163.99 45.55,164.45 v1(44.37,164.69) ; R468.1 69.4,155.47 69.4,156 68.08,157.32 65.84,157.32 v1(65.27,156.75) 63.81,156.65 63.81,156.64 61.66,155.6 58.79,154.23 56.73,153.27 53.81,150.35 53.81,147 53.27,146.47 48.88,146.47 47.43,145.02 46.9,145.02 44.64,142.76 U43.M27
FBA_CMD21: length 140
  TOP w0.102: v1(73.56,143.57) 72.78,143.86 72.65,143.86 71.26,143.67 70.83,143.61 70.57,143.61 U13.R8 ; v1(73.56,131.7) 72.78,131.99 72.48,131.99 71.26,131.8 70.83,131.74 70.57,131.74 U16.R8 ; U11.R8 35.8,158.33 36.2,158.73 36.2,159.24 36.08,159.36 v1(36.08,159.57) ; U12.R8 48.02,158.84 48.02,159.1 47.76,160.75 47.76,161.26 48.05,161.83 v1(48.05,161.85)
  IN1 w0.14: v1(74.04,135.97) 74.69,136.36 74.78,136.49 74.86,136.86 74.76,138.38 74.76,142.07 74.31,142.82 v1(73.56,143.57) ; v1(36.08,159.57) 36.74,159.57 38.93,161.76 42.02,161.76 43.07,162.81 v1(43.49,162.81) 44.31,162.63 45.02,162.63 45.86,162.83 46.42,162.83 46.55,162.96 46.55,163.22 46.67,163.34 46.87,163.34 47,163.22 47,162.96 47.13,162.83 47.28,162.83 47.41,162.96 47.41,163.22 47.53,163.34 47.71,163.34 47.84,163.22 47.84,162.82 47.96,162.7 48.31,162.7 48.43,162.58 48.43,162.41 48.31,162.29 48.08,162.29 47.95,162.16 47.95,161.95 v1(48.05,161.85)
  IN3 w0.102: v1(73.56,131.7) 74.56,131.7 74.66,131.81 74.66,132.07 74.56,132.17 73.68,132.17 73.56,132.3 73.56,132.45 73.66,132.55 74.56,132.55 74.66,132.65 74.66,132.83 74.56,132.93 73.94,132.93 73.84,133.04 73.84,133.23 73.92,133.32 74.05,133.32 74.18,133.44 74.18,133.59 74.07,133.7 73.92,133.7 73.84,133.78 73.84,135.76 v1(74.04,135.97) 73.93,136.66 74.25,138.06 74.35,138.58 74.66,141.44 74.66,141.98 74.65,142.03 74.61,142.3 74.61,142.84 74.62,143.58 74.52,143.99 73.53,146.49 72.46,148.29 72.19,148.69 71.92,148.97 70.96,149.9 66.14,153.61 v1(64.14,154.99) 63.27,156.08 60.8,158.48 58.76,160.22 56.31,161.57 53.15,163.08 52.09,163.56 49.62,164.56 48.74,164.56 47.41,163.97 46.68,163.25 46.24,163.05 45.66,163.05 44.72,162.7 44.29,162.7 v1(43.49,162.81)
  BOTTOM w0.102: v1(73.56,143.57) 72.78,143.86 72.65,143.86 71.26,143.67 70.83,143.61 70.57,143.61 U13.R8 ; v1(73.56,131.7) 72.78,131.99 72.48,131.99 71.26,131.8 70.83,131.74 70.57,131.74 U16.R8 ; U12.R8 48.02,158.84 48.02,159.1 47.76,160.75 47.76,161.26 ; U43.M26 44.92,140.85 45.19,141.12 ; v1(36.08,159.57) 36.15,159.5 36.15,158.74 35.8,158.38 U11.R8
  BOTTOM w0.178: v1(48.05,161.85) 48.05,161.83 47.76,161.26 ; 45.19,141.12 45.49,141.66 45.49,142.22 47.14,143.87 47.36,143.87 49.19,145.7 53.59,145.7 54.57,146.68 54.57,148.98 56.42,150.83 57.26,150.83 58.56,152.14 58.56,152.83 58.78,153.05 61.57,154.53 62.44,154.99 v1(64.14,154.99) 64.4,155 66.05,155.49 66.23,155.49 66.68,155.03 66.68,154.77 R469.1 R478.2
FBA_CMD22: length 121.7
  TOP w0.102: U13.P2 v1(69.53,139.55) ; v1(52.07,157.77) 52.47,157.39 U12.P2 ; U16.P2 69.13,127.31 v1(69.5,127.68) ; U11.P2 v1(40.2,157.8)
  IN1 w0.14: v1(40.2,157.8) 40.2,158.05 40.33,158.18 40.55,158.18 40.67,158.3 40.67,158.68 40.8,158.81 40.98,158.81 41.11,158.68 41.11,158.32 41.23,158.2 41.41,158.2 41.54,158.33 41.54,158.68 41.66,158.81 41.84,158.81 41.97,158.68 41.97,158.35 42.17,158.15 v1(45.15,158.15) 45.47,157.83 49.54,157.83 50.49,157.57 51.47,157.57 v1(52.07,157.77) ; v1(69.69,134.48) 69.66,134.48 69.53,134.61 69.53,134.77 69.69,134.93 69.69,135.25 69.85,135.41 69.85,136.23 69.72,136.36 69.5,136.36 69.38,136.48 69.38,136.66 69.5,136.79 69.71,136.79 69.83,136.92 69.83,137.12 69.71,137.25 69.24,137.25 69.12,137.37 69.12,138.08 69.22,138.19 69.22,138.41 69.12,138.52 69.12,138.97 69.19,139.05 69.19,139.23 69.12,139.3 69.12,139.54 69.24,139.66 69.43,139.66 v1(69.53,139.55)
  IN3 w0.102: v1(45.15,158.15) 45.43,158.23 46.17,158.35 46.23,158.43 46.21,158.55 46.28,158.64 46.47,158.67 46.56,158.61 46.58,158.52 46.69,158.44 46.99,158.49 47.08,158.6 47.06,158.73 47.15,158.86 47.3,158.88 47.4,158.81 47.43,158.66 47.54,158.58 47.7,158.6 47.78,158.72 47.74,158.92 47.82,159.03 48,159.06 48.09,158.99 48.13,158.77 48.25,158.69 48.55,158.74 48.68,158.87 48.68,159.13 48.78,159.23 48.93,159.23 49.03,159.13 49.03,158.84 49.14,158.74 49.28,158.74 49.39,158.84 49.39,159.31 49.49,159.41 49.64,159.41 49.74,159.31 49.74,158.84 49.85,158.74 49.99,158.74 50.1,158.84 50.1,159.46 50.19,159.56 50.38,159.56 50.45,159.48 50.45,159.3 50.53,159.23 50.71,159.23 50.81,159.32 50.81,159.57 50.99,159.75 51.43,159.88 52.16,159.88 52.46,159.58 53.29,158.47 53.35,158.41 53.35,157.91 53.48,157.79 53.62,157.79 53.72,157.88 53.72,158.17 53.82,158.28 53.98,158.28 54.09,158.17 54.09,157.95 54.21,157.82 54.31,157.82 54.44,157.95 54.44,158.2 54.52,158.28 54.82,158.28 54.92,158.18 54.92,157.77 55.05,157.64 55.33,157.64 55.43,157.54 55.43,157.39 55.33,157.29 55,157.29 54.9,157.18 54.9,157.03 55,156.93 55.51,156.93 55.63,156.8 55.63,156.21 56.58,155.27 56.66,155.03 57.24,153.62 57.3,153.36 57.3,152.74 57.4,152.57 57.51,152.46 57.84,152.46 57.95,152.36 57.95,152.15 v1(57.76,151.96) 58.83,150.41 59.41,149.74 60.03,148.95 61.05,148.32 61.17,148.3 61.4,148.26 62.08,148.18 63.2,148.11 63.36,148.1 64.73,148.1 65.34,147.92 66.06,147.59 66.44,147.43 66.46,147.42 67.59,146.54 67.69,146.47 67.74,146.44 68.54,146.07 68.61,146.02 68.85,145.78 68.89,145.71 68.92,145.61 68.93,145.6 68.95,145.49 68.96,145.43 68.96,145.34 69.01,144.95 69.14,144.12 69.55,142.86 70.11,141.38 70.11,140.17 70.17,139.99 70.17,139.98 70.21,139.88 70.54,139.14 70.62,138.97 70.82,138.34 70.85,138.21 70.85,138.05 70.82,137.82 70.77,137.66 70.62,137.41 70.59,137.32 70.56,137.25 70.41,136.89 69.72,135.27 69.72,135.15 69.69,134.93 v1(69.69,134.48) 69.48,134.27 69.48,129.98 69.25,128.56 69.25,127.75 69.32,127.68 v1(69.5,127.68)
  BOTTOM w0.102: v1(52.07,157.77) 52.1,157.77 U12.P2 ; U43.M25 44.23,140.27 44.23,140.81 44.48,141.06 44.79,141.06 44.97,141.23 45.05,141.38 45.05,142.53 ; U11.P2 v1(40.2,157.8) ; U16.P2 69.13,127.31 v1(69.5,127.68) ; U13.P2 v1(69.53,139.55)
  BOTTOM w0.178: 45.05,142.53 46.9,144.38 47.33,144.38 49.03,146.08 53.43,146.08 54.19,146.84 54.19,149.75 56.25,151.81 57.6,151.81 v1(57.76,151.96) 57.76,152.07 58.17,152.48 58.17,153.02 58.57,153.51 62.3,155.42 63.74,155.49 64.47,155.49 65.81,155.98 67.25,156.56 67.83,156.56 68.21,156.18 68.21,155.79 67.89,155.48 67.89,154.46 68.22,154.13 R470.1 R479.2
FBA_CMD23: length 117.6
  TOP w0.102: v1(69.32,141.09) 69.93,140.48 U13.R3 ; U16.R3 70.32,128.08 70.39,128.16 70.39,128.4 v1(70.64,128.64) ; v1(51.33,159.43) 51.33,159.43 51.33,158.86 51.67,158.52 U12.R3 ; U11.R3 39.43,158.2 39.32,158.31 v1(39.32,158.59)
  TOP w0.178: v1(46.71,141.05) 46.71,141.05 46.44,141.32 46.44,142.25 49.46,145.27 53.77,145.27 54.9,146.4 54.9,149.89 55.89,150.89 57.87,150.89 59.24,152.26 v1(59.24,152.36)
  IN1 w0.14: v1(39.32,158.59) 39.95,159.22 42.12,159.22 42.27,159.06 42.93,159.06 43.32,159.45 43.6,159.45 43.7,159.35 43.7,158.69 43.8,158.59 43.98,158.59 44.08,158.69 44.08,159.35 44.2,159.48 v1(44.54,159.48) 44.62,159.39 44.89,159.39 44.97,159.48 45.4,159.48 45.83,159.05 50.38,159.05 50.76,159.43 v1(51.33,159.43) ; v1(70.97,135.04) 70.97,136.38 71.46,137.29 71.46,138.82 71.13,139.15 71.13,139.66 70.51,140.28 70.01,140.68 v1(69.32,141.09) ; v1(59.83,158.72) 59,157.89 59,152.36 v1(59.24,152.36)
  IN3 w0.102: v1(44.54,159.48) 45.62,159.48 45.97,159.56 46.14,159.82 46.51,159.93 46.9,159.78 47.54,159.94 47.81,160 47.95,160.04 48.02,160.11 48.02,160.47 48.12,160.56 48.25,160.56 48.35,160.47 48.35,160.28 48.43,160.19 48.56,160.19 48.65,160.28 48.65,160.87 48.94,161.15 49.15,161.15 49.36,160.94 49.57,160.94 49.78,161.15 50.22,161.15 50.46,161.4 50.7,161.4 50.95,161.15 51.53,161.15 52.7,160.71 53.25,160.16 53.4,160.16 53.53,160.28 53.68,160.28 53.81,160.16 53.81,160.05 53.68,159.93 53.68,159.8 53.76,159.72 53.95,159.72 54.16,159.93 54.39,159.93 54.56,159.75 54.64,159.75 54.94,159.61 55.26,159.29 55.4,159.11 56.1,158.42 57.1,156.31 57.64,155.36 57.72,155.22 57.86,155.18 58.08,155.31 58.21,155.27 58.28,155.13 58.24,154.99 58.03,154.87 57.99,154.73 58.06,154.6 58.2,154.56 58.39,154.67 58.52,154.63 58.59,154.49 58.55,154.35 58.36,154.24 58.32,154.11 58.41,153.94 58.54,153.91 58.69,153.99 58.8,153.96 58.89,153.79 58.85,153.67 58.71,153.59 58.68,153.48 58.77,153.31 59.12,153.22 59.22,153 59.22,152.89 59.14,152.82 58.96,152.82 58.89,152.74 58.89,152.59 59.11,152.36 v1(59.24,152.36) 60.56,150.76 61.83,149.92 64.11,149.38 65.54,148.84 66.1,148.67 67.01,148.25 70.16,146.54 70.27,146.36 70.81,145.52 70.89,145.07 71.04,144.68 71.26,141.49 71.54,140.51 71.57,139.28 71.76,138.33 71.76,137.66 71.75,137.6 71.69,137.45 71.57,137.16 71.56,137.14 71.32,136.5 71.12,135.77 v1(70.97,135.04) 70.98,135.04 70.98,134.15 70.39,133.57 70.39,130.14 71.02,129.52 71.02,128.79 70.87,128.64 v1(70.64,128.64)
  BOTTOM w0.102: v1(39.32,158.59) 39.32,158.31 39.43,158.2 U11.R3 ; v1(51.33,159.43) 51.33,159.43 51.33,158.86 51.67,158.52 U12.R3 ; v1(70.64,128.64) 70.39,128.4 70.39,128.16 70.32,128.08 U16.R3 ; U13.R3 69.93,140.48 v1(69.32,141.09) ; v1(46.71,141.05) 46.32,140.66 U43.K26
  BOTTOM w0.178: v1(59.83,158.72) 58.94,157.83 R463.1 58.82,157.59 57.91,157.59 R462.2
FBA_CMD24: length 141.7
  TOP w0.102: v1(50.1,160.42) 49.79,158.59 U12.P7 ; 47.96,142.6 47.58,142.22 47.58,141.97 47.33,141.72 47.33,140.32 47.12,140.11 47.12,138.33 46.71,137.93 v1(46.71,137.82) ; U11.P7 37.92,158.59 v1(38.23,160.42) ; U13.P7 70.32,141.83 70.57,141.83 v1(72.1,141.57) ; v1(72.15,129.65) 70.32,129.96 U16.P7
  TOP w0.178: R4.1 R5.2 60.4,160.25 60.77,160.61 v1(60.77,161.33) ; v1(60.9,152.52) 60.59,152.52 58.2,150.12 56.98,150.12 55.66,148.81 55.66,146.08 54.06,144.48 49.84,144.48 47.96,142.6
  IN1 w0.14: v1(72.3,135.5) 72.3,135.95 72.25,136 72.25,136.36 72.54,137.09 72.54,138.81 72.79,139.06 72.79,140.51 72.6,141.04 72.59,141.08 72.52,141.22 v1(72.1,141.57) ; v1(50.1,160.42) 50.1,160.9 49.97,161.03 49.74,161.03 49.62,160.9 49.62,160.32 49.43,160.13 47.62,160.13 47.02,160.73 45.27,160.73 45.26,160.73 45.16,160.83 v1(44.79,160.83) 44.72,160.91 44.17,160.91 44.08,160.82 42.33,160.82 42.27,160.87 38.68,160.87 v1(38.23,160.42) ; v1(60.9,152.52) 60.9,154.68 61.58,155.36 61.58,155.84 61.3,156.12 61.3,157.08 61.6,157.39 61.6,159.75 60.77,160.59 v1(60.77,161.33)
  IN3 w0.102: v1(44.79,160.83) 44.79,161.08 44.92,161.2 45.55,161.2 46.11,161.76 46.68,161.76 46.68,161.76 46.93,161.76 47.82,162.65 48.27,162.65 48.36,162.75 48.36,162.96 48.47,163.06 48.65,163.06 48.75,162.96 48.75,162.81 48.89,162.67 48.9,162.67 49.28,162.71 49.35,162.72 49.54,162.91 49.54,163.03 49.66,163.15 49.8,163.15 49.92,163.03 49.92,162.85 50.16,162.61 53.19,161.61 55.37,160.52 56.22,159.8 57.14,158.84 57.44,158.55 57.67,157.92 57.79,157.58 58.03,157.34 58.75,156.62 58.8,156.5 59.61,154.55 59.74,154.49 59.9,154.56 60.03,154.51 60.08,154.36 60.03,154.22 59.87,154.16 59.82,154.03 59.88,153.89 60.01,153.83 60.28,153.95 60.43,153.89 60.48,153.75 60.43,153.62 60.15,153.5 60.09,153.37 60.14,153.26 60.2,153.2 60.66,153.2 60.9,152.96 v1(60.9,152.52) 61.56,151.75 62.05,151.36 62.8,151.09 63.76,150.83 64.83,150.55 66.98,150.05 68.03,149.74 68.19,149.7 68.2,149.69 68.52,149.6 69.85,149.04 70.22,148.73 70.8,148.24 71.25,147.71 72.08,146.44 72.27,146.14 72.5,144.87 72.33,143.74 72.27,143.57 72.27,143.34 72.37,143.19 72.53,143.04 72.73,142.73 72.94,141.72 72.94,141.21 73.02,140.46 73.02,140.2 73.02,140.2 73.02,139.95 73.02,139.15 73.01,138.97 72.7,137.58 72.63,137.23 72.33,136.6 72.29,136.48 72.27,136.37 v1(72.3,135.5) 72.3,132.91 71.31,131.92 71.31,130.59 72.15,129.75 72.15,129.65 v1(72.15,129.65)
  BOTTOM w0.102: v1(72.15,129.65) 70.32,129.96 U16.P7 ; U11.P7 37.92,158.59 v1(38.23,160.42) ; v1(46.71,137.82) 46.42,137.52 U43.K22 ; U12.P7 49.79,158.59 v1(50.1,160.42) ; U13.P7 70.32,141.83 70.57,141.83 v1(72.1,141.57)
FBA_CMD25: length 107.9
  TOP w0.102: U13.L3 67.25,140.47 v1(67.25,140.47) ; U11.L3 39.63,155 39.32,155.32 v1(39.32,155.43) ; v1(50.99,155.18) 51.17,155 U12.L3 ; v1(66.83,128.76) 66.73,128.66 U16.L3 ; v1(47.54,138.66) 47.96,139.08 47.96,140.7 v1(48.03,140.77) 48.47,141.21 48.47,141.91 49.17,142.6
  TOP w0.178: R36.1 63.26,155.98 62.57,155.28 R38.2 61,155.28 v1(60.64,155.64) ; v1(57.67,149.29) 57.46,149.08 57.06,149.08 56.42,148.45 56.42,145.77 54.3,143.65 50.21,143.65 49.17,142.6
  IN1 w0.14: v1(39.32,155.43) 39.32,154.6 39.44,154.47 39.76,154.47 39.89,154.6 39.89,155.29 40.01,155.41 40.19,155.41 40.32,155.29 40.32,154.52 40.57,154.27 41.34,154.27 43.14,156.07 43.91,156.07 v1(44.02,155.95) 44.27,155.95 44.41,155.81 44.97,155.81 45.19,155.6 46.93,155.6 47.11,155.77 47.73,155.77 48.06,156.11 48.53,156.11 49.63,155.01 49.9,155.01 50.17,154.73 50.54,154.73 v1(50.99,155.18) ; v1(57.67,149.29) 58.05,149.29 60.05,151.85 60.05,155.06 v1(60.64,155.64)
  IN3 w0.102: v1(66.83,128.76) 66.81,128.79 66.81,130.01 66.05,130.77 66.05,131.35 66.51,131.81 66.51,133.84 67.66,135 v1(67.66,135.84) ; v1(44.02,155.95) 44.18,155.79 46.47,155.79 46.85,156.18 47.22,156.18 47.63,155.76 48.3,155.76 48.77,156.24 48.77,156.8 48.91,156.94 49.08,156.94 49.16,156.86 49.16,156.73 49.26,156.63 49.44,156.63 49.54,156.73 49.54,157.1 49.64,157.2 50.97,157.2 51.23,156.94 51.23,156.39 51.89,155.73 52.47,155.73 52.69,155.51 53.23,155.51 55.04,153.7 55.75,153.7 55.87,153.58 55.94,153.41 55.94,151.02 v1(57.67,149.29) 58.25,148.19 59.46,147.52 59.68,147.38 60.52,147.06 62.94,146.91 64.01,146.33 64.29,146.27 64.73,146.31 65.11,146.27 65.31,146.19 66.3,144.71 66.81,142 66.81,140.89 66.25,140.34 66.25,138.66 66.92,137.99 66.92,136.76 67.51,136.18 67.51,135.99 v1(67.66,135.84) ; v1(67.25,140.47) 66.85,140.47 66.69,140.32 66.69,140.17 66.82,140.04 67.17,140.04 67.27,139.94 67.27,139.8 67.17,139.7 66.65,139.7 66.56,139.6 66.56,139.46 66.65,139.37 67.21,139.37 67.3,139.27 67.3,139.13 67.21,139.04 66.73,139.04 66.63,138.94 66.63,138.8 66.73,138.7 67.15,138.7 67.25,138.6 67.25,136.88 67.78,136.35 67.78,135.96 v1(67.66,135.84)
  BOTTOM w0.102: v1(50.99,155.18) 51.17,155 U12.L3 ; v1(39.32,155.43) 39.32,155.32 39.63,155 U11.L3 ; v1(47.54,138.66) 47.14,138.26 U43.J23 ; U16.L3 66.73,128.66 66.83,128.76 v1(66.83,128.76) ; U13.L3 66.73,139.96 v1(67.25,140.47)
FBA_CMD26: length 145
  TOP w0.102: v1(73.54,131.09) 72.34,131.12 70.87,130.95 70.6,130.95 70.51,131.04 70.38,131.17 70.26,131.32 70.26,131.42 70.07,131.61 69.99,131.69 U16.P8 ; U11.P8 36.19,158.18 36.31,158.4 36.39,158.47 36.81,158.74 36.95,158.88 36.96,159.32 36.82,159.94 36.73,160.66 36.73,160.92 v1(36.79,161.81) ; v1(48.66,161.84) 48.62,160.44 48.8,159.15 48.8,158.87 48.64,158.7 48.33,158.53 48.14,158.34 U12.P8 ; v1(73.54,142.96) 72.4,142.97 72.27,142.97 70.87,142.82 70.6,142.82 70.47,142.94 70.26,143.29 70.07,143.48 U13.P8
  TOP w0.178: v1(47.07,142.08) 47.07,142.34 49.62,144.89 53.93,144.89 55.28,146.24 55.28,149.72 56.07,150.5 58.04,150.5 v1(60.86,153.33) 62.42,154.89 62.91,154.89 v1(63.96,155.94) 63.96,157.26 R16.2 R15.1
  IN1 w0.14: v1(36.79,161.81) 36.79,161.84 37.28,162.33 43.26,163.23 43.39,163.26 43.94,163.26 v1(44.02,163.18) 44.38,162.97 44.93,162.97 45.9,163.27 46.11,163.27 46.53,163.69 48.13,163.69 48.77,163.04 48.77,161.96 v1(48.66,161.84) ; v1(74.34,136.65) 74.34,141.25 74.41,141.32 74.41,141.97 74.05,142.33 74.05,142.57 73.66,142.96 v1(73.54,142.96)
  IN3 w0.102: v1(73.54,131.09) 74.38,131.09 74.97,131.68 74.97,133.29 74.43,133.82 74.43,135.42 74.48,135.47 74.48,136.51 v1(74.34,136.65) 74.77,138.45 75.39,142.14 75.41,142.28 75.44,142.48 75.38,142.73 74.93,143.99 74.26,145.87 74.23,145.92 74.22,145.95 74.17,146.02 73.07,147.91 72.91,148.18 72.47,148.92 71.34,150.11 v1(63.96,155.94) 63.37,156.49 60.54,159.18 58.92,160.56 55.46,162.42 50.18,164.77 49.82,164.86 48.64,164.86 47.17,164.22 46.17,163.35 45.6,163.35 44.65,163 44.41,163 v1(44.02,163.18)
  BOTTOM w0.102: U43.J25 47.51,140.25 47.51,141.64 v1(47.07,142.08) ; v1(36.79,161.81) 36.73,160.89 36.73,160.64 36.82,159.93 36.96,159.3 36.93,158.87 36.81,158.74 36.4,158.49 36.3,158.39 36.19,158.18 U11.P8 ; U16.P8 69.99,131.69 70.07,131.61 70.26,131.42 70.26,131.32 70.38,131.17 70.51,131.04 70.6,130.95 70.87,130.95 72.35,131.12 v1(73.54,131.09) ; 48.63,160.87 48.62,160.46 48.8,159.17 48.8,158.87 48.65,158.72 48.33,158.53 48.14,158.34 U12.P8 ; v1(73.54,142.96) 72.4,142.97 72.18,142.97 70.87,142.82 70.6,142.82 70.47,142.94 70.26,143.29 70.07,143.48 U13.P8
  BOTTOM w0.178: v1(48.66,161.84) 48.63,160.87
FBA_CMD27: length 138.4
  TOP w0.102: 48.25,142.22 48.14,142.22 47.54,141.62 v1(47.54,139.46)
  TOP w0.178: v1(44.04,163.79) 43.61,163.79 40.63,160.81 40.63,160.51 v1(40.39,160.27) ; v1(75.9,136.38) 75.52,136.89 74.81,137.38 73.05,138.62 v1(72,139.36) ; 48.25,142.22 48.68,142.65 50.11,144.08 54.2,144.08 56.04,145.92 56.04,148.65 57.13,149.74 57.92,149.74 58.12,149.54 58.12,148.83 57.44,148.15 57.44,147.86 57.69,147.61 57.98,147.61 58.84,148.47 58.84,150.18 59.01,150.35 59.25,150.35 59.42,150.18 59.42,149.67 59.62,149.46 59.84,149.46 60.03,149.65 60.03,150.05 60.23,150.25 60.74,150.25 60.89,150.4 60.89,150.61 60.74,150.76 60.36,150.76 60.16,150.96 60.16,151.44 60.41,151.7 v1(61.55,151.7) 62.52,151.7 62.82,152 62.82,152.51 62.57,152.76 62.01,152.76 61.81,152.97 61.81,153.65 62.62,154.47 63.28,154.47 63.46,154.29 63.46,153.59 63.64,153.4 63.91,153.4 64.09,153.59 64.09,154.11 64.65,154.67 64.65,155.8 v1(65.03,156.18) 64.7,156.52 64.7,156.93 65.72,157.94 R17.1 R18.2
  IN3 w0.102: v1(75.9,136.38) 75.92,136.8 75.94,137.52 76.13,142.92 74.82,146.53 72.92,149.49 71.16,151.62 70.38,152.41 70.19,152.57 66.89,154.8 66.17,155.48 65.74,155.79 v1(65.03,156.18) 61.3,159.5 58.92,161.39 58.81,161.47 56.01,162.96 52.47,164.5 50.11,165.47 48.47,165.47 45.5,164.41 44.15,163.83 v1(44.04,163.79)
  BOTTOM w0.102: v1(44.04,163.79) 44.6,163.84 44.88,163.75 44.98,163.61 45.1,163.32 45.65,159.18 45.65,158.7 45.59,158.09 45.3,156.83 45.3,156.54 45.85,155.99 46.82,155.43 47.71,155.43 U39.M3 ; U44.M3 67.95,132.17 67.95,133.06 68.46,133.57 68.47,133.57 68.57,133.67 71.64,133.67 72.05,133.82 72.65,134.04 74.56,134.73 75.09,134.92 75.38,135.1 75.58,135.6 v1(75.9,136.38) ; v1(72,139.36) 71.54,139.92 71.54,140.55 71.52,140.64 71.3,140.86 71.26,140.87 70.19,141.13 70.16,141.14 70.16,141.15 70.13,141.16 69.75,141.34 69.66,141.4 67.96,142.72 U41.M3 ; v1(47.54,139.46) 47.14,139.06 U43.J24 ; U38.M3 36.9,155.98 37.16,156.24 38.87,158.72 38.94,159.47 39.18,159.7 39.38,159.7 39.8,159.83 v1(40.39,160.27)
FBA_CMD28: length 111.6
  TOP w0.102: U11.L7 36.78,154.82 37.37,154.82 37.8,155.26 v1(37.8,155.44) ; U13.L7 66.73,142.21 v1(67.22,141.72) ; v1(49,155.03) 49.08,155.11 49.08,155.39 49.01,155.46 48.44,155.46 48.32,155.33 48.32,155.15 U12.L7 ; U16.L7 66.73,131.08 66.38,130.72 66.38,130.58 66.52,130.43 66.85,130.43 v1(67.03,130.61)
  IN1 w0.14: v1(58.3,159.99) 58.3,158.97 56.65,157.31 56.65,151.9 56.19,151.45 v1(56.19,149.98) ; v1(67.22,141.72) 66.74,141.25 66.74,140.35 67.24,139.86 67.24,136.44 67.24,136.44 v1(67.24,135.4) 67.24,134.51 67.83,133.92 67.83,132.17 67.7,132.05 67.27,132.05 67.14,131.92 67.14,131.66 67.27,131.54 67.7,131.54 67.83,131.41 67.83,131.16 67.7,131.03 67.22,131.03 67.07,130.88 67.07,130.65 v1(67.03,130.61) ; v1(43.48,155.63) 43.59,155.52 44.07,155.52 44.17,155.42 44.88,155.42 45.05,155.25 47.08,155.25 47.25,155.43 47.58,155.43 47.76,155.25 47.99,155.25 48.07,155.33 48.07,155.62 48.21,155.76 48.37,155.76 48.52,155.61 48.52,155.36 48.61,155.27 48.87,155.27 49,155.13 v1(49,155.03)
  IN3 w0.102: v1(37.8,155.44) 37.68,155.44 37.55,155.3 37.55,155.06 37.63,154.98 39.31,154.98 39.59,155.08 40.16,155.38 42.88,155.38 43.13,155.63 v1(43.48,155.63) 43.59,155.52 44.04,155.52 44.15,155.41 46.52,155.41 46.95,155.84 47.12,155.84 47.55,155.41 48.38,155.41 49.16,156.19 49.42,156.19 49.61,156.38 49.77,156.38 49.92,156.53 49.92,156.76 50.02,156.86 50.2,156.86 50.3,156.76 50.3,156.53 50.4,156.43 50.61,156.43 50.82,156.22 50.96,156.22 51.72,155.46 51.72,154.96 51.85,154.83 51.95,154.83 52.08,154.96 52.08,155.36 52.14,155.42 52.34,155.42 52.43,155.33 52.43,154.93 52.54,154.83 52.69,154.83 52.79,154.93 52.79,155.08 52.92,155.2 53.11,155.2 55.1,153.21 55.1,153.1 55.64,152.57 55.64,150.92 55.22,150.5 55.22,150.37 55.31,150.27 55.42,150.27 55.73,150.58 55.9,150.58 56.01,150.47 56.01,150.38 55.71,150.07 55.71,149.88 55.83,149.76 55.98,149.76 v1(56.19,149.98) 57.73,148.36 57.99,147.99 58.37,147.69 60.41,146.67 61.02,146.67 61.56,146.69 61.92,146.67 64.76,145.44 65.74,144.81 65.98,144.52 66.51,141.84 66.51,141.02 65.95,140.46 65.95,138.54 66.62,137.87 66.62,136.64 67.21,136.05 67.21,135.43 v1(67.24,135.4)
  BOTTOM w0.102: U11.L7 36.78,154.82 37.37,154.82 37.8,155.26 v1(37.8,155.44) ; v1(49,155.03) 49.08,155.11 49.08,155.39 49.01,155.46 48.44,155.46 48.32,155.33 48.32,155.15 U12.L7 ; v1(67.22,141.72) 66.73,142.21 U13.L7 ; v1(67.03,130.61) 66.85,130.43 66.52,130.43 66.38,130.58 66.38,130.72 66.73,131.08 U16.L7
  BOTTOM w0.178: R456.2 57.68,159.75 R454.1 58.18,160.11 v1(58.3,159.99) ; U43.K27 46.19,141.59 46.19,142.38 47.17,143.37 47.93,143.37 49.89,145.32 53.75,145.32 54.95,146.53 54.95,148.73 v1(56.19,149.98)
FBA_CMD29: length 127.9
  TOP w0.102: U16.M2 67.34,127.47 67.04,127.47 66.94,127.57 66.94,127.78 67.09,127.93 67.09,128.26 67.24,128.41 67.24,128.99 67.8,129.55 67.8,130.03 v1(67.69,130.14) ; U12.M2 52.59,155.68 52.59,155.44 52.51,155.36 51.48,155.36 51.25,155.59 50.12,155.59 50.07,155.54 49.89,155.54 49.8,155.64 v1(49.8,155.95) ; v1(38.59,156.5) 38.59,156.1 38.74,155.95 39.35,155.95 39.63,156.23 40.88,156.23 41.01,156.1 41.01,155.93 40.88,155.8 U11.M2 ; v1(68.69,141.04) 68.69,141.29 68.49,141.49 68.11,141.49 67.95,141.34 67.95,139.23 67.88,139.15 U13.M2
  TOP w0.178: v1(46.72,140.24) 46.72,140.22 46.71,140.24 46.71,140.25 46.06,140.9 46.06,142.42 49.3,145.65 53.61,145.65 54.47,146.51 54.47,150.25 55.56,151.35 v1(56.77,151.35) 57.79,151.35 58.56,152.11 58.56,153.02 58.94,153.4 R48.2 59.31,153.75 59.78,154.22 59.78,154.8 58.94,155.63 R35.1
  IN1 w0.14: v1(49.8,155.95) 48.95,156.79 47.78,156.79 47.45,156.46 46.83,156.46 46.65,156.28 45.47,156.28 44.94,156.81 v1(43.99,156.81) ; v1(68.69,141.04) 68.69,141.24 68.54,141.39 68.28,141.39 68.16,141.26 68.16,140.17 67.92,139.93 67.92,136.79 68.51,136.2 v1(68.51,135.85) 68.51,135.04 68.27,134.79 68.27,131.95 68.41,131.81 68.64,131.81 68.77,131.68 68.77,131.22 v1(67.69,130.14)
  IN3 w0.102: v1(68.51,135.85) 68.39,135.97 68.39,136.6 67.96,137.04 67.96,142.63 67.84,143.37 67.66,144.3 67.5,144.76 67.11,145.11 67,145.25 66.7,145.7 66.14,146.33 65.95,146.61 65.89,146.67 65.36,146.9 64.47,147.19 64.27,147.19 63.68,147.17 63.33,147.19 63.33,147.19 63.17,147.2 60.61,147.36 59.84,147.75 59.16,148.07 58.69,148.59 58.05,149.53 v1(56.77,151.35) 56.77,151.16 56.65,151.04 56.4,151.04 56.27,151.16 56.27,151.47 56.52,151.72 56.52,151.98 56.27,152.23 56.27,153.46 56.12,153.78 55.75,154.15 55.75,154.67 55.61,154.91 54.09,156.34 52.59,156.34 52.47,156.45 52.47,157.29 52.39,157.37 51.72,157.37 51.6,157.49 51.6,157.75 51.52,157.83 48.93,157.83 48.64,157.54 48.49,157.54 48.29,157.74 48.13,157.74 48.02,157.62 48.02,157.44 48.19,157.26 48.19,157.09 47.91,156.81 47.76,156.81 47.66,156.91 47.66,157.49 47.54,157.61 47.37,157.61 47.25,157.49 47.25,156.91 47.15,156.8 47,156.8 46.9,156.91 46.9,157.39 46.81,157.48 46.61,157.48 46.52,157.39 46.52,157.21 46.44,157.13 45.42,157.13 45.3,157.01 45.3,156.51 45.2,156.4 44.99,156.4 44.89,156.51 44.89,156.73 44.8,156.81 v1(43.99,156.81) 43.87,156.93 43.52,156.93 43.44,156.85 43.44,156.5 43.29,156.35 42.99,156.35 42.63,155.99 39.84,155.99 39.34,156.49 39.18,156.49 38.91,156.22 38.7,156.22 38.59,156.33 v1(38.59,156.5)
  BOTTOM w0.102: v1(38.59,156.5) 37.93,156.5 37.22,155.79 37.22,155.58 37.04,155.4 35.91,155.4 35.8,155.51 U38.M2 ; U39.M2 48.07,156.2 48.66,156.2 49.44,156.98 49.62,156.98 49.75,156.85 49.75,156.66 49.56,156.47 49.56,156.18 v1(49.8,155.95) ; v1(46.72,140.24) 46.34,139.86 U43.K25 ; U44.M2 67.36,132.08 67.12,131.84 67.12,131.11 67.32,130.9 68.03,130.9 68.34,130.6 68.34,130.29 68.18,130.14 v1(67.69,130.14) ; v1(68.69,141.04) 68.69,141.52 67.17,143.04 67.17,143.59 U41.M2
FBA_CMD30: length 123
  TOP w0.102: U11.M3 40.68,155.4 41.58,155.4 42.66,156.47 43.94,160.85 44.33,161.43 v1(46,163.76) 47.26,160.48 47.26,160.11 47.25,160.11 47.25,157.45 47.34,156.51 47.38,156.43 47.53,156.27 48.61,156.27 48.66,156.29 49.05,156.45 50.39,156.5 50.63,156.37 51.56,155.85 U12.M3 ; v1(68.16,129.27) 68.11,129.22 68.11,128.55 67.64,128.08 U16.M3 ; U13.M3 67.19,139.34 67.19,138.11 68.4,136.9 71.48,136.9 72.99,135.38 v1(75.03,135.38)
  IN1 w0.14: v1(68.16,129.27) 68.28,129.4 68.75,129.4 69.25,129.86 71.96,132.33 74.72,135.07 v1(75.03,135.38)
  IN3 w0.102: v1(46,163.76) 46.88,164.42 48.53,165.17 50.03,165.17 50.25,165.08 55.58,162.8 58.58,161.19 59.18,160.75 61.05,159.24 64.59,156 65,155.7 65.32,155.46 v1(66.03,154.92) 67.14,154.03 70.08,152.09 70.54,151.64 72.6,149.34 74.44,146.42 74.64,146 75.77,142.78 75.71,141.23 75.63,138.06 75.5,136.47 75.48,135.92 75.34,135.68 75.03,135.39 v1(75.03,135.38)
  BOTTOM w0.178: U43.J27 46.95,141.46 46.57,141.84 46.57,142.22 47.08,142.73 47.84,142.73 50.05,144.94 53.9,144.94 55.33,146.37 55.33,148.19 56.41,149.28 57,149.28 60.13,152.41 60.13,152.92 60.25,153.04 62.64,154.42 63.08,154.46 64.53,154.47 v1(66.03,154.92) 65,153.89 R471.1 64.79,153.72 65.88,152.63 R477.2
FBA_ZQ0: length 9.9
  IN1 w0.254: v1(67.68,128.69) 66.13,127.14 66.13,124.32 65.34,123.54 v1(64.14,123.54)
  BOTTOM w0.18: v1(67.68,128.69) 67.45,128.69 67.1,128.34 67.1,127.65 U44.L8
  BOTTOM w0.254: R562.1 v1(64.14,123.54)
FBA_ZQ1: length 12.8
  BOTTOM w0.102: R498.1 73.04,138.15 71.76,136.87 65.29,136.87 65.03,137.13 65.03,137.77 65.28,138.01 66.18,138.01 66.33,138.17 66.33,138.45 66.73,138.85 U41.L8
FBA_ZQ2: length 16.6
  TOP w0.203: U16.L8 66.73,132.3 66.34,132.69 66.34,133.02 65.21,134.15 v1(65.21,134.51) ; v1(65.29,124.25) 65.29,123.79 64.41,122.91 R121.1
  IN2 w0.203: v1(65.21,134.51) 65.49,134.23 65.49,133.21 64.86,132.57 64.86,129.9 65.11,129.65 65.11,128.89 66.25,127.75 66.25,125.21 v1(65.29,124.25)
FBA_ZQ3: length 6.3
  TOP w0.18: 66.34,145.14 66.34,144.59 66.73,144.19 U13.L8
  TOP w0.3: R62.1 67.37,148.98 v1(67.37,147.94) 67.37,146.24 66.34,145.21 66.34,145.14
FBA_ZQ4: length 4.9
  BOTTOM w0.18: U39.L8 52.75,155 53.14,154.6 54.56,154.6 55.18,153.98 55.87,153.98 R466.1
FBA_ZQ5: length 14.1
  TOP w0.14: R8.1 v1(32.39,158.97)
  IN3 w0.102: v1(32.39,158.97) 33.03,158.33 33.03,156.67 34.21,155.49 36.59,155.49 38.55,157.45 v1(38.74,157.45)
  BOTTOM w0.102: U38.L8 40.55,155 40.14,155.41 40.14,156.05 40.01,156.18 39.51,156.18 38.74,156.94 v1(38.74,157.45)
FBA_ZQ6: length 16.5
  TOP w0.102: v1(44.81,153.63) 45.83,153.63 46.85,154.65 47.13,154.65 47.48,155 U12.L8
  TOP w0.14: R46.1 56.6,154.54 v1(55.33,154.54)
  IN2 w0.152: v1(44.81,153.63) 45.72,154.54 47.58,154.54 48.6,155.56 49.31,155.56 50.33,154.54 v1(55.33,154.54)
FBA_ZQ7: length 4.7
  TOP w0.18: 34.62,154.61 35.17,154.61 35.56,155 U11.L8
  TOP w0.3: 34.62,154.61 31.6,154.61 R43.1
FBVDDQ_EN: length 96
  TOP w0.14: PR60.1 67.88,77.86 67.27,78.47 67.27,81.14 67.75,81.62 68.39,81.62 69.43,82.66 69.43,90.71 v2(69.73,91.02) ; v1(22.16,116.29) 21.68,115.81 20.41,115.81 19.71,115.11 PR34.1 ; U21.4 38.45,105.92 38.31,105.77 R197.2 37.05,105.14 v1(36.28,105.14) 35.77,104.63 35.77,104 36.15,103.62 36.92,103.62 37.22,103.31 38.87,103.31 39.25,102.93 39.25,101.15 v1(39.71,100.69) 43.77,100.69 44.66,101.58 R218.1
  IN3 w0.14: v2(69.73,91.02) 69.99,91.27 69.99,95.31 69.22,96.08 69.22,98.9 67.55,100.57 56.96,100.57 56.78,100.39 53.09,100.39 52.41,101.08 40.09,101.08 v1(39.71,100.69)
  BOTTOM w0.14: v1(36.28,105.14) 35.52,104.38 32.72,104.38 26.01,111.09 26.01,113.12 22.84,116.29 v1(22.16,116.29)
G_MBCLK: length 3.1
  TOP w0.14: TP96.1 157.21,65.9 156.64,65.33 U32.94
G_MBCLK_R: length 3.2
  BOTTOM w0.14: R755.2 R754.1 219.03,55.36 v1(218.91,55.23) 218.53,54.86 U54.4
G_MBDATA: length 3.4
  TOP w0.14: U32.95 156.65,65.73 157.2,66.28 157.82,66.28 TP95.1
G_MBDATA_R: length 3.1
  BOTTOM w0.14: U54.6 217.07,53.38 v1(217.38,53.07) R760.1 R761.2
GC6_FB_EN: length 144.5
  TOP w0.14: R199.1 43.78,105.89 43.52,106.16 43.15,106.16 v1(42.76,106.54) 42.18,107.12 38.24,107.12 R189.2
  IN2 w0.114: v1(74.63,103.74) 76.54,101.84 83.27,101.84 84.03,102.6 87.21,102.6 90.51,105.9 91.78,105.9 95.84,109.97 95.84,111.19 100.34,115.68 102.07,115.68 102.21,115.82 105.61,115.82 106.96,117.18 109.49,117.18 109.64,117.03 110.3,117.03 110.61,117.34 116.32,117.34 116.77,117.78 116.77,118.32 117.21,118.76 131.23,118.76 133.28,120.82 136.64,120.82 136.83,121.01 138.87,121.01 139.35,121.49 139.35,122.99 140.95,124.6 143.93,124.6 145.37,126.04 147.2,126.04 148.65,127.49 151.29,127.49 v1(151.82,128.03)
  IN3 w0.089: v1(74.63,103.74) 74.51,103.62 71.59,103.62 69.83,105.37 65.77,105.37 64.86,106.28 60.66,106.28 59.39,107.55 48.09,107.55 47.58,107.04 43.27,107.04 v1(42.76,106.54)
  BOTTOM w0.076: U45.J4 143.25,124.68 143.64,124.68 143.68,124.64 145.04,124.64 145.29,124.89 145.41,124.89 145.62,125.09
  BOTTOM w0.089: 145.62,125.09 145.87,125.34 146.4,125.34 147.7,126.64 147.7,127.17 148.41,127.89 148.53,127.89
  BOTTOM w0.14: R531.1 R535.2 152.23,127.62 v1(151.82,128.03) 151.65,128.2 151.01,128.2 150.67,127.86 148.56,127.86 148.53,127.89
