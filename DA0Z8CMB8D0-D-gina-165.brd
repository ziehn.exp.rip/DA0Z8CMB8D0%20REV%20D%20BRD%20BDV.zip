# Allegro board DA0Z8CMB8D0-D-gina-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPIO4: length 7.8
  BOTTOM w0.076: 144.98,126.97 144.54,126.97 144.18,126.6 U45.F2
  BOTTOM w0.089: 147.53,130.41 147.51,130.39 146.92,130.39 145.58,129.05 145.58,128.51 145.5,128.43 145.5,127.49 144.98,126.97
  BOTTOM w0.14: 147.53,130.41 147.79,130.67 148.68,130.67 R524.1
GPIO5: length 9.7
  BOTTOM w0.076: 145.25,126.48 145.08,126.31 143.78,126.31 U45.F3
  BOTTOM w0.089: 147.79,130.03 147.79,129.59 147.09,128.89 146.64,128.89 145.86,128.1 145.86,127.34 145.25,126.73 145.25,126.48
  BOTTOM w0.14: 147.79,130.03 147.79,130.16 148.04,130.41 149.45,130.41 R525.1
GPIO6: length 7.1
  TOP w0.14: R98.1 147.2,128.89 v1(146.49,128.18)
  BOTTOM w0.076: U45.G4 143.18,126.2 143.63,126.2 143.68,126.14 145.19,126.14 145.42,126.38 145.42,126.65 146.06,127.29 146.06,127.75 v1(146.49,128.18)
GPIO7: length 5.4
  TOP w0.14: R94.1 147.78,129.4 v1(147.15,129.4) 146.59,129.4 v1(145.98,128.79)
  BOTTOM w0.089: U45.F1 144.9,126.64 145.68,127.42 145.68,128.3 145.98,128.61 v1(145.98,128.79)
GPIO8: length 208.4
  TOP w0.14: R213.1 152.14,103.72 152.14,105.36 151.6,105.9 149.16,105.9 146.07,108.99 v1(146.07,109.01)
  IN1 w0.114: v1(76.41,97.32) 76.41,95.08 74.65,93.32 73.99,93.32 71.65,90.98 71.65,88.49 67.16,84 67.16,80.54 66.22,79.61 66.22,78.23 65.81,77.82 65.81,77.46 62.82,74.47 62.82,69.83 63.5,69.16 63.5,65.35 64.63,64.22 64.63,55.76 64.61,55.74 64.61,55.15 65.3,54.45 66.47,54.45 66.81,54.11 70.49,54.11 72.96,51.64 76.43,51.64 76.84,52.05 76.84,52.69 77.26,53.1 79.7,53.1 80.22,52.58 81.17,52.58 81.46,52.29 87.88,52.29 88.23,52.64 111.06,52.64 113.55,50.14 117.25,50.14 118.84,51.74 126.48,51.74 129.17,54.42 129.17,55.08 130.09,56 132.76,56 135.47,58.71 137.15,60.4 137.15,64.89 136.62,65.43 136.62,72.51 140.29,76.18 141.56,76.18 142.99,77.62 142.99,86.67 145.94,89.62 145.94,94.21 143.9,96.25 v1(143.9,98.79)
  IN2 w0.114: v1(143.9,98.79) 144.57,99.46 144.57,104.59 145.5,105.52 145.5,108.7 145.82,109.01 v1(146.07,109.01)
  BOTTOM w0.076: U45.AU2 144.33,109.43 144.65,109.75 145.02,109.75 145.75,109.01 v1(146.07,109.01)
  BOTTOM w0.14: v1(76.41,97.32) 76.41,102.35 75.9,102.85 73.16,102.85 72.05,103.96 CN7.1
GPIO12_ACIN: length 12.1
  TOP w0.14: v1(51.7,124.56) 52.42,124.56 54.06,122.92 v1(54.06,120) 54.06,119.24 Q10.1 54.38,117.9 54.38,115.63 R169.1
  BOTTOM w0.102: U43.D7 v1(51.7,124.56)
GPIO15: length 15.1
  TOP w0.14: R146.2 154.14,119.11 153.88,118.86 152.86,118.86 R140.1 152.35,118.78 152.14,118.57 148.64,118.57 148.04,117.97 147.46,117.97 146.95,117.46 143.09,117.46 142.55,117.99 142.19,117.99 v1(141.74,117.55)
  BOTTOM w0.102: v1(141.74,117.55) 141.54,117.34 U45.AD6
GPIO24: length 27.2
  TOP w0.14: v1(153.88,120.63) 154.13,120.63 R138.1 ; v1(142.37,117.55) 142.62,117.55 142.96,117.2 145.12,117.2 145.63,116.7 TP60.1
  IN1 w0.102: v1(142.37,117.55) 144.1,117.55 144.91,116.74 145.94,116.74 146.67,116.01 146.72,116.01
  IN1 w0.114: 146.72,116.01 149.06,116.01 149.52,116.47 150.83,116.47 151.22,116.86 151.22,119.24 151.52,119.54 151.97,119.54 152.63,118.88 152.63,117.51 153.06,117.08 154.39,117.08 154.8,117.48 154.8,120.23 154.39,120.63 v1(153.88,120.63)
  BOTTOM w0.102: U45.AD5 142.37,117.25 v1(142.37,117.55)
GPIO25: length 27.1
  TOP w0.14: R206.2 157.01,104.12 v1(156.88,104)
  IN1 w0.114: v1(147.76,112.73) 147.76,109.33 147.98,109.11 147.98,108.75 149.64,107.08 152.09,107.08 154.01,109 155.8,109 156.21,108.6 156.21,106.32 157.3,105.23 157.3,104.42 v1(156.88,104)
  BOTTOM w0.076: U45.AM4 143.18,112.71 143.65,112.71 143.71,112.66 144.47,112.66 144.63,112.82 144.94,112.82 145.16,113.04 145.86,113.04 145.99,112.91 146.24,112.91
  BOTTOM w0.14: TP142.1 148.5,112.38 148.12,112.38 v1(147.76,112.73) 147.28,112.25 147.02,112.25 146.37,112.91 146.24,112.91
GPIO28: length 24.4
  TOP w0.14: R204.2 153.37,106.03 152.31,107.1 149.63,107.1 147.91,108.82 147.91,109.2 147.6,109.52 146.83,109.52 146.37,109.98 145.88,109.98 145.58,110.28 145.58,111.34 146.29,112.05 146.29,112.79 146.39,112.89 TP77.1 146.26,113.65 146.26,114.36 147.02,115.12 147.02,115.68 146.77,115.93 145.98,115.93 144.97,116.95 142.82,116.95 142.65,117.12 141.54,117.12 v1(141.12,117.55)
  BOTTOM w0.102: U45.AD7 140.89,117.32 v1(141.12,117.55)
GPIO36: length 14.5
  TOP w0.14: R134.2 152.48,120.9 151.04,122.34 TP36.1 148.74,122.34 148.29,122.79 R120.1 147.89,123.19 145.62,123.19 145.09,122.67 145.09,122.12 144.27,121.3 144.27,120.78 144.05,120.56 143,120.56 142.71,120.84 142.2,120.84 v1(141.77,120.4)
  BOTTOM w0.102: U45.V6 141.54,120.17 v1(141.77,120.4)
GPIO37: length 14.8
  BOTTOM w0.076: U45.AC1 145.01,117.61 145.16,117.46 146,117.46 146.39,117.84 146.39,118.5 146.52,118.63 146.52,118.91 146.68,119.07 146.76,119.15 147.09,119.15 147.33,118.9 147.33,118.42 147.53,118.22 147.65,118.22 148.14,117.73 150.02,117.73
  BOTTOM w0.14: 150.02,117.73 151.51,117.73 151.57,117.67 152.67,117.67 R599.2 154.13,116.95 R595.1 155.14,116.95 155.94,116.95 TP134.1
GPIO44: length 19.9
  TOP w0.14: v1(145.4,114.25) 145.4,113.04 144.76,112.4 144.76,109.43 TP82.1 145.33,108.87 145.33,108.23 146.06,107.5 146.44,107.5 148.83,105.11 149.8,105.11 150.61,104.31 150.61,103.03 151.6,102.04 R231.2
  BOTTOM w0.076: U45.AK4 143.19,114.22 143.62,114.22 143.68,114.15 144.36,114.15 144.53,114.32 145.36,114.32 145.4,114.28 v1(145.4,114.25)
GPIO45: length 19
  TOP w0.14: v1(142.44,115.67) 142.57,115.79 144.98,115.79 145.12,115.93 145.63,115.93 146.14,115.43 TP70.1 ; v1(143.6,104.38) 143.59,104.39 R209.2
  IN3 w0.089: v1(142.44,115.67) 142.47,115.67 142.71,115.43 143.95,115.43 144.22,115.15 144.22,114.55 144.62,114.16 144.62,111.68 144.2,111.26 144.2,110.32 143.6,109.71 v1(143.6,104.38)
  BOTTOM w0.102: U45.AG5 142.19,115.41 v1(142.44,115.67)
GPIO47: length 10.5
  TOP w0.14: R141.2 150.32,119.23 149.92,118.83 148.56,118.83 147.94,118.21 146.94,118.21 TP51.1 146.43,117.7 144.9,117.7 144.13,118.47 143.34,118.47 142.89,118.92 142.12,118.92 v1(141.69,118.5)
  BOTTOM w0.102: v1(141.69,118.5) 141.54,118.35 U45.AB6
GPIO56: length 18.3
  TOP w0.14: v1(141.83,115.64) 142.28,115.19 142.72,115.19 143.08,115.55 144.23,115.55 TP74.1 ; v1(142.83,105.14) 142.08,104.39 R208.2
  IN3 w0.089: v1(141.83,115.64) 141.83,115.54 142.2,115.17 142.45,115.17 142.76,114.87 142.76,114.36 142.83,114.28 143.98,114.28 144.43,113.83 144.43,111.76 143.17,110.5 143.17,105.6 142.83,105.27 v1(142.83,105.14)
  BOTTOM w0.102: U45.AG6 141.54,115.35 v1(141.83,115.64)
GPIO57: length 8.1
  BOTTOM w0.089: U45.AP1 144.82,110.8 145.34,110.29 145.34,110.18 145.76,109.76 146.47,109.76 146.87,109.36 146.87,108.85 147.33,108.39 147.91,108.39
  BOTTOM w0.14: R648.2 150.33,106.66 149.82,107.17 149.23,107.17 TP143.1 148.01,108.39 147.91,108.39
GPIO58: length 12
  TOP w0.14: R203.1 148,104.38 146.21,106.17 TP81.1 146.11,106.59 144.23,108.47 144.23,111.46 144.26,111.49 144.26,112.44 143.21,113.49 v1(143.17,113.49)
  BOTTOM w0.102: U45.AL4 142.87,113.19 v1(143.17,113.49)
GPIO59: length 8.4
  TOP w0.14: v1(142.5,110.55) 142.71,110.34 142.71,110.09 143.21,109.58 TP83.1 143.21,108.43 144.87,106.78 144.87,106.23 145.88,105.22 145.88,104.51 R202.2
  BOTTOM w0.102: v1(142.5,110.55) 142,110.05 U45.AT5
GPIO64: length 7.4
  BOTTOM w0.076: U45.E3 143.93,126.98 144.33,126.98 144.48,127.13 144.89,127.13 145.33,127.57 145.33,128.51 145.41,128.6 145.41,129.16 145.89,129.64
  BOTTOM w0.14: 145.89,129.64 147.41,131.17 R523.1
GPIO65: length 21.7
  TOP w0.14: R97.1 156.46,130.26 156.46,132.25 154.86,133.84 151.32,133.84 150.98,133.5 150.98,132.95 150.97,132.95 150.97,132.26 150.97,132.06 150.12,131.21 148.32,131.21 146.87,129.77 146.21,129.77 145.02,128.57 145.02,128.41 144.23,127.62 144.23,127.16 v1(143.87,126.81) 143.39,126.81 v1(143.21,126.98)
  BOTTOM w0.14: v1(143.21,126.98) 142.87,126.64 U45.F4
GPIO66: length 10.7
  BOTTOM w0.076: U45.D3 143.84,128.36 143.84,128.95 144.06,129.17 144.48,129.17 144.73,129.41 145,129.41
  BOTTOM w0.14: 145,129.41 147.43,131.84 147.43,132.32 147.66,132.55 R516.1 R517.2 148.68,133.59 148.17,134.1 148.17,135.24 v1(148.29,135.37)
GPIO67: length 8.6
  TOP w0.14: R92.1 146.61,130.26 145.86,130.26 144.99,129.4 v1(143.85,129.4) 143.24,129.4 142.45,128.61 142.45,128.03 v1(142.6,127.87)
  BOTTOM w0.14: v1(142.6,127.87) 142.87,127.6 U45.E4
GPIO68: length 7.6
  TOP w0.14: v1(144.41,130.57) 144.87,130.11 145.32,130.11 145.75,130.54 146.14,130.54 148.29,132.69 R91.1
  BOTTOM w0.076: v1(144.41,130.57) 144.41,130.21 143.9,129.7 143.9,129.24 143.52,128.86 U45.C3
GPIO69: length 9.4
  BOTTOM w0.076: U45.E2 144.17,127.37 144.69,127.88 145,127.88 145.14,128.03 145.14,128.6 145.25,128.7 145.25,129.32 145.6,129.68
  BOTTOM w0.14: R520.1 149.93,132.95 148.5,132.95 147.66,132.11 147.66,131.73 145.6,129.68
GPIO84: length 15.5
  TOP w0.14: R108.1 150.14,127.06 150.14,127.56 149.31,128.38 147.41,128.38 146.77,127.75 145.3,127.75 145.17,127.62 v1(145.2,127.62) 144.52,126.94 144.52,126.85 143.99,126.32 143.37,126.32 142.76,125.72 142.76,125.01 143.64,124.14 143.64,123.79 143.39,123.54 143.04,123.54 142.87,123.7 141.65,123.7 v1(141.16,124.19)
  BOTTOM w0.14: v1(141.16,124.19) 141.54,123.81 U45.L6
GPIO85: length 27.5
  TOP w0.14: R158.1 162.68,117.59 v1(162.09,118.19)
  IN1 w0.114: v1(141.79,123.28) 142.27,122.79 142.58,122.79 142.83,123.05 143.34,123.05 143.72,123.43 146.95,123.43 147.2,123.68 147.91,123.68 148.42,124.19 148.42,124.52 149.11,125.21 149.94,125.21 150.15,125 152.69,125 152.97,125.28 154.57,125.28 156.03,123.82 157,123.82 157.27,123.54 157.27,122.55 157.83,121.99 158.83,121.99 161.68,119.14 161.68,118.45 161.94,118.19 v1(162.09,118.19)
  BOTTOM w0.14: U45.N6 141.54,123.02 v1(141.79,123.28)
GPIO86: length 28.9
  TOP w0.14: v1(140.53,123.25) 140.73,123.45 140.73,124.37 140.98,124.62 141.99,124.62 142.33,124.95 142.33,125.84 142.79,126.3 142.79,127.16 143.2,127.57 143.45,127.57 v1(143.98,128.1) 144.2,128.1 146.11,130.01 146.77,130.01 148.22,131.45 150.02,131.45 150.73,132.16 150.73,133.62 151.2,134.1 154.95,134.1 156.7,132.35 156.7,131.15 R93.1 157.74,130.11 157.74,129.05 R99.2
  BOTTOM w0.14: v1(140.53,123.25) 140.24,123.55 U45.L8
GPIO87: length 10.1
  TOP w0.14: v1(141.11,122.31) 141.59,122.79 142.61,122.79 142.83,123.02 143.56,123.02 144.12,123.58 144.12,124.94 144.78,125.6 146.27,125.6 146.62,125.94 v1(147.33,125.94) 148.18,125.94 R110.1
  BOTTOM w0.14: U45.R7 140.89,122.09 v1(141.11,122.31)
GPIO88: length 30.7
  TOP w0.14: v1(162.11,118.8) 162.55,119.24 164.55,119.24 166.07,117.71 R157.1
  IN1 w0.114: v1(162.11,118.8) 162.11,119.04 158.92,122.23 157.9,122.23 157.49,122.64 157.49,123.66 157.12,124.03 156.12,124.03 154.66,125.5 152.88,125.5 152.6,125.22 150.24,125.22 150.03,125.43 149.02,125.43 148.17,124.57 147.44,124.57 147.24,124.37 146.57,124.37 146.01,123.81 143.72,123.81 143.34,123.43 143.09,123.43 142.83,123.68 142.3,123.68 v1(141.79,124.19)
  BOTTOM w0.14: U45.L5 142.19,123.79 v1(141.79,124.19)
GPIO89: length 30.3
  TOP w0.14: R155.1 159.33,117.59 158.53,118.4 158.53,119.54 158.05,120.02 v1(157.9,120.02)
  IN1 w0.114: v1(157.9,120.02) 157.87,120.02 156.56,121.34 155.72,121.34 155.55,121.5 155.55,122.01 155.37,122.19 155.02,122.19 153.62,123.59 152.91,123.59 152.58,123.92 151.4,123.92 151.22,123.73 151.22,123.04 150.93,122.76 150.24,122.76 149.86,122.38 149.52,122.38 149.08,122.82 147.81,122.82 146.77,121.78 146.39,121.78 145.5,120.89 144.87,120.89 144.48,120.51 142.96,120.51 142.58,120.89 140.29,120.89 140.06,121.12 140.06,122.56 140.29,122.79 140.7,122.79 v1(141.17,123.26)
  BOTTOM w0.14: v1(141.17,123.26) 140.89,122.98 U45.N7
GPIO90: length 11.2
  BOTTOM w0.076: 146.64,125.33 146.35,125.04 146.35,124.69 145.72,124.06 144.49,124.06 144.19,124.35 U45.K2
  BOTTOM w0.089: 148.55,127.62 148.4,127.62 147.89,127.11 147.89,126.58 146.64,125.33
  BOTTOM w0.14: R539.1 152.6,126.69 151.96,127.33 151.84,127.33 151.47,127.7 v1(151.22,127.7) 151.14,127.62 148.55,127.62
GPIO91: length 5.5
  BOTTOM w0.076: U45.J1 145.03,125.1 145.15,125.22 145.26,125.22 145.26,125.23
  BOTTOM w0.089: R533.1 148.29,128.26 148.23,128.2 148.23,128.19 147.28,127.24 147.28,126.73 146.26,125.71 145.75,125.71 145.26,125.23
GPIO92: length 26.4
  TOP w0.14: R159.1 163.31,118.2 v1(162.95,118.2)
  IN1 w0.114: v1(143.21,123.96) 143.28,124.02 145.92,124.02 146.53,124.63 146.53,124.89 146.92,125.28 147.23,125.28 148.21,126.26 149.86,126.26 150.68,125.43 152.51,125.43 152.8,125.71 154.75,125.71 156.21,124.25 157.25,124.25 162.54,118.96 162.54,118.6 v1(162.95,118.2)
  BOTTOM w0.14: v1(143.21,123.96) 143.21,124.08 U45.K3
GPIO93: length 12.2
  BOTTOM w0.076: 145.31,125.52 145.18,125.39 144.47,125.39 U45.J2
  BOTTOM w0.089: 145.31,125.52 145.7,125.92 146.21,125.92 147.09,126.79 147.09,127.3 147.79,128 147.79,128.83 148.11,129.16 148.29,129.16
  BOTTOM w0.14: 148.29,129.16 151.35,129.16 152.1,129.9 R529.1 152.35,129.91 v1(151.47,130.79)
GPIO94: length 5.7
  BOTTOM w0.089: U45.G1 145.14,125.85 145.63,126.34 145.63,126.6 147.28,128.25 147.28,128.83 148.29,129.83 R527.1
GPO_NC: length 3.5
  TOP w0.14: R287.1 222.72,80.88 222.08,81.52 221.95,81.52 v1(221.32,82.15) 220.76,82.71 U24.50
GPU_EVENT#: length 39.6
  TOP w0.14: v1(40.32,106.44) 36.25,106.44 35.52,107.17 35.14,107.17 v1(34.88,107.43) 34.88,107.68 33.91,108.65 R182.1 R178.1 33.91,111.07 33.61,111.36 Q13.1
  BOTTOM w0.102: 54.7,119.24 54.7,121.51 53.74,122.46 U43.A4
  BOTTOM w0.14: v1(40.32,106.44) 40.32,106.97 41.23,107.88 41.23,109.08 42.05,109.89 43.59,109.89 44.04,110.35 46.03,110.35 46.55,109.82 49.09,109.82 50.38,111.11 51.52,111.11 52.41,112 52.41,112.63 52.02,113.02 R630.1 52.39,113.77 52.39,115.97 52.94,116.52 52.94,117.16 54.68,118.9 54.68,119.14 54.7,119.16 54.7,119.24
GPU_GPIO16: length 10.6
  BOTTOM w0.102: U43.D5 50.96,122.97 50.96,122.48 50.54,122.06 50.2,122.06 50.02,121.89 50.02,120.92 49.94,120.84 49.94,119.11
  BOTTOM w0.14: 49.94,119.11 49.94,118.47 49.31,117.84 46.97,117.84 TP136.1
GPU_PEX_RST_HOLD#: length 8.6
  BOTTOM w0.102: U43.C4 52.1,122.3 52.5,121.9 52.5,119.84 52.03,119.36 52.03,119.11
  BOTTOM w0.14: R609.1 50.5,116.04 TP137.1 50.86,116.7 51.14,116.7 52.03,117.59 52.03,119.11
GPU_THAL#: length 5.3
  TOP w0.14: PU3.14 57.25,74.31 57.39,74.18 57.69,74.18 58.11,74.6 58.11,74.77 58.47,75.13 PR65.1 59.14,75.8 59.42,75.8 59.95,76.34 v1(60.23,76.34)
GPU_VCCP_SENSE: length 104.9
  IN2 w0.254: v1(49.16,119.6) 49.38,119.6 51.37,117.61 51.37,114.28 52.64,113.01 56.85,113.01 57.68,112.19 57.68,107.87 59.05,106.49 59.05,105.48 61.65,102.87 61.65,101.56 61.98,101.23 66.1,101.23 67.06,100.26 67.06,98.71 68.36,97.42 68.36,93.58 69.2,92.74 73.34,92.74 73.68,93.09 75.76,93.09 80.55,97.87 82.97,97.87 83.55,97.29 83.55,96.21 83.55,82.94 79.71,79.1 75.9,79.1 75.11,78.31 64.29,78.31 63.38,77.4 63.38,75.6 61.17,73.39 60.66,73.39 60.13,72.86 60.13,71.46 59.64,70.98 59.19,70.98 v1(59.02,70.81)
  BOTTOM w0.102: v1(49.16,119.6) 49.23,119.67 49.23,120.49 U43.F2
  BOTTOM w0.254: v1(59.02,70.81) 58.73,70.81 PR185.1
GPU_VSSP_SENSE: length 104.1
  IN2 w0.254: v1(49.16,118.33) 51.01,116.48 51.01,114.03 52.38,112.66 56.68,112.66 57.3,112.04 57.3,107.74 58.7,106.35 58.7,105.33 59.62,104.4 59.62,101.58 60.49,100.72 65.95,100.72 66.58,100.09 66.58,98.49 67.98,97.09 67.98,93.33 68.92,92.39 73.48,92.39 73.83,92.73 75.91,92.73 80.69,97.51 82.83,97.51 83.19,97.15 83.19,83.09 79.59,79.49 75.65,79.49 74.83,78.67 64.15,78.67 63.03,77.55 63.03,75.75 61.05,73.77 60.54,73.77 59.78,73.01 59.78,71.61 59.52,71.36 59.12,71.36 v1(59.02,71.45)
  BOTTOM w0.102: U43.F1 49.6,119.11
  BOTTOM w0.254: v1(59.02,71.45) 58.83,71.45 PR179.1 ; 49.6,119.11 49.6,118.71 49.22,118.33 v1(49.16,118.33)
GPUT_CLK_L: length 24.4
  TOP w0.14: Q12.1 61.05,115.44 R175.2 60.28,114.67 60.28,113.65 v1(60.03,113.39) 59.78,113.14 56.22,113.14 55.76,113.6 55.76,115.53 55.2,116.09 55.2,123.82 53.3,125.71 52.54,125.71 52.28,125.97 52.28,126.46 v1(51.7,127.04)
  BOTTOM w0.102: U43.D9 v1(51.7,127.04)
GPUT_DATA_L: length 27.6
  TOP w0.14: Q12.4 65.23,114.14 65.36,114.28 R176.2 64.48,112.89 v1(62.32,112.89) 56.13,112.89 55.52,113.5 55.52,115.43 54.95,116 54.95,123.55 53.1,125.41 v1(51.69,125.41)
  BOTTOM w0.102: U43.D8 51.69,125.41 v1(51.69,125.41)
H_CPU_SVIDART#: length 5.2
  BOTTOM w0.076: U45.L62 106.55,123.35 105.02,123.35 104.6,122.93 103.98,122.93 103.34,122.28
  BOTTOM w0.14: 103.34,122.28 103.16,122.11 R565.1
H_CPU_SVIDCLK: length 5.6
  BOTTOM w0.076: 103.97,121.95 103.97,122.38 104.18,122.59 104.73,122.59 105.03,122.89 U45.N63
  BOTTOM w0.14: 103.97,121.95 103.39,121.37 102.9,121.37 v1(102.62,121.1) 102.23,120.7 R579.1
H_CPU_SVIDDAT: length 7.4
  BOTTOM w0.076: U45.L63 106.08,123.53 104.95,123.53 104.71,123.29 103.73,123.29 103.72,123.28
  BOTTOM w0.14: R558.1 R554.2 102.12,123.68 102.62,123.17 R555.2 103.08,123.17 103.18,123.28 103.72,123.28
H_PECI: length 106.7
  TOP w0.14: v1(145.88,74.15) 145.88,74.66 145.49,75.05 R298.2
  IN1 w0.14: v1(134.22,117.51) 133.87,117.51 132.88,116.52 132.5,116.52 130.71,114.73 127.27,114.73 125.47,116.54 113.24,116.54 111.61,118.17 111.61,119.64 110.75,120.51 109.81,120.51 108.47,121.85 105.5,121.85 v1(105.01,122.34)
  IN3 w0.14: v1(134.22,117.51) 135.64,117.51 135.85,117.71 136.74,117.71 137.07,117.38 137.96,117.38 138.39,116.95 138.39,116.32 138.9,115.81 139.79,115.81 140.55,115.05 140.55,113.78 140.93,113.39 140.93,109.71 140.42,109.2 140.42,106.92 140.68,106.66 140.68,103.44 142.16,101.96 142.16,101.08 143.31,99.93 143.51,99.93 145.87,97.57 146.44,97.57 147.58,96.44 147.58,96.01 147.79,95.8 147.79,95.35 151.58,91.56 152.37,91.56 157.69,86.24 157.69,85.2 158.2,84.69 158.2,82.28 158.4,82.09 158.4,81.59 158.12,81.31 158.12,77.76 156.93,76.57 156.36,76.57 155.63,75.84 154.31,75.84 153.95,76.2 146.78,76.2 145.88,75.29 v1(145.88,74.15)
  BOTTOM w0.076: U45.N62 106.47,122.52 106.15,122.52 105.95,122.72 105.39,122.72 v1(105.01,122.34)
H_PROCHOT#: length 266.5
  TOP w0.14: PU1.30 147.4,152.29 147.4,152.99 v1(147.49,153.09) ; PR81.1 57.88,67.67 PQ18.3 58.16,68.15 v1(58.89,68.87) ; Q29.3 130.64,52.94 130.01,53.58 130.01,54.8 v1(130.18,54.97)
  IN1 w0.114: v1(130.18,54.97) 130.16,54.97 130.13,54.95 130.13,54.44 126.79,51.09 119.22,51.09 117.64,49.51 113.29,49.51 110.8,52 88.49,52 88.14,51.65 81.24,51.65 81.12,51.54 77.23,51.54 76.7,51.01 72.7,51.01 70.23,53.48 65.75,53.48 65.41,53.82 63.95,53.82 62.16,55.61 60.9,55.61 60.46,56.05 60.3,56.21 60.3,59.31 60.46,59.47 60.77,59.78 60.77,63.94 60.49,64.22 60.49,66.63 58.89,68.23 v1(58.89,68.87)
  IN3 w0.089: v1(58.89,68.87) 58.61,69.15 58.61,72.03 62.91,76.34 63.32,76.34 63.66,76.68 67.9,76.68 71.83,80.61 71.83,82.62 72.51,83.3 72.51,88.71 72.89,89.09 73.69,89.09 74.25,89.65 74.25,90.58 73.66,91.17 73.31,91.17 72.87,91.61 72.87,92.71 73.45,93.3 73.45,99.54 74.23,100.31 76.23,100.31 78.57,102.65 78.57,103.87 79.46,104.76 79.46,115.69 90.5,126.73 92.1,126.73 94.51,129.15 v1(95.57,129.15) ; v1(147.49,153.09) 147.06,153.09 146.24,153.91 144.87,153.91 143.72,155.05 139.79,155.05 139.33,154.59 133.38,154.59 132.55,155.43 126.2,155.43 125.43,156.19 120.74,156.19 119.64,155.1 116.53,155.1 113.62,152.19 112.92,152.19 110.81,150.08 110.81,145.63 110.58,145.4 106.51,145.4 103.77,142.66 101.91,142.66 v1(101.05,141.79)
  BOTTOM w0.102: R548.1 101.93,124.32
  BOTTOM w0.14: v1(101.05,141.79) 101.05,141.59 99.07,139.61 97.14,139.61 94.46,136.92 94.46,130.9 95.09,130.27 95.09,129.63 v1(95.57,129.15) 95.57,129.12 98,126.7 98,126.69 99.46,125.22 99.65,125.22 R546.1 100.85,124.7 101.23,124.32 R548.1 ; R542.1 101.93,125.46 101.93,124.32 ; PR129.2 145.84,154.03 146.78,153.09 v1(147.49,153.09)
H_PROCHOT#_R: length 8.1
  BOTTOM w0.076: U45.K63 106.01,124.39 105.91,124.49 104.56,124.49 104.23,124.82 104.1,124.82 103.97,124.7
  BOTTOM w0.14: R542.2 103.21,125.46 103.89,126.15 104.05,126.15 104.28,125.92 104.28,125.76 103.56,125.05 103.08,125.05 102.98,124.95 102.98,124.73 103.14,124.57 103.41,124.57 103.49,124.49 103.49,124.28 103.58,124.19 103.78,124.19 103.89,124.3 103.89,124.62 103.97,124.7
H_PWRGOOD_R: length 25.4
  BOTTOM w0.076: 101.81,133.71 102.8,133.71 102.96,133.87 102.96,134.35 103.08,134.48 103.34,134.48 103.46,134.35 103.46,133.59 103.34,133.46 102.96,133.46 102.83,133.33 102.83,133.07 102.96,132.95 103.37,132.95 103.46,132.86 103.46,132.57 103.96,132.06 104.4,132.06 104.47,131.98 104.47,131.69 104.21,131.43 104.21,131.17 104.34,131.05 104.73,131.05 104.86,130.92 104.86,130.79 104.73,130.67 104.35,130.67 104.24,130.56 104.24,130.4 104.35,130.29 104.61,130.29 104.73,130.16 104.73,129.64 104.84,129.52 105,129.52 105.11,129.64 105.11,130.16 105.24,130.29 106.26,130.29 106.44,130.47 107.52,130.47 107.77,130.22 107.77,129.94 107.84,129.87 107.84,129.28 107.82,129.26 U45.C61 ; 101.81,134.86 102.07,134.86 102.25,134.67 R508.1
  BOTTOM w0.14: 101.81,134.86 101.05,134.86 100.95,134.76 v1(100.03,134.76) 99.7,134.76 99.53,134.58 99.53,132.83 100.41,131.94 100.59,131.94 100.73,132.08 100.73,132.26 100.16,132.83 100.16,133.41 100.34,133.59 101.69,133.59 101.81,133.71
H_SYS_PWROK_XDP: length 3.3
  TOP w0.14: R261.2 86,90.56 R274.1 84.71,89.16 TP87.1
HDA_BCLK_R: length 6.2
  BOTTOM w0.076: 139.84,105.27 139.74,105.36 139.74,107.13 139.66,107.21 139.66,107.8 U45.AW8
  BOTTOM w0.127: R652.2 141.28,104 v1(140.98,103.69) 140.83,103.84 140.83,104.28 139.84,105.27
HDA_RST#_R: length 10
  BOTTOM w0.076: 141,104.41 139.94,105.47 139.94,106.82 140.24,107.12 140.24,108.58 140.31,108.64 140.31,109.08 U45.AU8
  BOTTOM w0.127: R659.2 143.72,102.98 143.19,103.51 143.19,104.25 143.03,104.41 141.69,104.41 141.53,104.25 141.16,104.25 141,104.41
HDA_SDO_R: length 11.4
  BOTTOM w0.076: 139.76,105.04 139.56,105.24 139.56,107.06 139.49,107.13 139.49,107.57 139.32,107.74 139.28,107.78 139.09,107.78 138.91,107.97 138.91,108.38 138.81,108.47 138.81,108.85 138.49,109.18 U45.AU11
  BOTTOM w0.127: 139.76,105.04 140.55,104.25 140.55,103.43 141.37,102.61 R657.2 ; R657.2 142.27,102.02 v1(142.27,100.87) ; R657.2 R658.1
HDA_SYNC_R: length 11.2
  BOTTOM w0.076: 139.38,104.76 139.21,104.94 139.21,106.91 138.91,107.21 138.91,107.71 138.74,107.88 138.74,108.31 138.49,108.56 U45.AV11
  BOTTOM w0.127: 140.79,102.35 v1(140.79,100.69) C678.2 140.79,99.05 140.8,99.04 R684.2
  BOTTOM w0.14: 139.38,104.76 140.04,104.1 140.04,103.1 140.79,102.35
HDMI_5V: length 7
  BOTTOM w0.508: Q37.1 85.38,158.3 85.38,159.19 v3(85.35,159.22) 85.2,159.37 C549.1 D27.2 84.17,162.55 84.71,163.09 CN2.18
HDMI_DDCCLK_COM: length 4.5
  TOP w0.14: R57.2 86.94,151 86.45,151.49 Q3.1 85.81,150.1 v3(85.68,149.97) 85.56,149.84 R60.1
HDMI_DDCCLK_MB: length 16.2
  TOP w0.14: v1(85.33,160.64) 85.33,155.72 85.61,155.44 85.61,154.34 Q3.3 86.67,153.53 87.17,153.03 R50.1
  BOTTOM w0.14: v1(85.33,160.64) 85.33,161.43 85.56,161.65 85.56,163.56 84.92,164.19 83.89,164.19 CN2.15
HDMI_DDCCLK_SW: length 70.1
  TOP w0.14: R57.1 87.33,148.83 v3(87.59,148.57) 89.37,146.8 93.43,146.8 v1(94.32,145.91)
  IN1 w0.114: v1(141.06,135.11) 140.55,135.62 140.04,135.62 139.53,136.13 138.22,136.13 136.48,137.86 136.48,139.18 135.78,139.88 128.06,139.88 125.97,141.97 120.06,141.97 118.66,143.37 108.42,143.37 104.48,147.3 98.38,147.3 96.48,145.4 94.83,145.4 v1(94.32,145.91)
  BOTTOM w0.076: 141.46,133.84 141.46,133.23 140.29,132.06 140.14,132.06 139.66,131.58 139.66,130.79 139.05,130.19 139.05,129.49 U45.B9
  BOTTOM w0.14: v1(141.06,135.11) 141.46,134.71 141.46,133.84
HDMI_DDCDATA_COM: length 5.2
  BOTTOM w0.14: Q38.1 83.78,150.49 83.77,150.48 R486.1 83.77,149.55 84.05,149.27 85.21,149.27 v3(85.58,149.64) 86.06,149.17 R492.2
HDMI_DDCDATA_MB: length 15.4
  BOTTOM w0.14: R474.1 86.45,153.03 85.95,153.53 Q38.3 82.76,153.53 v1(82.51,153.78) 82.2,154.09 82.2,161.82 CN2.16
HDMI_DDCDATA_SW: length 70.3
  IN1 w0.114: v1(95.84,145.91) 97.75,147.81 104.72,147.81 108.66,143.87 118.87,143.87 120.27,142.48 126.16,142.48 128.26,140.38 136.09,140.38 140.33,136.13 141.44,136.13 v1(141.82,135.75)
  BOTTOM w0.076: U45.C9 139.63,129.04 139.63,129.54 139.83,129.74 139.83,130.26 140.65,131.08 140.65,131.91 141.94,133.21 142.07,133.21 142.38,133.51 142.38,133.84
  BOTTOM w0.14: 142.38,133.84 142.38,135.19 v1(141.82,135.75) ; R492.1 86.84,148.7 88.48,147.05 94.7,147.05 v1(95.84,145.91)
HDMI_MB_HP: length 5.9
  TOP w0.14: Q2.3 81.87,155.3 82.64,156.08 R37.1 RV1.1 v1(84.79,157.03) R14.2
HP-L: length 15.3
  TOP w0.203: v1(239.65,40.94) 239.44,40.94 239.05,40.55 238.64,40.55 238.47,40.72 U34.32
  TOP w0.381: R419.2 v1(238.85,29.08)
  IN1 w0.381: v1(239.65,40.94) 239.67,40.91 239.67,40.69 238.67,39.68 238.67,38.39 239.23,37.83 239.23,30.72 238.85,30.34 v1(238.85,29.08)
HP-L-1: length 2.2
  TOP w0.381: v1(239.1,28.3) 239.09,28.3 R419.1 R423.1
HP-R: length 14.1
  TOP w0.203: v1(238.85,41) 238.73,41.12 U34.33
  TOP w0.381: R418.2 v1(236.94,29.7)
  IN1 w0.381: v1(238.85,41) 237.91,40.07 237.91,37.63 237.7,37.42 237.7,35.04 238.21,34.53 238.21,30.97 v1(236.94,29.7)
HP-R-1: length 2.2
  TOP w0.381: v1(236.05,28.3) 236.06,28.3 R418.1 R422.1
HP_DET_CN: length 7.2
  TOP w0.14: CN2.19 86.32,163.77 v3(86.32,162.8) 86.32,162.42 84.79,160.89 R14.1
HPL_SYS: length 4.6
  TOP w0.381: R423.2 238.21,24.74 D24.1 v1(238.58,23.53) 238.58,22.9 CN21.1
HPOUT_JD: length 44.5
  TOP w0.14: CN21.6 248.5,8.87 243.8,8.87 242.4,7.48 D26.1 242.15,7.47 v1(242.15,8.11) ; R410.2 232.5,33.13 v1(232.75,32.88)
  IN1 w0.114: v1(232.75,32.88) 233.21,32.42 233.89,32.42 235.87,30.44 235.87,28.23 236.69,27.42 236.69,23.15 235.52,21.98 235.52,18.81 236.03,18.3 236.03,14.14 235.77,13.88 235.77,9.31 237.37,7.71 241.74,7.71 v1(242.15,8.11)
  BOTTOM w0.14: v1(242.15,8.11) 241.64,7.6 v1(241.26,7.6)
HPR_SYS: length 19.7
  TOP w0.381: R422.2 236.94,25 237.2,24.74 D23.1 237.2,24 v1(237.45,23.76)
  IN3 w0.381: CN21.2 239.36,9.38 237.83,9.38 236.81,10.4 236.81,13.7 236.31,14.21 236.31,22.62 v1(237.45,23.76)
HSYNC: length 9.2
  TOP w0.127: U5.2 v1(99.53,161.91)
  BOTTOM w0.127: v1(99.53,161.91) 100.03,161.4 100.03,158.86 101.01,157.88 101.39,157.88 102.19,157.08 102.19,156.96 102.97,156.18 U40.4
HWPG: length 25.7
  TOP w0.14: U32.84 156.7,61.33 157.51,60.52 v1(157.69,60.52) 157.7,60.52 158.45,61.27 R344.1 158.45,61.58 158.96,62.09 160.28,62.09 160.61,61.76 D14.2
  BOTTOM w0.254: v1(157.69,60.52) 158.2,60.01 158.2,58.53 157.64,57.97 157.64,48.98 158.12,48.5 D34.2 D36.2 D37.2 D38.2
HWPG_1.5V: length 30.1
  IN3 w0.254: v1(154.97,39.86) 154.21,40.62 145.47,40.62 144.61,39.76 133.03,39.76 132.93,39.86 v1(132.93,39.89)
  BOTTOM w0.254: PU10.14 133.26,43.37 133.16,43.27 v1(133.16,42.92) 133.16,42.45 PR217.1 132.6,41.95 132.17,41.51 132.17,40.62 132.93,39.86 v1(132.93,39.89) ; D38.1 155.5,40.39 v1(154.97,39.86)
HWPG_1.05V: length 28.9
  TOP w0.254: D14.1 161.12,58.61 v1(161.53,58.2) ; Q34.3 R400.2 R402.1 155.41,41.13 156.7,39.84 v1(157.31,39.84) v1(158.2,39.84)
  BOTTOM w0.254: v1(158.2,39.84) 158.2,40.55 159.14,41.49 159.14,48.7 158.33,49.51 158.33,56.88 159.32,57.87 161.2,57.87 v1(161.53,58.2)
HWPG_1.05V_EC: length 3.8
  BOTTOM w0.14: v1(96.48,130.59) R521.2 96.73,131.55 97.1,131.17 97.88,131.17 98.26,131.56 Q39.3
HWPG_1.05V_EC#: length 193.1
  TOP w0.14: v1(138.13,59.25) 138.56,59.25 139.44,60.13 U32.16
  IN3 w0.089: v1(138.13,59.25) 136.95,59.25 134.58,56.88 134.13,56.88 131.63,54.38 129.94,54.38 127.85,52.29 118.97,52.29 118.61,51.93 116.09,51.93 115.57,52.44 115.57,52.85 114.59,53.83 105.78,53.83 104.89,52.94 97.87,52.94 97.16,52.24 90.75,52.24 88.8,50.29 82.38,50.29 82.15,50.52 80.64,50.52 80.41,50.29 78.97,50.29 78.21,49.53 71.14,49.53 70.11,50.56 65.09,50.56 64.83,50.82 63.72,50.82 62.87,51.67 62.56,51.67 61.61,52.63 61.2,52.63 60.37,53.45 60.37,54.12 58.86,55.64 58.86,59.97 59.85,60.96 59.85,62.35 59.42,62.78 59.42,64.34 59.83,64.75 59.83,72.17 63.25,75.59 63.78,75.59 64.28,76.1 68.14,76.1 76.25,84.2 76.25,91.14 75.48,91.91 74.87,91.91 74.63,91.68 74,91.68 73.71,91.97 73.71,92.27 74.76,93.33 74.76,94.17 74.05,94.88 74.05,99.31 74.46,99.72 76.46,99.72 80.26,103.52 80.26,115.67 89.77,125.17 91.37,125.17 94.19,128 95.46,128 96.86,129.4 v1(99.07,129.4)
  BOTTOM w0.14: v1(99.07,129.4) 99.2,129.52 Q39.2
HWPG_1.05V_S5: length 301.2
  TOP w0.14: R254.1 86.03,93.67 v1(85.66,94.04) 85.66,96.05 v1(83.57,98.13)
  TOP w0.279: PR72.1 v1(197.32,73.14) 197.05,73.41 PU4.1
  IN1 w0.114: v1(83.57,98.13) 82.74,98.13 82,97.39 80.32,97.39 74.53,91.6 73.03,91.6 72.12,90.69 72.12,88.35 67.59,83.82 67.59,80.37 66.65,79.43 66.65,78.05 66.25,77.64 66.25,77.28 65.81,76.85 65.81,76.21 65.11,75.51 65.11,74.92 64.18,73.99 64.18,69.11 63.93,68.86 63.93,66.53 65.24,65.22 65.24,64.42 65.06,64.25 65.06,57.39 66.28,56.16 66.28,55.25 66.99,54.54 70.67,54.54 71.9,53.32 79.79,53.32 80.31,52.8 81.26,52.8 81.55,52.5 87.76,52.5 88.1,52.85 111.15,52.85 113.64,50.36 117.16,50.36 118.75,51.95 125.36,51.95 v1(126.54,53.13)
  IN3 w0.089: v1(192.62,51.04) 193.13,51.55 194.52,51.55 195.56,50.5 202.96,50.5 212.21,41.26 216.62,41.26 220.3,44.94 220.3,57.5 219.02,58.78 216.48,58.78 213.34,61.92 213.34,64.23 209,68.56 206.44,68.56 203.84,71.16 203.84,72.7 202.9,73.64 197.82,73.64 v1(197.32,73.14)
  BOTTOM w0.14: v1(126.54,53.13) 126.64,53.13 129.02,55.51 131.17,55.51 134.58,52.1 136.66,52.1 139.53,49.22 148.85,49.22 151.05,51.42 154.64,51.42 155.5,50.56 D34.1 154.5,47.74 153.93,47.16 153.93,39.43 155.22,38.14 173.26,38.14 174.21,39.1 174.21,41.91 177.44,45.14 191.92,45.14 193.51,46.72 193.51,50.15 v1(192.62,51.04)
HWPG_1.5VGFX: length 55.4
  TOP w0.14: PR33.1 14.94,115.67 15.08,115.81 v1(15.53,115.81) 15.81,115.81 16.37,116.37 PU2.1 ; R56.2 21.08,151.88 v1(17.74,151.88) 14.31,151.88 v1(12.15,149.72)
  IN3 w0.14: v1(12.15,149.72) 12.73,149.13 12.73,143.29 16.09,139.94 16.09,138.67 18.3,136.46 18.3,128.08 20.79,125.59 20.79,117.71 19.39,116.32 16.04,116.32 v1(15.53,115.81)
HWPG_VDDR: length 52
  TOP w0.14: v1(197.7,49.34) 198.28,49.34 198.97,50.02 198.97,51.15 PR114.1
  TOP w0.208: PU6.20 198.5,53.54 199.5,52.54 199.5,51.73 PR114.1
  IN3 w0.089: v1(155.18,44.81) 155.58,44.41 162.24,44.41 166.33,48.5 196.86,48.5 v1(197.7,49.34)
  BOTTOM w0.14: D36.1 155.15,45.48 155.15,44.84 v1(155.18,44.81)
I2CA_SCL: length 15.3
  BOTTOM w0.102: U43.B7 53.31,124.55 53.79,124.55 54.04,124.3 54.04,123.18 55.46,121.76 55.46,120
  BOTTOM w0.14: v1(52.93,113.02) R631.1 53.48,113.47 53.48,115.81 53.68,116 53.68,116.7 55.46,118.47 55.46,120
I2CA_SDA: length 11.3
  BOTTOM w0.102: U43.A7 53.7,124.93 54.25,124.39 54.25,123.37 55.46,122.16
  BOTTOM w0.14: 55.46,122.16 55.71,121.9 55.71,118.35 54.11,116.75 v1(54.11,116.19) 54.11,115.36 R611.1
ICLK_BIAS: length 10.4
  BOTTOM w0.076: U45.C26 129.55,128.69 129.26,128.98 129.26,129.27 129.38,129.39 129.38,130.15 129.27,130.26 129.27,132.67 128.36,133.59 128.36,133.84
  BOTTOM w0.14: v1(126.93,137.65) 126.93,136.67 R500.2 127.42,136.19 127.42,135.67 128.36,134.73 128.36,133.84
ICMNT: length 130.7
  TOP w0.14: U32.67 156.81,54.53 157.18,54.16 157.18,52.59 C469.2 155.28,51.42 154.64,52.05 154.64,52.94 154.26,53.32 153.25,53.32 151.98,54.59 v1(148.42,54.59)
  TOP w0.508: PR88.1 58.2,64.62 58.61,65.02 58.61,65.29 58.58,65.31 v1(58.56,65.31)
  IN1 w0.114: v1(148.42,54.59) 148.05,54.97 146.89,54.97 146.26,54.34 146.26,53.2 145.88,52.82 144.99,52.82 143.72,51.55 139.79,51.55 139.15,52.18 137.92,52.18 137.17,51.43 131.55,51.43 128.8,48.68 120.18,48.68 118.63,47.12 110.78,47.12 109.99,47.91 107.71,47.91 106.65,48.97 97,48.97 96.35,49.62 90.41,49.62 89.54,48.75 82.19,48.75 81.58,48.14 72.19,48.14 70.39,49.94 67.7,49.94 67.11,50.54 65.34,50.54 64.78,51.1 63.47,51.1 63.18,51.39 62.75,51.39 v1(62.38,51.02)
  IN2 w0.114: v1(58.56,65.31) 58.58,65.31 58.61,65.29 58.61,62.75 59.27,62.09 59.27,60.82 58.28,59.83 58.28,56.21 60.31,54.19 60.31,53.39 61.29,52.41 61.29,51.93 62.21,51.02 v1(62.38,51.02)
  BOTTOM w0.279: PU9.7 57.92,64.89 58.34,65.31 v1(58.56,65.31) 59.22,65.98 PC124.2
IMVP_PWRGD: length 71.1
  TOP w0.14: v1(127.19,155.95) 127.32,155.81 U10.2
  IN2 w0.114: v1(139.66,153.65) 139.23,154.08 128.46,154.08 127.19,155.36 v1(127.19,155.95) 120.61,155.95 115.37,150.7 115.37,145.57 107.2,137.4 102.96,137.4 102.07,136.51 102.07,135.04 v1(104.2,132.9)
  BOTTOM w0.076: U45.C59 108.92,128.99 109.23,129.3 109.23,129.6 109.09,129.74 108.79,129.74 108.59,129.94 108.59,130.28 108.3,130.57 108.12,130.57 107.73,130.96 105.56,130.96 105.06,131.46 105.06,132.51 104.67,132.9 v1(104.2,132.9) 104.2,133.93 R506.1 104.62,134.09 104.74,133.97 105,133.97 105.11,134.09 R507.1
  BOTTOM w0.14: v1(139.66,153.65) 141.23,153.65 141.81,154.23 PR130.1
IMVP_PWRGD_3V: length 143.1
  TOP w0.14: v1(123.91,153.15) 124.68,153.92 124.68,154.94 125.56,155.81 125.95,155.81 R33.2 126.6,156.46 U10.4 ; Q8.2 93.81,132.57 94.95,132.57 97.75,135.37 101.81,135.37 102.57,136.13 107.78,136.13 v1(109.69,138.03)
  IN1 w0.114: v1(157.44,99.91) 158.01,99.91 159.01,100.91 159.01,102.14 160.03,103.16 160.03,104.52 160.65,105.14 160.65,109.55 160.03,110.17 v1(160.03,110.8)
  IN2 w0.114: v1(157.44,99.91) 156.83,99.3 154.14,99.3 v1(153.88,99.55) ; v1(109.69,138.03) 116.54,144.89 116.54,150.35 119.06,152.87 123.63,152.87 v1(123.91,153.15) 124.24,153.15 126.22,151.16 129.8,151.16 130.74,150.22 140.29,150.22 142.71,147.81 143.21,147.81 143.72,147.3 145.22,147.3 145.74,147.82 146.4,147.82 146.62,147.61 150.66,147.61 151.01,147.96 151.01,149.26 151.34,149.59 152.1,149.59 152.31,149.39 152.31,142.27 153.63,140.95 153.63,130.16 159.47,124.32 159.47,123.94 159.85,123.55 159.85,116.81 159.34,116.3 159.34,114.31 159.66,113.99 159.66,111.17 v1(160.03,110.8)
  BOTTOM w0.14: R683.2 153.49,99.16 v1(153.88,99.55) ; v1(157.44,99.91) 157.91,99.44 U47.1
INT_HDMI_HPD: length 82.6
  TOP w0.14: v1(91.02,148.32) 90.38,148.95 90.38,150.22 89.09,151.52 87.16,151.52 86.69,151.99 86.69,152.4 86.12,152.96 85.63,152.96 85.31,152.64 84.29,152.64 83.65,153.27 Q2.1 82.13,152.52 82.26,152.38 R55.2
  IN1 w0.114: v1(143.09,135.75) 142.24,136.6 140.53,136.6 136.29,140.83 128.45,140.83 126.34,142.95 120.46,142.95 118.54,144.87 108.31,144.87 104.02,149.16 91.86,149.16 v1(91.02,148.32)
  BOTTOM w0.076: 144.1,133.84 144.1,132.83 143.47,132.19 142.32,132.19 142.12,131.99 142.12,131.35 141.44,130.67 141.17,130.67 140.74,130.24 140.74,129.88 140.41,129.55 140.41,129.01 U45.C8
  BOTTOM w0.14: 144.1,133.84 144.1,134.48 144.15,134.53 144.15,135.92 143.9,136.17 143.51,136.17 v1(143.09,135.75)
INT_HDMICLK+: length 61.7
  IN3 w0.089: v1(80.4,156.83) 80.65,157.08 80.65,157.38 80.94,157.67 83.1,157.67 83.47,157.29 83.47,156.45 83.22,156.19 82.36,156.19 82.13,155.96 82.13,155.63 82.36,155.39 85.5,155.39 86.52,154.37 86.52,151.2 86.74,150.99 87.04,150.99 87.26,151.2 87.26,152.65 87.58,152.97 88.03,152.97 88.35,152.65 88.35,150.99 88.6,150.73 90.21,150.73 90.59,150.36 90.59,149.12 90.21,148.75 89.75,148.75 89.49,148.5 89.49,148.02 89.75,147.76 91.64,147.76 91.98,147.42 91.98,146.93 91.64,146.59 90.37,146.59 90.13,146.35 90.13,146.02 90.37,145.78 91.78,145.78 92.03,145.53 92.03,143.93 100.4,135.57 101.64,135.57 103.29,133.92 105.25,133.92 106.01,133.16 106.27,133.16 v1(106.5,133.38)
  BOTTOM w0.076: v1(106.5,133.38) 106.7,133.17 107,133.17 107.18,132.99 107.18,132.54 107.39,132.33 108.5,132.33 110.51,130.32 110.51,129.96 110.48,129.9 110.42,129.79 110.35,129.72 110.17,129.72 110.05,129.6 U45.B57
  BOTTOM w0.14: v1(80.4,156.83) 80.4,157.66 C559.1
INT_HDMICLK+_C: length 7.8
  TOP w0.14: v1(80.25,159.62) 80.25,159.6 80.72,159.13 80.72,158.77 80.56,158.62 R25.1
  BOTTOM w0.14: CN2.10 81.07,162.96 81.07,162.27 80.72,161.92 80.72,160.76 R453.1 80.73,160.25 80.73,159.75 80.6,159.62 v1(80.25,159.62) 80.72,159.15 80.72,158.9 80.43,158.62 R25.1
INT_HDMICLK-: length 61.7
  IN3 w0.089: v1(81.15,156.83) 81,156.83 80.85,156.98 80.85,157.29 81.02,157.46 83.02,157.46 83.27,157.21 83.27,156.53 83.13,156.4 82.28,156.4 81.92,156.04 81.92,155.54 82.28,155.19 85.42,155.19 86.32,154.29 86.32,151.12 86.65,150.78 87.13,150.78 87.46,151.12 87.46,152.56 87.66,152.76 87.95,152.76 88.15,152.56 88.15,150.9 88.52,150.53 90.13,150.53 90.38,150.28 90.38,149.21 90.13,148.95 89.66,148.95 89.29,148.58 89.29,147.93 89.66,147.56 91.56,147.56 91.78,147.33 91.78,147.02 91.56,146.8 90.28,146.8 89.92,146.44 89.92,145.93 90.28,145.58 91.69,145.58 91.83,145.44 91.83,143.85 100.31,135.37 101.56,135.37 103.21,133.71 105.16,133.71 105.93,132.95 106.33,132.95 106.47,132.82 v1(106.47,132.73)
  BOTTOM w0.076: U45.A57 110.05,130 110.17,129.88 110.28,129.88 110.28,129.88 110.29,129.9 110.34,130 110.34,130.25 108.43,132.17 107.32,132.17 107.02,132.47 107.02,132.92 106.93,133 106.66,133 106.47,132.81 v1(106.47,132.73)
  BOTTOM w0.14: v1(81.15,156.83) 81.03,156.83 80.67,157.2 80.67,157.59 80.91,157.84 C560.1
INT_HDMICLK-_C: length 7.7
  TOP w0.14: R26.1 81.11,158.62 80.98,158.74 80.98,159.06 81.52,159.6 v1(81.52,159.62)
  BOTTOM w0.14: R26.1 81.18,158.62 80.98,158.81 80.98,159.09 v1(81.52,159.62) 81.12,159.62 81,159.75 81,160.26 R453.2 80.98,160.77 80.98,161.81 81.34,162.16 81.34,162.96 CN2.12
INT_HDMITX0N: length 57.6
  IN3 w0.089: v1(73.78,156.83) 73.51,157.1 73.51,157.61 74.13,158.23 83.45,158.23 92.67,149.01 92.67,144.48 99.87,137.27 105.59,137.27 107.53,135.33 107.53,134.89 107.38,134.75 107.24,134.75 v1(107.13,134.86)
  BOTTOM w0.076: U45.B55 111.59,129.58 111.59,129.64 111.72,129.78 111.72,130.43 109.94,132.22 109.94,132.7 108,134.64 107.34,134.64 v1(107.13,134.86)
  BOTTOM w0.14: v1(73.78,156.83) 73.51,157.1 73.51,157.61 73.74,157.84 C554.1
INT_HDMITX0N_C: length 14.2
  TOP w0.14: CN2.9 79.84,164.51 79.84,164.25 79.51,163.91 76.38,163.91 73.21,160.74 73.21,159.9 73.49,159.62 v1(73.9,159.62) 73.9,159.6 73.57,159.27 73.57,158.78 73.73,158.62 R20.1
  BOTTOM w0.14: R450.2 73.88,159.64 v1(73.9,159.62) 73.56,159.29 73.56,159.05 R20.1
INT_HDMITX0P: length 57.6
  IN3 w0.089: v1(73.03,156.83) 73.31,157.1 73.31,157.69 74.04,158.43 83.53,158.43 92.87,149.09 92.87,144.56 99.96,137.47 105.67,137.47 107.73,135.42 107.73,134.81 v1(107.13,134.21)
  BOTTOM w0.076: v1(107.13,134.21) 107.13,134.36 107.25,134.48 107.93,134.48 109.77,132.64 109.77,132.15 111.56,130.36 111.56,130.2 U45.A55
  BOTTOM w0.14: v1(73.03,156.83) 73.24,157.04 73.24,157.45 C553.1
INT_HDMITX0P_C: length 14.7
  TOP w0.14: CN2.7 79.57,164.51 79.57,164.36 79.4,164.18 76.27,164.18 72.94,160.85 72.94,159.94 v1(72.63,159.62) 72.65,159.6 73.03,159.6 73.29,159.34 73.29,158.81 73.1,158.62 R19.1
  BOTTOM w0.14: R19.1 73.29,159.05 73.29,159.39 73.06,159.62 v1(72.63,159.62) 73.1,160.1 R450.1
INT_HDMITX1N: length 61
  IN3 w0.089: v1(78.61,156.83) 78.41,156.83 78.29,156.95 78.29,157.15 78.4,157.26 78.87,157.26 79.13,157 79.13,156.07 79.38,155.81 80.91,155.81 81.16,155.56 81.16,151.9 81.52,151.55 82.02,151.55 82.38,151.9 82.38,153.81 82.6,154.03 82.92,154.03 83.14,153.81 83.14,151.28 83.51,150.91 84.04,150.91 84.41,151.28 84.41,153.81 84.64,154.03 84.95,154.03 85.18,153.81 85.18,149.05 99.64,134.58 101.2,134.58 103.63,132.15 105.72,132.15 105.81,132.07 v1(105.81,131.9)
  BOTTOM w0.076: v1(105.81,131.9) 105.81,132.07 105.89,132.16 106.53,132.16 107.04,131.64 108.33,131.64 109.59,130.39 109.59,129.2 U45.B58
  BOTTOM w0.14: v1(78.61,156.83) 78.49,156.83 78.13,157.2 78.13,157.78 78.31,157.96 78.7,157.96 C558.1
INT_HDMITX1N_C: length 10.1
  TOP w0.14: R24.1 78.57,158.62 78.42,158.77 78.42,159.06 78.98,159.62 v1(78.98,159.65)
  BOTTOM w0.14: R24.1 78.59,158.62 78.44,158.76 78.44,159.11 v1(78.98,159.65) 78.55,159.65 78.44,159.75 78.44,160.25 R452.2 78.46,160.76 78.46,161.26 78.19,161.53 77.05,161.53 76.92,161.65 76.92,161.99 77.05,162.11 78.09,162.11 78.34,162.37 78.34,162.96 CN2.6
INT_HDMITX1P: length 61
  IN3 w0.089: v1(77.86,156.83) 78.09,157.06 78.09,157.24 78.32,157.46 78.95,157.46 79.33,157.08 79.33,156.15 79.47,156.02 80.99,156.02 81.37,155.64 81.37,151.99 81.6,151.75 81.94,151.75 82.18,151.99 82.18,153.9 82.52,154.24 83,154.24 83.35,153.9 83.35,151.37 83.6,151.11 83.96,151.11 84.21,151.37 84.21,153.9 84.55,154.24 85.04,154.24 85.38,153.9 85.38,149.13 99.73,134.78 101.29,134.78 103.72,132.35 105.61,132.35 v1(105.81,132.55)
  BOTTOM w0.076: U45.C58 109.49,128.69 109.78,128.98 109.78,129.27 109.75,129.3 109.75,130.46 108.4,131.81 107.11,131.81 106.6,132.32 106.04,132.32 v1(105.81,132.55)
  BOTTOM w0.14: v1(77.86,156.83) 77.86,157.66 C557.1
INT_HDMITX1P_C: length 10.1
  TOP w0.14: R23.1 77.94,158.62 78.15,158.83 78.15,159.18 77.71,159.62 v1(77.71,159.65)
  BOTTOM w0.14: R23.1 78.03,158.62 78.18,158.76 78.18,159.18 v1(77.71,159.65) 78.05,159.65 78.18,159.77 78.18,160.26 R452.1 78.19,160.77 78.19,161.15 78.08,161.26 76.94,161.26 76.65,161.54 76.65,162.1 76.94,162.38 77.98,162.38 78.08,162.48 78.08,162.96 CN2.4
INT_HDMITX2N: length 61.3
  IN3 w0.089: v1(107.77,132.73) 107.99,132.95 108.17,132.95 108.42,132.7 108.42,132.19 108.34,132.11 107.53,131.3 103.75,131.3 102.79,132.27 101.1,132.27 86.32,147.05 84.92,147.05 84.67,147.3 84.67,149.55 84.3,149.92 83.77,149.92 83.4,149.55 83.4,147.3 83.14,147.05 82.71,147.05 82.46,147.3 82.46,149.55 79.59,152.42 79.59,154.16 78.49,155.25 76.89,155.25 75.9,156.24 75.9,156.54 v1(76.2,156.83)
  BOTTOM w0.076: U45.C54 111.36,128.45 111.03,128.78 111.03,129.19 110.99,129.24 110.99,129.61 111.03,129.65 111.03,129.84 110.99,129.89 110.99,130.26 108.25,132.99 108.04,132.99 v1(107.77,132.73)
  BOTTOM w0.14: v1(76.2,156.83) 75.85,157.18 75.85,157.66 76.02,157.84 C556.1
INT_HDMITX2N_C: length 9.5
  TOP w0.14: v1(76.44,159.62) 76.44,159.6 75.95,159.11 75.95,158.72 76.06,158.62 R22.1
  BOTTOM w0.14: CN2.3 76.83,164.5 76.83,164.27 76.03,163.47 76.03,160.77 R451.2 75.98,160.2 75.98,159.79 76.15,159.62 v1(76.44,159.62) 75.95,159.14 75.95,158.84 76.17,158.62 R22.1
INT_HDMITX2P: length 61.3
  IN3 w0.089: v1(75.45,156.83) 75.7,156.57 75.7,156.16 76.81,155.05 78.41,155.05 79.38,154.08 79.38,152.33 82.25,149.46 82.25,147.22 82.63,146.85 83.23,146.85 83.6,147.22 83.6,149.46 83.85,149.72 84.21,149.72 84.46,149.46 84.46,147.22 84.84,146.85 86.23,146.85 101.02,132.06 102.7,132.06 103.67,131.1 107.61,131.1 108.54,132.03 108.62,132.11 108.62,132.78 108.25,133.15 108.08,133.15 v1(107.77,133.45)
  BOTTOM w0.076: v1(107.77,133.45) 108.07,133.16 108.32,133.16 111.15,130.32 111.15,129.96 111.2,129.91 111.2,129.59 111.15,129.54 111.15,129.31 111.2,129.26 111.2,128.85 111.27,128.77 U45.C55
  BOTTOM w0.14: C555.1 75.58,157.52 75.58,156.96 v1(75.45,156.83)
INT_HDMITX2P_C: length 9.4
  TOP w0.14: R21.1 75.52,158.62 75.66,158.76 75.66,159.1 75.17,159.6 v1(75.17,159.62)
  BOTTOM w0.14: R21.1 75.51,158.62 75.68,158.78 75.68,159.11 v1(75.17,159.62) 75.52,159.62 75.71,159.81 75.71,160.31 75.72,160.31 R451.1 75.76,160.76 75.76,163.58 76.56,164.38 76.56,164.53 CN2.1
IOAC_LANPWR#: length 126.8
  TOP w0.14: R330.2 212.94,62.09 213.95,61.07 220.43,61.07 222.82,58.68 222.82,51.27 219.29,47.74 219.29,43.8 217.03,41.54 207.12,41.54 206.33,40.75 199.49,40.75 197.47,42.77 v1(197.47,43.75) ; U32.20 141.69,58.53 141.87,58.71 141.87,59.85 142.47,60.45 149.32,60.45 150.4,61.53 150.4,62.44 150.61,62.65 151.06,62.65 151.29,62.42 151.29,62.01 151.52,61.78 152.26,61.78 152.43,61.96 152.43,62.47 v1(152.97,63)
  IN1 w0.114: v1(197.47,43.75) 195.88,43.75 194.41,45.22 189.56,45.22 186.61,48.17 170.98,48.17 169.63,49.51 165.82,49.51 162.01,53.32 162.01,54.85 160.08,56.78 159.57,56.78 156.92,59.43 156.92,61.46 155.91,62.47 153.5,62.47 v1(152.97,63)
IOAC_RST#: length 145.3
  TOP w0.14: v1(142.96,65.16) 142.96,65.22 141.47,66.71 138.71,66.71 137.82,65.82 136.28,65.82 135.49,65.03 135.49,62.95 135.59,62.85 135.59,62.21 135.11,61.73 133.36,61.73 133.19,61.89 R341.1 133.19,62.71 132.7,63.2 U27.2 ; v1(153.53,60.89) 153.5,60.92 153.91,61.32 154.7,61.32 155.1,61.73 U32.85
  IN2 w0.114: v1(211.11,76.82) 210.78,77.15 210.78,79.87 209.34,81.31 209.34,82.04 206.56,84.82 202.17,84.82 196.93,90.06 194.99,90.06 194.17,89.24 167.88,89.24 164.42,85.79 164.42,78.42 157.91,71.91 157.91,70.23 157.06,69.38 157.06,69.13 155.78,67.85 155.78,67.36 155.36,66.94 155.36,63.61 153.7,61.96 153.7,61.07 v1(153.53,60.89) 152.83,60.19 152.83,58.95 152.31,58.43 150.99,58.43 150.63,58.07 150.63,55.53 150.24,55.14 149.4,55.14 148.24,56.3 143.29,56.3 140.8,58.78 140.8,62.72 142.96,64.88 v1(142.96,65.16)
  BOTTOM w0.14: R704.2 218.27,80.63 216.24,78.6 215.55,78.6 214.54,77.58 213.7,77.58 212.48,76.36 211.57,76.36 v1(211.11,76.82) ; v1(142.96,65.16) 142.68,65.44 140.94,65.44 140.76,65.26 v1(140.04,65.26) 139.53,65.26 138.9,64.63 R724.2
IOAC_WLANPWR#: length 105.5
  TOP w0.14: U32.81 155.13,60.13 154.62,59.62 v1(154.31,59.62)
  IN1 w0.114: v1(154.31,59.62) 155.81,59.62 159.34,56.09 159.34,51.96 160.66,50.63 160.66,49.93 166.3,44.29 174.97,44.29 177.71,47.04 180.03,47.04 180.39,47.39 184.96,47.39 187.86,44.49 194.27,44.49 196.77,41.99 208.65,41.99 209.64,41 216.96,41 218.65,42.69 218.65,47.49 220.04,48.88 220.04,54.14 219.77,54.42 219.77,58.92 218.38,60.3 215.99,60.3 v1(215.73,60.56)
  BOTTOM w0.14: Q41.2 216.62,62.98 215.99,62.35 215.99,62.09 215.73,61.82 v1(215.73,60.56)
IRQ_SERIRQ: length 126
  TOP w0.14: v1(149.36,61.96) 148.47,61.07 145.25,61.07 144.92,61.4 144.92,62.24 143.79,63.36 143.16,63.36 142,64.53 U32.5 ; v1(143.24,120.98) 143.65,121.4 143.68,121.4 144.6,122.32 144.6,122.89 144.99,123.28 144.99,124.02 144.83,124.19 v1(144.83,124.69) 145.09,124.95 145.86,124.95 v1(145.96,124.85) 146.41,124.85 146.84,125.28 147.31,125.28 147.76,124.82 R114.1
  IN1 w0.114: v1(149.36,61.96) 150.02,61.96 152.61,59.37 152.61,58.73 153.27,58.07 156.44,58.07 158.66,55.86 158.66,51.72 159.98,50.4 159.98,50.02 v1(159.47,49.51)
  IN3 w0.089: v1(145.96,124.85) 145.96,124.39 144.95,123.38 144.95,120.84 145.88,119.91 145.88,119.65 146.52,119.01 146.52,117.83 147.94,116.41 147.94,116.05 148.42,115.57 148.42,112.68 147.14,111.4 146.86,111.4 146.49,111.03 146.49,108.62 146.9,108.21 146.9,107.43 146.41,106.94 146.41,105.22 150.55,101.07 150.55,100.6 150.89,100.26 151.22,100.26 152.21,99.27 152.21,97.58 153.44,96.35 154.49,96.35 159.78,91.06 159.78,89.63 160.6,88.81 160.6,87.89 161.88,86.61 161.88,82.3 163.98,80.2 163.98,78.38 161.96,76.36 161.96,76.02 157.68,71.74 156.32,71.74 154.5,69.92 152.85,69.92 152.59,70.17 151.55,70.17 151.09,69.71 151.09,68.94 149.28,67.14 149.28,62.04 v1(149.36,61.96)
  BOTTOM w0.102: v1(143.24,120.98) 142.87,121.34 U45.T4
  BOTTOM w0.14: v1(159.47,49.51) 159.47,49.46 159.7,49.23 159.7,46.99 R769.1
ISOLATEB: length 5.4
  TOP w0.14: U24.38 214.48,80.8 214.03,80.35 214.03,79.95 R290.1 213.57,78.48 213.57,77.46 R293.1
ISPSCL: length 12.7
  IN1 w0.114: v1(101.05,156.07) 101.88,155.24 107.98,155.24 108.79,154.43 v1(108.79,154.29)
  BOTTOM w0.127: R467.2 109.17,154.29 v1(108.79,154.29) 108.55,154.29 107.96,153.71 107.65,153.71 107.6,153.66 U40.15 ; v1(101.05,156.07) 101.43,156.07 101.77,155.73 U40.1
ISPSDA: length 15.7
  IN1 w0.114: v1(101.05,156.83) 101.56,156.83 102.52,155.86 108.24,155.86 109.56,154.54 109.56,153.91 109.33,153.68 v1(108.8,153.68)
  BOTTOM w0.127: v1(101.05,156.83) 101.21,156.83 102.17,155.87 U40.2 ; R472.2 109.52,153.68 v1(108.8,153.68) 108.31,153.68 108.11,153.48 107.82,153.48 107.6,153.26 U40.16
IVDDO: length 2.2
  BOTTOM w0.203: U40.38 100.08,150.46 v2(99.88,150.66) 100.08,150.86 U40.39
  vias: v1(101.3,149.21)
IVDDO_18: length 4.8
  BOTTOM w0.203: v1(108.16,150.73) 108.04,150.86 U40.22 ; v1(106.61,148.32) 106.17,148.76 U40.25 ; U40.31 103.77,148.45 v1(103.56,148.24) 103.37,148.44 U40.32
  BOTTOM w0.508: L28.1 v1(111.21,147.3)
  vias: v1(109.18,150.73)
JTAG_TCK: length 11.9
  BOTTOM w0.102: U43.AE5 33.9,123.11 33.49,122.7 33.49,121.56 33.23,121.3 30.57,121.3
  BOTTOM w0.14: R567.1 27.89,121.91 TP124.1 28.5,121.3 30.57,121.3
JTAG_TDI: length 13.5
  BOTTOM w0.102: U43.AE6 33.49,123.75 33.49,123.18 33.11,122.8 32.96,122.8 32.7,122.55 32.7,122.26 32.5,122.06 30.57,122.06
  BOTTOM w0.14: 30.57,122.06 29.14,122.06 TP122.1 27.9,122.92 27.64,123.17 25.23,123.17 24.72,122.67 23.32,122.67 R552.1
JTAG_TDO: length 5.7
  BOTTOM w0.102: 30.57,123.3 32.04,123.3 32.5,123.77 32.7,123.77 U43.AF6
  BOTTOM w0.14: TP120.1 28.66,124.44 29.8,123.3 30.57,123.3
JTAG_TMS: length 17
  BOTTOM w0.102: 30.94,120.01 31.79,120.01 32.15,119.64 33.97,119.64 34.25,119.92 34.25,123.43 34.7,123.88 U43.AD6
  BOTTOM w0.14: 30.94,120.01 28.4,120.01 TP127.1 27.64,120.76 25.74,120.76 25.36,120.38 23.44,120.38 R566.1
JTAG_TRST#: length 9.2
  BOTTOM w0.102: U43.AG4 32.25,122.41 30.57,122.41
  BOTTOM w0.14: 30.57,122.41 29.8,122.41 28.53,123.68 25.1,123.68 v1(24.85,123.94) 24.71,124.07 R553.1
KB_BL_LED: length 115.3
  TOP w0.14: U32.88 156.97,62.93 v1(157.89,62.02) ; v1(66.91,50.3) Q31.2 68.89,50.3 69.12,50.07 v1(69.12,48.13)
  BOTTOM w0.14: v1(69.12,48.13) 69.12,47.15 70.44,45.83 81.24,45.83 81.52,46.11 81.52,48.31 82.14,48.93 83.85,48.93 85.14,47.64 88.82,47.64 89.53,48.35 94.64,48.35 95.81,49.52 122.01,49.52 126.35,53.86 127.03,53.86 128.92,55.75 131.27,55.75 134.68,52.34 136.76,52.34 139.63,49.46 148.75,49.46 150.96,51.67 154.64,51.67 156.97,54 156.97,61.03 157.89,61.94 v1(157.89,62.02)
L_SPK2: length 4.7
  TOP w0.203: U34.24 236.98,36.34 237.32,36
  TOP w0.508: TP101.1 239.99,34.27 239.05,34.27 237.32,36
L_SPK+: length 49.7
  TOP w0.203: v2(234.4,45.58) 234.4,45.37 v1(234.81,44.97) 234.98,44.79 U34.42
  TOP w0.508: R428.1 233.64,7.25 v2(233.26,7.63)
  IN3 w0.508: v2(234.4,45.58) 234.53,45.58 234.96,45.15 234.96,44.1 234.02,43.16 233.63,43.16 232.42,41.96 232.42,38.4 228.69,34.67 228.69,30.84 229.45,30.08 232.74,30.08 233.89,28.93 233.89,24.86 234.4,24.36 234.4,8.37 233.66,7.63 v2(233.26,7.63)
L_SPK+_1: length 9.2
  TOP w0.508: v2(234.17,4.48) 233.75,4.06 C519.1 233.51,4.18 233.38,4.31 233.38,4.94 233.64,5.19 R428.2
  BOTTOM w0.508: v2(234.17,4.48) 234.27,4.58 234.27,7.72 235.17,8.62 236.09,8.62 236.31,8.84 CN22.4
L_SPK-: length 47.9
  TOP w0.203: v2(234.04,44.74) 234.58,44.2 U34.43
  TOP w0.508: v2(233.26,8.52) 233.87,8.52 v1(234.27,8.11) 234.91,7.48 R429.1
  IN3 w0.508: v2(234.04,44.74) 234.04,44.45 233.65,44.05 233.26,44.05 231.53,42.33 231.53,38.77 227.8,35.04 227.8,30.48 229.08,29.19 232.37,29.19 233,28.56 233,24.49 233.51,23.99 233.51,8.77 v2(233.26,8.52)
L_SPK-_1: length 7.7
  TOP w0.508: v2(235.62,4.51) 235.48,4.51 C520.1 234.91,4.18 R429.2
  BOTTOM w0.508: CN22.3 236.31,7.59 236.16,7.73 235.54,7.73 235.16,7.35 235.16,4.96 v2(235.62,4.51)
LAN_DISABLE#: length 12.4
  TOP w0.089: 141.83,108.33 141.56,108.59 141.56,109.33 141.08,109.81 141.08,111.94 v1(141.46,112.32)
  TOP w0.14: 141.83,108.33 v1(142.43,107.73) 143.07,107.08 143.07,106.54 144.74,104.87 144.74,103.54 145.68,102.61 R220.1
  BOTTOM w0.089: U45.AM7 141.41,112.32 141.46,112.32 v1(141.46,112.32)
