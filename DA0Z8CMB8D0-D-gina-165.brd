# Allegro board DA0Z8CMB8D0-D-gina-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LAN_RESET: length 6.4
  TOP w0.14: v1(221.83,93.46) 221.07,93.46 R247.1 221.2,93.06 221.2,89.02 220.89,88.71 U24.62
LAN_WAKE#: length 84.4
  TOP w0.14: R308.1 212.44,71.35 v1(212.68,71.1) ; R317.1 154.51,71.39 154.82,71.08 v1(154.82,71.13)
  IN2 w0.114: v1(212.68,71.1) 212.68,72.37 210.09,74.96 210.09,79.23 207.45,81.87 207.45,82.13 206.63,82.95 202.84,82.95 197.47,88.33 187.05,88.33 185.19,86.46 183.61,86.46 182.36,87.72 167.7,87.72 165.31,85.33 165.31,75.78 163.05,73.52 v1(162.52,73.52)
  BOTTOM w0.14: v1(162.52,73.52) 162.52,72.25 161.63,71.36 155.05,71.36 v1(154.82,71.13)
LAN_XTAL2: length 8.9
  TOP w0.14: Y1.1 224.88,93.58 C301.1 224.88,91.31 R271.2 223.2,89.63 v1(223.2,89.16) 223.2,88.86 222.05,87.71 U24.60
LAN_XTALI: length 12.2
  TOP w0.14: U24.59 220.34,87.22 222.33,87.22 v1(222.92,87.82) 223.8,88.69 223.8,89.45 R271.1 225.51,91.16 225.51,91.69 C302.1 226.01,92.69 226.01,94.29 Y1.3
LANWAKE#: length 9.5
  TOP w0.14: U24.40 215.48,80.23 214.97,79.71 214.97,78.11 215.1,77.98 R294.1 215.1,75.61 Q27.1 214.95,74.81 215.1,74.67 R303.2 216.61,74.67 v1(216.62,74.66)
LCD_VIN:
  vias: v1(51.37,103.11) v1(51.98,103.11) v1(52.61,103.11) v3(52.54,104.76)
LCDVCC:
  vias: v1(51.65,102.22) v1(52.28,102.22) v3(53.37,102.12)
LCDVCC_1:
  vias: v1(45.55,101.96) v1(46.16,103.31) v1(46.49,103.84) v1(46.8,103.31)
LED0/SPICSB: length 6.1
  TOP w0.14: U24.51 220.89,83.21 222.72,81.39 224.85,81.39 225.26,80.98 TP91.1
LED1/SPICLK/EESK: length 2.2
  TOP w0.14: TP90.1 220.62,82.21 U24.49
LED3/SPIDO/EEDO: length 2.4
  TOP w0.14: TP92.1 216.62,79.49 217.23,80.1 217.23,80.71 216.98,80.95 U24.43
LID#: length 204.9
  TOP w0.14: v1(68.67,83.63) 68.03,84.26 68.03,96.76 67.01,97.77 67.01,102.29 66.25,103.05 60.98,103.05 59.9,104.12 D5.1 58.73,106.06 58.38,106.41 58.38,107.68 58.76,108.06 59.65,108.06 60.79,109.2 v1(60.79,109.71) ; v1(154.39,61.76) 154.57,61.76 154.94,62.13 U32.86
  IN3 w0.089: v1(31.58,119.01) 33.69,116.9 33.69,115.15 37.7,111.14 38.98,111.14 39.23,110.88 52.31,110.88 52.61,111.19 59.32,111.19 v1(60.79,109.71)
  BOTTOM w0.102: 114.27,70.74 119.71,70.74
  BOTTOM w0.14: CN6.11 12.52,117.93 15.79,114.66 17.78,114.66 20.09,116.97 20.09,117.4 22.39,119.69 27.06,119.69 27.9,118.86 28.79,118.86 28.94,119.01 v1(31.58,119.01) ; v1(68.67,83.63) 69.25,83.63 69.32,83.7 74.02,83.7 75.18,82.53 84.57,82.53 95.48,71.62 102.94,71.62 103.83,70.74 114.27,70.74 ; v1(154.39,61.76) 154.9,61.25 154.9,60.56 154.39,60.05 154.05,60.05 152.59,58.59 150.86,58.59 150.03,57.76 145.37,57.76 143.33,55.72 141.45,55.72 140.86,56.31 140.86,57.45 138.47,59.85 137.92,59.85 136.74,58.66 132.42,58.66 131.68,59.4 131.55,59.4 128.86,62.09 128.86,63.23 126.75,65.34 126.75,70.04 126.06,70.74 119.71,70.74
LM393_PIN2: length 10.3
  BOTTOM w0.254: PU8.2 94.07,117.84 93.15,116.93 93.15,113.73 93.99,112.89 v3(94.45,112.89) 95.08,112.25 PR157.2 PR158.2
LPC_LAD0: length 231.5
  TOP w0.14: U32.10 141,62.53 141.61,61.91 142.48,61.91 v1(142.81,61.58)
  IN1 w0.114: v1(213.06,68.51) 213.9,68.51 216.84,65.57 216.84,62.68 217.87,61.65 218.94,61.65 221.16,59.43 221.16,54.93 221.39,54.7 221.39,48.32 220.18,47.11 220.18,42.27 217.46,39.56 209.08,39.56 208.04,40.6 194.02,40.6 191.49,43.13 187.16,43.13 184.62,45.68 178.26,45.68 174.08,41.5 172.07,41.5 171.31,40.75 168.87,40.75 168.49,41.13 164.68,41.13 162.26,43.54 162.26,44.81 v1(161.63,45.45) 161.02,45.45 156.68,49.8 156.68,51.29 156.24,51.72 156.24,53.68 154.1,55.83 151.6,55.83 150.59,56.83 149.54,56.83 148.34,58.02 146.37,58.02 v1(142.81,61.58) 142.81,63.03 142.89,63.1 142.89,64.28 143.42,64.8 143.42,65.25 144.2,66.02 144.2,66.57 145.44,67.81 146.39,67.81 147.02,68.44 148.17,68.44 150.21,70.48 150.59,70.48 151.2,71.08 152.71,71.08 155.39,73.75 155.39,83.15 155.98,83.75 157.49,83.75 158.72,84.97 158.72,87.18 157.69,88.21 157.69,88.78 v1(157.87,88.96)
  BOTTOM w0.076: U45.AU14 137.37,109.02 137.37,107.3 137.63,107.04 137.63,105.19 138.32,104.5 138.32,103.87
  BOTTOM w0.14: R696.1 215.93,87.18 212.89,87.18 211.77,86.06 211.77,83.45 207.77,79.45 207.77,76.02 210.12,73.67 210.12,71.77 213.06,68.82 v1(213.06,68.51) ; 138.32,103.87 138.32,96.12 141.64,92.8 v1(141.77,92.8) 143.26,91.31 150.85,91.31 151.06,91.52 152.96,91.52 153.32,91.88 154.95,91.88 157.87,88.96 v1(157.87,88.96) ; U56.26 162.14,45.96 v1(161.63,45.45)
LPC_LAD1: length 231.5
  TOP w0.14: v1(143.77,61.83) 143.16,61.83 142.81,62.18 141.72,62.18 140.98,62.93 U32.9
  IN1 w0.114: v1(158.2,89.82) 158.76,89.26 158.76,87.84 159.56,87.04 159.56,84.97 157.85,83.26 156.18,83.26 155.87,82.95 155.87,73.21 154.29,71.62 154.29,70.89 153.97,70.56 151.37,70.56 150.79,69.99 150.41,69.99 148.37,67.95 147.22,67.95 146.59,67.33 145.64,67.33 144.7,66.38 144.7,65.82 144.13,65.25 144.13,63.59 143.96,63.42 143.96,62.23 143.77,62.05 v1(143.77,61.83) 143.77,61.32 145.12,59.97 146.27,59.97 147.65,58.59 148.46,58.59 149.72,57.33 151.46,57.33 151.7,57.57 152.23,57.57 152.83,56.97 154.98,56.97 157.39,54.56 157.39,49.77 158.91,48.24 160.14,48.24 163.17,45.22 163.17,44.04 163.84,43.37 v1(164.55,43.37) 165.9,42.02 171.37,42.02 172.1,42.75 174.65,42.75 178.06,46.16 184.82,46.16 187.36,43.61 193.8,43.61 196.31,41.1 208.27,41.1 209.33,40.04 217.26,40.04 219.69,42.48 219.69,47.31 220.91,48.52 220.91,54.5 220.63,54.78 220.63,59.27 218.74,61.17 217.67,61.17 216.33,62.5 216.33,65.4 214.08,67.65 v1(213.09,67.65)
  BOTTOM w0.076: 137.99,107.17 137.99,107.32 137.99,107.32 137.99,107.8 U45.AW12
  BOTTOM w0.089: 137.99,107.17 137.99,105.33 138.85,104.46 138.85,103.93
  BOTTOM w0.14: v1(213.09,67.65) 212.63,68.11 212.63,68.79 209.81,71.61 209.81,73.59 207.5,75.9 207.5,79.56 211.5,83.56 211.5,86.56 213.04,88.1 215.7,88.1 R695.1 ; 138.85,103.93 138.85,96.78 140.55,95.08 141.14,95.08 144.38,91.84 150.63,91.84 151.52,92.73 153.22,92.73 153.54,92.41 155.2,92.41 157.69,89.93 158.1,89.93 v1(158.2,89.82) ; v1(164.55,43.37) 163.91,44.01 U56.23
LPC_LAD2: length 229.4
  TOP w0.14: v1(143.34,62.26) 143.16,62.45 141.83,62.45 140.95,63.33 U32.8
  IN1 w0.114: v1(212.19,68.5) 212.61,68.08 213.99,68.08 216.59,65.49 216.59,62.59 217.77,61.41 218.84,61.41 220.92,59.33 220.92,54.83 221.15,54.6 221.15,48.42 219.93,47.21 219.93,42.38 217.36,39.8 209.23,39.8 208.19,40.84 196.23,40.84 193.7,43.37 187.26,43.37 184.72,45.92 178.16,45.92 174.75,42.51 172.3,42.51 171.48,41.7 165.38,41.7 165.02,42.06 v1(164.55,42.06) 162.92,43.69 162.92,45.12 160.04,48 158.81,48 157.11,49.71 157.11,54.5 154.88,56.73 152.73,56.73 152.13,57.32 151.8,57.32 151.56,57.09 149.62,57.09 148.36,58.35 147.53,58.35 146.15,59.73 145.01,59.73 143.34,61.4 v1(143.34,62.26) 143.34,63.14 143.85,63.65 143.85,65.31 144.46,65.92 144.46,66.48 145.54,67.57 146.49,67.57 147.12,68.2 148.27,68.2 150.31,70.23 150.69,70.23 151.29,70.83 152.82,70.83 155.63,73.64 155.63,83.05 156.08,83.5 157.75,83.5 158.96,84.72 158.96,87.28 158.3,87.94 v1(158.3,88.5)
  BOTTOM w0.076: 137.8,107.17 137.8,107.2 137.7,107.3 U45.AY12
  BOTTOM w0.089: 138.58,104 138.58,104.48 137.8,105.26 137.8,107.17
  BOTTOM w0.14: 138.58,104 138.58,96.66 143.63,91.62 143.76,91.62 143.81,91.57 150.74,91.57 151.64,92.47 153.11,92.47 153.42,92.15 155.09,92.15 157.82,89.42 158.05,89.42 158.3,89.16 v1(158.3,88.5) ; v1(164.55,42.06) U56.20 ; v1(212.19,68.5) 209.32,71.37 209.32,73.71 207.23,75.79 207.23,79.67 210.96,83.39 210.96,88.56 R693.1
LPC_LAD3: length 236.3
  TOP w0.14: U32.7 140.94,63.73 141.95,62.72 143.53,62.72 144.26,61.99 v1(144.26,61.45)
  IN1 w0.114: v1(158.2,90.43) 159.01,89.62 159.01,87.94 159.8,87.16 159.8,84.87 157.95,83.02 156.28,83.02 156.11,82.85 156.11,72.46 155.41,71.76 155.41,71.13 154.57,70.29 151.47,70.29 150.96,69.78 150.96,69.1 149.57,67.71 147.57,67.71 145.96,66.1 145.96,64.7 144.26,63 v1(144.26,61.45) 144.26,61.18 145.22,60.21 147.19,60.21 148.04,59.37 148.04,59.08 148.29,58.83 148.56,58.83 149.62,57.77 150.38,57.77 150.85,58.24 151.9,58.24 152.93,57.21 155.08,57.21 157.64,54.64 157.64,50.28 159.29,48.62 160.11,48.62 163.41,45.32 163.41,44.56 164.17,43.8 165.31,43.8 v1(166.33,42.78) 166.84,42.27 171.28,42.27 172.68,43.67 175.23,43.67 177.97,46.42 184.92,46.42 187.47,43.87 193.9,43.87 196.4,41.37 208.38,41.37 209.46,40.29 217.15,40.29 219.44,42.58 219.44,47.39 220.67,48.62 220.67,54.4 220.39,54.67 220.39,59.17 218.64,60.92 217.57,60.92 216.09,62.4 216.09,65.28 214.16,67.22 212.78,67.22 v1(212.18,67.83)
  BOTTOM w0.076: 139.75,103.49 139.75,104.06 139.03,104.78 139.03,106.84 138.79,107.07 138.79,107.09 138.74,107.14 138.74,107.65 138.45,107.94 U45.AW11
  BOTTOM w0.14: v1(166.33,42.78) 166.33,41.39 165.05,40.11 U56.17 ; 139.75,103.49 139.75,103.01 140.15,102.62 140.15,97.41 140.98,96.58 142.81,96.58 146.25,93.13 149.81,93.13 150.7,94.03 153.75,94.03 154.07,93.71 155.74,93.71 158.2,91.25 v1(158.2,90.43) ; v1(212.18,67.83) 209.05,70.95 209.05,73.59 206.97,75.68 206.97,79.87 210.65,83.55 210.65,87.99 210.02,88.63 210.02,90.35 210.96,91.3 R691.1
LPC_LFRAME#: length 234.6
  TOP w0.14: v1(208.11,39.35) 217.86,39.35 221.59,43.08 221.59,44.67 222.84,45.93 222.84,48.08 234.03,59.27 234.03,67.8 233.7,68.13 231.81,68.13 231.11,68.83 229.97,68.83 227.94,70.86 227.94,74.52 227.2,75.26 227.2,80.39 227.71,80.89 227.71,88.29 228.69,89.26 228.69,90.29 R270.1 ; v1(142.23,63.38) 141.48,64.13 U32.6
  IN1 w0.114: v1(157.61,90.92) 157.06,90.36 157.06,87.87 157.68,87.25 157.68,85.19 156.86,84.37 155.57,84.37 154.64,83.44 154.64,79.49 153.58,78.42 153.58,75.98 154.26,75.29 154.26,73.52 152.47,71.73 150.96,71.73 150.34,71.1 149.48,71.1 148.47,70.09 147.79,70.09 146.14,68.44 145.19,68.44 142.5,65.75 142.5,64.77 142.23,64.5 v1(142.23,63.38) 142.17,63.32 142.17,61.32 146.11,57.39 148.09,57.39 149.27,56.21 150.33,56.21 151.34,55.2 153.83,55.2 155.58,53.45 155.58,51.5 156.04,51.04 156.04,49.55 161.63,43.96 v1(161.63,42.02) 161.95,42.02 163.86,40.11 173.57,40.11 178.51,45.05 184.36,45.05 186.9,42.51 191.23,42.51 193.78,39.96 207.5,39.96 v1(208.11,39.35)
  BOTTOM w0.076: 138.17,107.17 138.17,107.32 138.16,107.32 138.16,108.25 U45.AV12
  BOTTOM w0.089: 139.5,103.62 139.5,104.07 138.17,105.4 138.17,107.17
  BOTTOM w0.14: 139.5,103.62 139.5,97.14 140.71,95.93 142.44,95.93 v1(144.28,94.09) 145.88,92.49 150.08,92.49 150.97,93.38 153.49,93.38 153.8,93.06 155.47,93.06 v1(157.61,90.92) ; v1(161.63,42.02) 161.63,42.91 162.08,43.36 U56.22
LVDS_BRIGHT: length 7.4
  BOTTOM w0.14: CN7.27 59.05,103.9 58.63,103.49 57.99,103.49 56.98,102.47 56.6,102.47 v1(56.35,102.22) 56.35,101.84 56.73,101.46 C674.1 R672.1 R671.1
M_A_A0: length 154.2
  TOP w0.102: U31.N3 115.69,60.05 115.69,59.89 116.11,59.47 116.11,59.27 116.55,58.83 117.08,58.83 117.1,58.85 117.77,58.85 v1(117.98,58.63) ; v1(104.77,58.73) 104.6,58.9 103.89,58.9 103.84,58.86 103.19,58.86 102.96,59.09 102.96,59.73 U30.N3 ; U29.N3 83.95,60.13 84.36,59.72 84.36,59.14 84.56,58.95 85.9,58.95 85.98,58.87 v1(85.98,58.73) ; v1(72.77,58.73) 72.77,58.87 72.71,58.93 71.42,58.93 71.15,59.2 71.15,59.48 71.1,59.53 70.91,59.53 70.68,59.76 70.68,60 U28.N3
  IN1 w0.178: v1(66.33,59.06) 66.73,58.66 71.33,58.66 71.46,58.78 71.71,58.78 71.86,58.94 72.33,58.94 72.53,58.73 v1(72.77,58.73) 73.04,58.73 73.47,59.17 74.01,59.17 74.88,58.3 77.21,58.3 77.69,58.78 79.67,58.78 81.07,57.39 81.62,57.39 81.87,57.64 83.16,57.64 84.37,58.85 84.98,58.85 85.2,59.06 85.46,59.06 85.8,58.73 v1(85.98,58.73) 86.24,58.73 86.85,58.12 88.81,58.12 89.35,57.58 90.51,57.58 91.06,58.12 92.22,58.12 92.57,57.77 102.07,57.77 103.03,58.73 103.62,58.73 103.95,59.06 104.23,59.06 104.56,58.73 v1(104.77,58.73) 105.58,58.73 106.16,58.15 108.57,58.15 110.09,59.67 110.66,59.67 111.68,58.65 111.68,58.51 112.48,57.71 115.23,57.71 116.18,58.66 116.79,58.66 117.02,58.89 117.61,58.89 117.87,58.63 v1(117.98,58.63)
  IN1 w0.203: v1(117.98,58.63) 118.58,58.63 119.15,58.06 121.74,58.06 122,58.33 124.08,58.33 125.22,59.47 128.28,59.47 128.89,60.08 130.63,60.08 130.89,59.83 v1(131.78,59.83)
  IN3 w0.076: v1(122.83,109.1) 123.25,108.68 123.25,104.23 123.68,103.79 123.68,99.65
  IN3 w0.152: v1(131.78,59.83) 131.91,59.95 131.91,69.18 131.3,69.79 131.3,74.38 128.94,76.74 128.94,82.31 128.41,82.84 128.11,82.84 125.82,85.13 125.82,87.84 125.56,88.1 123.68,89.98 123.68,99.65
  BOTTOM w0.102: U51.N3 86.96,60.32 87.03,60.39 87.34,60.39 87.41,60.31 87.41,59.78 87.32,59.68 86.74,59.68 85.98,58.92 v1(85.98,58.73) ; U52.N3 105.91,60.27 106.1,60.27 106.21,60.17 106.21,60 106.36,59.85 106.36,59.72 106.21,59.57 106.05,59.57 105.92,59.7 105.67,59.7 104.77,58.81 v1(104.77,58.73) ; U50.N3 73.76,60.29 73.85,60.39 74.13,60.39 74.21,60.31 74.21,59.75 74.13,59.68 73.53,59.68 72.77,58.93 v1(72.77,58.73) ; v1(117.98,58.63) 117.98,58.81 118.88,59.7 119.08,59.7 119.19,59.6 119.39,59.6 119.52,59.72 119.52,59.91 119.37,60.05 119.37,60.2 119.3,60.27 119.11,60.27 U53.N3 ; R747.2 65.52,58.53 66.05,59.06 v1(66.33,59.06) ; v1(122.83,109.1) 122.98,109.1 U45.AU36
M_A_A1: length 152.9
  TOP w0.102: v1(72.77,57.63) 72.85,57.63 73.4,58.18 73.4,58.79 73.51,58.91 73.97,58.91 74.21,59.15 74.21,59.47 74.12,59.55 73.98,59.55 U28.P7 ; v1(85.98,57.63) 86.06,57.63 86.61,58.18 86.61,58.79 86.72,58.91 87.18,58.91 87.42,59.15 87.42,59.47 87.33,59.55 87.19,59.55 U29.P7 ; U31.P7 119.19,59.55 119.34,59.55 119.43,59.47 119.43,59.15 119.18,58.91 118.7,58.91 118.61,58.82 118.61,58.21 118.03,57.63 v1(117.98,57.63) ; U30.P7 105.99,59.55 106.13,59.55 106.22,59.47 106.22,59.12 106,58.91 105.54,58.91 105.4,58.77 105.4,58.18 104.85,57.63 v1(104.77,57.63)
  IN3 w0.14: v1(117.98,57.63) 117.83,57.63 117.56,57.9 117.2,57.9 117.06,57.76 111.62,57.76 111.49,57.89 111.49,58.25 111.36,58.38 111.06,58.38 110.93,58.25 110.93,57.89 110.8,57.76 110.5,57.76 110.37,57.89 110.37,58.25 110.24,58.38 109.94,58.38 109.81,58.25 109.81,57.89 109.69,57.76 104.91,57.76 v1(104.77,57.63) 104.62,57.63 104.31,57.94 104.03,57.94 103.86,57.76 103.32,57.76 102.98,58.1 102.52,58.1 102.18,57.76 98.87,57.76 98.21,58.43 90.62,58.43 89.8,57.6 89.44,57.6 88.85,58.19 86.55,58.19 85.99,57.63 v1(85.98,57.63) 85.78,57.63 85.47,57.94 85.24,57.94 85.06,57.76 84.71,57.76 83.53,56.58 74.84,56.58 74.71,56.7 74.71,57.5 74.58,57.63 74.28,57.63 74.15,57.5 74.15,57.36 74.02,57.24 73.72,57.24 73.59,57.36 73.59,57.5 73.47,57.63 v1(72.77,57.63) 72.54,57.63 72.36,57.81 70.53,57.81 70.14,58.2 67.45,58.2 v1(67.01,57.77)
  IN3 w0.152: v1(117.98,57.63) 118.34,57.63 119.25,56.71 124.39,56.71 125.26,55.84 127.34,55.84 128.76,57.26 128.76,63.71 128.05,64.42 128.05,70.16 127.72,70.5 127.72,73.19 127.26,73.65 127.26,74.76 126.4,75.63 125.27,75.63 124.08,76.81 124.08,80.28 123.67,80.69 123.67,82.74 121.7,84.72 121.7,85.88 121.73,85.91 121.73,88.15 121.19,88.68 121.19,99.42 121.37,99.61 121.37,103.31 v1(121.27,103.41)
  BOTTOM w0.102: U53.P7 115.77,59 116.34,58.43 116.34,58.04 116.59,57.79 117.82,57.79 v1(117.98,57.63) ; R751.2 65.24,57.77 v1(67.01,57.77) ; v1(104.77,57.63) 104.57,57.84 103.34,57.84 103.13,58.04 103.13,58.64 102.56,59.21 U52.P7 ; v1(85.98,57.63) 85.77,57.84 84.54,57.84 84.34,58.04 84.34,58.64 83.76,59.21 U51.P7 ; U50.P7 70.56,59.21 71.13,58.64 71.13,58.04 71.34,57.84 72.56,57.84 v1(72.77,57.63) ; U45.AY37 122.4,104.42 121.4,103.41 v1(121.27,103.41)
M_A_A2: length 149.8
  TOP w0.102: U28.P3 70.48,59.25 70.48,59.04 70.63,58.89 71.07,58.89 71.25,58.7 72.07,58.7 72.14,58.62 v1(72.14,58.49) ; U29.P3 83.69,59.25 83.69,59.03 83.85,58.86 84.3,58.86 84.46,58.7 85.28,58.7 85.35,58.62 v1(85.35,58.49) ; v1(117.39,58.44) 117.21,58.62 116.45,58.62 116.21,58.86 115.83,58.86 115.68,59.01 115.68,59.24 U31.P3 ; 64.34,57.94 65.51,57.94 v1(66,58.43) ; R359.2 62.7,56.51 v1(62.7,56.5) ; v1(104.15,58.49) 103.98,58.66 102.93,58.66 102.84,58.75 102.84,58.85 102.74,58.95 102.56,58.95 102.47,59.04 102.47,59.24 U30.P3
  TOP w0.241: 64.34,57.94 63.26,57.94 R359.2
  IN3 w0.076: 121.12,102.35 120.61,102.85 120.61,103.8 120.84,104.03 120.84,109.27 v1(121.8,110.23)
  IN3 w0.14: v1(117.39,58.44) 117.2,58.63 116.06,58.63 115.57,58.14 112.31,58.14 110.77,59.67 109.93,59.67 108.52,58.26 106.26,58.26 105.72,58.81 105.47,58.81 104.92,58.26 104.57,58.26 104.34,58.49 v1(104.15,58.49) 103.92,58.49 103.73,58.67 103.24,58.67 102.85,59.07 101.96,59.07 101.84,58.95 101.84,58.28 101.71,58.16 98.96,58.16 98.35,58.77 90.22,58.77 89.98,58.53 86.41,58.53 86.12,58.24 85.69,58.24 85.45,58.49 v1(85.35,58.49) 85.11,58.73 84.59,58.73 83.6,57.74 81.82,57.74 81.7,57.62 81.7,57.05 81.57,56.92 77.02,56.92 76.89,57.05 76.89,57.62 76.77,57.74 75.22,57.74 74.89,58.07 72.63,58.07 72.21,58.49 v1(72.14,58.49) 71.96,58.67 67.41,58.67 67.37,58.63 66.2,58.63 v1(66,58.43)
  IN3 w0.152: v1(117.39,58.44) 117.52,58.44 117.89,58.07 118.53,58.07 118.79,57.81 124.4,57.81 125.47,56.74 126.57,56.74 126.76,56.93 127.82,56.93 128.33,57.44 128.33,63.53 127.62,64.24 127.62,69.99 127.29,70.32 127.29,72.83 126.15,73.97 126.15,74.71 125.59,75.27 125.12,75.27 123.73,76.66 123.73,80.08 123.32,80.49 123.32,82.59 121.34,84.57 121.34,85.76 120.81,86.29 120.81,99.45 121.12,99.76 121.12,102.35
  BOTTOM w0.102: v1(117.39,58.44) 117.61,58.22 118.15,58.22 118.63,58.69 118.63,58.99 U53.P3 ; v1(104.15,58.49) 104.32,58.32 105.08,58.32 105.42,58.66 105.42,58.99 U52.P3 ; U50.P3 73.41,58.99 73.41,58.66 73.07,58.32 72.31,58.32 v1(72.14,58.49) ; v1(121.8,110.23) 122.12,110.56 U45.AR38 ; U51.P3 86.62,58.99 86.62,58.66 86.28,58.32 85.52,58.32 v1(85.35,58.49)
M_A_A3: length 158.9
  TOP w0.102: v1(65.59,59.19) 65.52,59.19 R355.2 ; v1(117.34,59.46) 117.34,59.69 117.2,59.83 117,59.83 116.87,59.7 116.47,59.7 116.1,60.07 116.1,60.27 115.77,60.59 115.12,60.59 114.97,60.43 U31.N2 ; U28.N2 69.76,60.4 70.07,60.72 70.25,60.72 70.48,60.49 70.66,60.49 70.89,60.27 70.89,59.84 70.97,59.76 71.96,59.76 v1(72.18,59.54) ; v1(85.39,59.6) 85.21,59.78 84.59,59.78 83.89,60.48 83.56,60.48 83.5,60.54 83.5,60.72 83.42,60.79 83.3,60.79 83.19,60.68 83.19,60.23 83.09,60.13 U29.N2 ; U30.N2 101.66,60.23 101.66,60.44 101.76,60.54 101.84,60.54 102.02,60.72 102.26,60.72 102.39,60.59 102.78,60.59 103.11,60.26 103.11,60.11 103.36,59.85 103.95,59.85 104.03,59.77 v1(104.03,59.52)
  IN1 w0.178: v1(117.34,59.46) 117.12,59.68 116.34,59.68 115.56,58.9 115.56,58.65 115,58.09 112.64,58.09 112.06,58.67 112.06,58.81 110.82,60.05 109.93,60.05 108.41,58.53 106.32,58.53 105.68,59.18 104.66,59.18 104.32,59.52 v1(104.03,59.52) 103.74,59.52 103.54,59.72 103.13,59.72 101.56,58.15 92.73,58.15 92.38,58.51 90.9,58.51 90.47,58.07 90.19,58.07 90.05,58.21 90.05,58.38 89.92,58.51 87.11,58.51 86.25,59.36 85.77,59.36 85.53,59.6 v1(85.39,59.6) 85.18,59.6 84.97,59.8 84.59,59.8 83.56,58.78 83.56,58.65 82.94,58.02 80.97,58.02 79.83,59.17 77.54,59.17 77.05,58.68 75.03,58.68 74.17,59.55 73.31,59.55 73.13,59.36 72.36,59.36 v1(72.18,59.54) 72.02,59.54 71.76,59.8 70.82,59.8 70.06,59.04 68.23,59.04 67.71,59.56 65.96,59.56 v1(65.59,59.19)
  IN1 w0.203: v1(117.34,59.46) 117.6,59.46 117.89,59.17 118.63,59.17 119.32,58.47 121.57,58.47 121.88,58.78 122.99,58.78 123.47,59.27 124.45,59.27 125.06,59.88 128.05,59.88 129.12,60.94 v1(131.35,60.94)
  IN3 w0.076: 123.33,99.86 123.33,100.14 123.45,100.26 123.45,103.62 122.89,104.17 122.89,107.65 122.34,108.21 122.34,110.62 v1(122.75,111.03)
  IN3 w0.152: 123.33,99.86 123.33,89.83 125.46,87.7 125.46,84.99 127.82,82.62 127.82,77.22 130.95,74.1 130.95,73.65 130.87,73.57 130.87,69.61 131.35,69.13 v1(131.35,60.94)
  BOTTOM w0.102: U53.N2 119.37,60.53 118.87,60.53 118.6,60.26 118.6,59.74 118.05,59.19 117.6,59.19 v1(117.34,59.46) ; U52.N2 106.16,60.53 105.69,60.53 105.39,60.23 105.39,59.75 104.94,59.3 104.25,59.3 v1(104.03,59.52) ; U50.N2 74.56,60.41 74.38,60.59 73.74,60.59 73.22,60.07 73.22,59.69 72.87,59.34 72.38,59.34 v1(72.18,59.54) ; U45.AP36 122.92,111.21 v1(122.75,111.03) ; U51.N2 87.76,60.44 87.61,60.59 86.92,60.59 86.43,60.1 86.43,59.69 86.13,59.39 85.59,59.39 v1(85.39,59.6)
M_A_A4: length 171.2
  TOP w0.102: v1(72.18,56.28) 72.35,56.11 73.42,56.11 74.18,56.87 74.18,58.79 74.56,59.17 U28.P8 ; U31.P8 119.77,59.17 119.39,58.79 119.39,56.87 118.63,56.11 117.56,56.11 v1(117.39,56.28) ; v1(66.63,56.75) 65.11,56.75 64.86,56.51 R364.2 ; v1(85.39,56.28) 85.56,56.11 86.63,56.11 87.39,56.87 87.39,58.79 87.76,59.17 U29.P8 ; v1(104.18,56.28) 104.36,56.11 105.42,56.11 106.18,56.87 106.18,58.79 106.56,59.17 U30.P8
  IN3 w0.076: 122.97,99.76 122.97,100.09 123.22,100.34 123.22,103.34 122.64,103.92 122.64,107.27 121.83,108.09 121.83,108.52 v1(121.25,109.1)
  IN3 w0.14: v1(66.63,56.75) 66.76,56.63 71.59,56.63 71.94,56.28 v1(72.18,56.28) 72.34,56.28 72.73,55.89 79.16,55.89 79.28,55.77 79.28,55.56 79.41,55.43 79.71,55.43 79.84,55.56 79.84,55.77 79.97,55.89 80.27,55.89 80.4,55.77 80.4,55.37 80.53,55.24 80.83,55.24 80.96,55.37 80.96,55.77 81.09,55.89 84.03,55.89 84.64,56.5 85,56.5 85.22,56.28 v1(85.39,56.28) 85.59,56.08 86.32,56.08 86.45,56.21 86.45,56.4 86.57,56.52 89.69,56.52 90.91,57.74 97.92,57.74 98.59,57.07 103.01,57.07 103.13,56.95 103.13,56.72 103.26,56.59 103.7,56.59 104.01,56.28 v1(104.18,56.28) 104.34,56.28 104.57,56.06 104.99,56.06 105.71,56.78 105.85,56.78 106.12,56.51 106.26,56.51 106.38,56.64 106.38,56.95 106.51,57.07 106.82,57.07 106.94,56.95 106.94,56.64 107.07,56.51 110.19,56.51 110.32,56.64 110.32,56.95 110.45,57.07 116.25,57.07 116.73,56.59 116.91,56.59 117.22,56.28 v1(117.39,56.28)
  IN3 w0.152: 122.97,99.76 122.97,89.68 125.1,87.55 125.1,84.84 127.47,82.48 127.47,77.07 129.96,74.58 129.96,73.69 130.44,73.21 130.44,69.43 130.92,68.95 130.92,59.29 131.2,59.01 131.2,58.1 131.28,58.02 131.28,57.26 130.79,56.78 129.51,56.78 127.71,54.97 124.9,54.97 124.03,55.85 118.59,55.85 118.45,55.99 117.87,55.99 117.58,56.28 v1(117.39,56.28)
  BOTTOM w0.102: U52.P8 101.93,59.5 102.06,59.5 102.11,59.45 102.11,57.43 103.04,56.49 103.97,56.49 v1(104.18,56.28) ; v1(85.39,56.28) 85.18,56.49 84.25,56.49 83.31,57.43 83.31,59.45 83.26,59.5 83.13,59.5 U51.P8 ; v1(72.18,56.28) 71.97,56.49 71.04,56.49 70.11,57.43 70.11,59.45 70.05,59.5 69.93,59.5 U50.P8 ; U53.P8 115.14,59.5 115.26,59.5 115.32,59.45 115.32,57.43 116.25,56.49 117.18,56.49 v1(117.39,56.28) ; U45.AU39 121.4,109.1 v1(121.25,109.1)
M_A_A5: length 173.7
  TOP w0.102: v1(67.78,55.62) 67.57,55.41 67.57,54.59 67.4,54.42 R369.2 ; U31.P2 114.97,59.72 115.04,59.8 115.3,59.8 115.38,59.72 115.38,58.2 115.47,58.1 116.01,58.1 116.13,57.98 116.13,56.58 116.67,56.04 v1(116.79,56.04) ; v1(71.58,56.04) 70.92,56.7 70.92,57.88 70.69,58.1 70.41,58.1 70.17,58.34 70.17,59.42 70.27,59.52 70.27,59.77 70.12,59.91 70.01,59.91 69.76,59.65 U28.P2 ; U30.P2 101.76,59.65 101.99,59.89 102.13,59.89 102.22,59.79 102.22,59.66 102.17,59.61 102.17,58.34 102.41,58.1 102.77,58.1 102.92,57.96 102.92,56.65 103.53,56.04 v1(103.58,56.04) ; v1(84.78,56.04) 84.68,56.04 84.12,56.6 84.12,57.86 83.88,58.1 83.62,58.1 83.38,58.34 83.38,59.63 83.43,59.68 83.43,59.82 83.33,59.91 83.22,59.91 82.96,59.65 U29.P2
  IN1 w0.178: v1(67.78,55.62) 68.2,56.04 v1(71.58,56.04) 71.75,56.04 72.04,55.75 72.33,55.75 72.52,55.94 72.93,55.94 73.36,56.37 74.95,56.37 75.23,56.09 77.16,56.09 78.33,57.26 79.04,57.26 80.83,55.47 83.39,55.47 84.16,56.24 84.58,56.24 v1(84.78,56.04) 84.96,56.04 85.24,55.75 85.54,55.75 85.81,56.02 92.17,56.02 92.73,55.46 95.23,55.46 95.36,55.58 95.36,55.79 95.49,55.91 95.82,55.91 95.94,55.79 95.94,55.58 96.07,55.46 96.4,55.46 96.53,55.58 96.53,56.11 96.66,56.24 103.39,56.24 v1(103.58,56.04) 103.8,56.04 104.17,55.66 104.35,55.66 104.5,55.81 104.5,55.97 104.6,56.07 104.76,56.07 105.11,55.71 105.24,55.71 105.34,55.81 105.34,55.99 105.45,56.1 106.97,56.1 107.13,55.94 107.42,55.94 107.58,56.1 107.93,56.1 108.09,55.94 108.49,55.94 108.65,56.1 109,56.1 109.15,55.94 109.53,55.94 109.68,56.1 113.8,56.1 113.93,55.97 113.93,55.55 114.05,55.42 114.26,55.42 114.94,56.1 116.73,56.1 v1(116.79,56.04)
  IN1 w0.203: v1(131.63,58.63) 131.56,58.71 129.29,58.71 127.59,57.01 126.97,57.01 125.49,55.52 118.66,55.52 118.31,55.87 117.67,55.87 117.57,55.78 117.22,55.78 116.96,56.04 v1(116.79,56.04)
  IN3 w0.076: v1(122.75,110.38) 123.48,108.66 123.48,104.4 124.04,103.84 124.04,99.93
  IN3 w0.152: v1(131.63,58.63) 132.34,59.8 132.34,69.33 131.73,72.88 131.73,74.46 129.29,76.9 129.29,82.45 128.55,83.19 128.26,83.19 126.78,84.67 126.78,85.18 126.79,85.19 126.79,85.55 126.17,86.16 126.17,87.99 125.92,88.24 124.04,90.13 124.04,99.93
  BOTTOM w0.076: U45.AR36 122.92,110.56 v1(122.75,110.38)
  BOTTOM w0.102: U52.P2 106.12,58.88 106.12,58.41 105.83,58.13 105.67,58.13 105.4,57.86 105.4,56.57 104.7,55.86 103.76,55.86 v1(103.58,56.04) ; v1(116.79,56.04) 116.97,55.86 117.91,55.86 118.61,56.57 118.61,57.86 118.88,58.13 119.04,58.13 119.32,58.41 119.32,58.88 U53.P2 ; v1(71.58,56.04) 71.75,55.86 72.69,55.86 73.4,56.57 73.4,57.86 73.67,58.13 73.83,58.13 74.11,58.41 74.11,58.88 U50.P2 ; v1(84.78,56.04) 84.96,55.86 85.9,55.86 86.61,56.57 86.61,57.86 86.88,58.13 87.04,58.13 87.32,58.41 87.32,58.88 U51.P2
M_A_A6: length 173.1
  TOP w0.102: U28.R8 74.94,58.53 74.96,58.51 74.96,56.59 73.09,54.72 72.37,54.72 72.13,54.48 v1(72.13,54.25) 72.1,54.22 R373.2 ; v1(104.45,54.01) 104.45,54.21 105.04,54.79 105.09,54.79 105.83,55.53 106.69,55.53 106.96,55.8 106.96,58.13 U30.R8 ; U29.R8 87.81,58.53 88.22,58.12 88.22,57.72 87.97,57.46 87.97,56.54 86.22,54.79 85.53,54.79 85.39,54.65 v1(85.39,54.07) ; U31.R8 120.17,58.13 120.17,56.7 118.19,54.72 117.3,54.72 v1(116.84,54.26)
  IN1 w0.178: v1(72.13,54.25) 72.2,54.17 72.79,54.17 72.92,54.05 78.56,54.05 78.7,54.19 78.7,55.08 78.88,55.25 79.43,55.25 80.92,53.77 84.06,53.77 84.63,54.34 84.87,54.34 85.14,54.07 v1(85.39,54.07) 85.81,54.07 86.11,53.77 87.25,53.77 87.79,54.31 97.6,54.31 97.72,54.19 97.72,54.05 97.85,53.92 98.18,53.92 98.31,54.05 98.31,54.19 98.43,54.31 98.76,54.31 98.89,54.19 98.89,54.06 99.02,53.93 100.47,53.93 100.59,54.06 100.59,54.19 100.72,54.31 102.24,54.31 102.55,54.01 v1(104.45,54.01) 104.53,54.09 109.31,54.09 110.18,54.95 110.47,54.95 110.63,54.8 110.8,54.8 110.96,54.95 111.11,54.95 111.24,54.82 111.24,54.4 111.36,54.28 114.78,54.28 115.45,54.95 116.16,54.95 116.34,54.77 116.34,54.52 116.01,54.19 116.01,54.01 116.21,53.81 116.39,53.81 v1(116.84,54.26)
  IN1 w0.203: v1(116.84,54.26) 117.62,53.48 125.24,53.48 125.97,54.21 126.67,54.21 129.79,57.34 v1(130.01,57.34)
  IN3 w0.076: 121.9,100.59 121.9,104.49 v1(121.25,105.14)
  IN3 w0.152: 121.9,100.59 121.9,89.24 122.94,88.2 122.94,85.77 123.21,85.51 123.21,84.75 125.42,82.55 125.42,77.18 126.26,76.34 126.69,76.34 128.13,74.9 128.13,74.05 128.74,73.44 128.74,70.7 128.91,70.52 128.91,69.12 129.63,68.41 129.63,57.72 v1(130.01,57.34)
  BOTTOM w0.076: v1(121.25,105.14) 120.52,105.88 120.52,107.24 120.53,107.26 120.53,108.45 U45.AV40
  BOTTOM w0.102: U50.R8 69.5,58.53 69.34,58.36 69.34,57.67 69.55,57.45 69.55,55.97 70.8,54.72 71.59,54.72 72.06,54.25 v1(72.13,54.25) ; U52.R8 101.39,58.16 101.39,56.54 103.92,54.01 v1(104.45,54.01) ; v1(85.39,54.07) 85.39,54.28 85.06,54.6 84.43,54.6 82.6,56.44 82.6,58.37 82.75,58.53 U51.R8 ; v1(116.84,54.26) 116.42,54.26 116.37,54.31 116.37,55.03 116.29,55.11 115.58,55.11 115.5,55.18 115.5,56.42 115.43,56.5 114.66,56.5 114.59,56.58 114.59,58.45 114.66,58.53 U53.R8
M_A_A7: length 173.4
  TOP w0.102: U30.R2 101.76,58.3 102.16,57.9 102.16,57.58 101.99,57.41 101.99,56.14 102.09,56.04 102.27,56.04 102.42,56.19 102.52,56.19 102.65,56.07 102.65,55.97 102.42,55.74 102.42,55.64 102.57,55.48 102.65,55.48 102.9,55.74 102.98,55.74 103.13,55.58 103.13,55.51 102.89,55.27 102.89,55.17 102.94,55.11 v1(103.53,55.11) ; R371.2 69.56,54.22 70.06,54.72 70.98,54.72 v1(71.45,55.19) 71.45,55.26 70.15,56.56 70.15,57.98 70.05,58.08 69.64,58.08 69.53,57.97 69.38,57.97 69.31,58.04 69.31,58.92 69.4,59.01 69.65,59.01 69.76,58.91 U28.R2 ; U31.R2 114.97,58.2 115.37,57.8 115.37,57.48 115.3,57.41 115.3,55.76 115.4,55.66 115.54,55.66 115.82,55.94 115.95,55.94 116.04,55.85 116.04,55.73 115.86,55.55 115.86,55.42 115.95,55.33 116.08,55.33 116.25,55.51 116.38,55.51 116.47,55.42 116.47,55.3 116.31,55.14 116.31,55 116.37,54.93 v1(116.79,54.93) ; U29.R2 82.86,58.43 82.86,58.18 82.97,58.07 83.22,58.07 83.36,57.93 83.36,56.56 83.54,56.38 83.54,56.24 83.24,55.94 83.24,55.84 83.39,55.69 83.5,55.69 83.81,55.99 83.89,55.99 84.06,55.83 84.06,55.75 83.86,55.55 83.86,55.42 83.93,55.35 84.69,55.35 84.76,55.29 v1(84.76,55.01)
  IN1 w0.178: v1(71.45,55.19) 71.92,54.72 72.28,54.72 72.45,54.56 73.02,54.56 73.15,54.43 77.48,54.43 77.63,54.58 77.63,55.1 78.16,55.64 79.59,55.64 81.07,54.15 83.9,54.15 v1(84.76,55.01) 85.2,54.57 85.96,54.57 86.38,54.15 87.09,54.15 87.79,54.85 87.79,55.13 87.92,55.26 91.85,55.26 92.42,54.69 97.33,54.69 98.11,55.47 102.84,55.47 103.2,55.11 v1(103.53,55.11) 103.53,54.7 103.77,54.47 109.15,54.47 110.02,55.33 111.49,55.33 111.62,55.2 111.62,54.78 111.74,54.66 112.3,54.66 112.49,54.85 112.73,54.85 112.92,54.66 114.58,54.66 115.25,55.33 116.33,55.33 116.45,55.21 116.51,55.21 v1(116.79,54.93)
  IN1 w0.203: v1(116.79,54.93) 116.94,54.93 117.32,54.55 118.63,54.55 119.3,53.89 124.03,53.89 124.85,54.71 126.59,54.71 129.67,57.79 v1(130.79,57.79)
  IN3 w0.076: v1(121.25,107.8) 122.44,106.61 122.44,103.82 122.97,103.29 122.97,100.39 122.61,100.03 122.61,99.86
  IN3 w0.152: 122.61,99.86 122.61,89.54 123.66,88.49 123.66,86.07 123.92,85.8 123.92,85.05 126.05,82.91 126.53,82.91 127.11,82.33 127.11,76.92 129.6,74.44 129.6,71.06 129.78,70.88 129.78,69.48 130.49,68.77 130.49,58.66 130.72,58.43 130.72,57.87 v1(130.79,57.79)
  BOTTOM w0.102: v1(103.53,55.11) 104,54.64 104.8,54.64 106.14,55.99 106.14,57.79 106.56,58.21 U52.R2 ; U53.R2 119.77,58.21 119.35,57.79 119.35,56.01 117.8,54.47 v1(117.53,54.47) 117.26,54.47 v1(116.79,54.93) ; v1(84.76,55.01) 84.96,55.01 85.35,54.62 86.03,54.62 87.32,55.91 87.32,58.12 87.73,58.53 U51.R2 ; U50.R2 74.56,58.21 74.11,57.77 74.11,56.04 72.79,54.72 71.92,54.72 v1(71.45,55.19) ; U45.AW39 121.55,108.1 v1(121.25,107.8)
M_A_A8: length 155.9
  TOP w0.102: U29.T8 87.76,56.62 86.14,55 85.56,55 v1(85.39,55.18) ; v1(117.39,55.18) 117.57,55 118.16,55 119.77,56.61 U31.T8 ; U30.T8 106.56,56.61 104.95,55 104.48,55 104.3,55.18 v1(104.18,55.18) ; U28.T8 74.56,56.61 72.95,55 72.36,55 v1(72.18,55.18) 71.62,54.62 71.21,54.62 70.81,54.22 R372.2
  IN1 w0.178: v1(72.18,55.18) 72.38,55.18 72.58,54.97 72.96,54.97 73.69,55.71 77.31,55.71 78.31,56.7 79.06,56.7 81.23,54.53 83.63,54.53 84.58,55.47 84.93,55.47 85.23,55.18 v1(85.39,55.18) 85.59,54.97 86.32,54.97 86.45,55.1 86.45,55.51 86.57,55.64 92.01,55.64 92.57,55.07 96.78,55.07 96.91,55.2 96.91,55.73 97.04,55.85 103.14,55.85 103.4,55.6 103.7,55.6 104.12,55.18 v1(104.18,55.18) 104.51,54.85 105.57,54.85 105.67,54.95 105.67,55.58 105.8,55.71 105.97,55.71 106.13,55.56 106.38,55.56 106.54,55.71 106.81,55.71 106.97,55.56 109.69,55.56 109.84,55.71 113.39,55.71 113.55,55.56 113.55,55.23 113.74,55.04 114.42,55.04 115.09,55.71 116.49,55.71 116.6,55.6 116.84,55.6 117.26,55.18 v1(117.39,55.18)
  IN1 w0.203: v1(117.39,55.18) 117.61,54.96 118.8,54.96 119.47,54.3 123.87,54.3 124.68,55.11 126.42,55.11 129.56,58.25 v1(130.29,58.25)
  IN3 w0.076: 122.26,99.98 122.74,100.47 122.74,103.21 122.23,103.72 122.23,106.13 v1(121.27,107.1)
  IN3 w0.152: 122.26,99.98 122.26,89.39 123.3,88.35 123.3,85.92 123.57,85.65 123.57,84.9 125.77,82.69 125.77,77.33 126.41,76.69 126.84,76.69 129.17,74.37 129.17,70.88 129.35,70.7 129.35,69.3 130.06,68.59 130.06,58.48 v1(130.29,58.25)
  BOTTOM w0.102: U53.T8 114.97,57.27 115.71,56.53 115.71,55.99 116.1,55.6 117.25,55.6 117.39,55.46 v1(117.39,55.18) ; v1(72.18,55.18) 72.18,55.41 71.99,55.6 71.43,55.6 70.81,56.22 70.21,56.22 69.81,56.63 69.81,57.68 U50.T8 ; U45.AY39 121.62,107.45 v1(121.27,107.1) ; v1(85.39,55.18) 85.39,55.41 85.2,55.6 84.04,55.6 82.96,56.68 U51.T8 ; U52.T8 101.76,56.73 102.14,56.35 102.68,56.35 103.42,55.6 104.04,55.6 104.18,55.46 v1(104.18,55.18)
M_A_A9: length 158
  TOP w0.102: v1(103.58,57.14) 103.7,57.02 103.7,56.76 103.62,56.68 103.3,56.68 103.14,56.84 103.14,58.32 103.03,58.43 102.66,58.43 U30.R3 ; v1(71.58,57.14) 71.7,57.02 71.7,56.81 71.58,56.7 71.31,56.7 71.13,56.87 71.13,58.42 71.03,58.53 U28.R3 ; v1(84.78,57.14) 84.91,57.02 84.91,56.81 84.79,56.7 84.51,56.7 84.34,56.87 84.34,58.42 84.23,58.53 U29.R3 ; v1(116.79,57.14) 116.91,57.02 116.91,56.81 116.8,56.7 116.52,56.7 116.35,56.87 116.35,58.42 116.24,58.53 U31.R3
  IN3 w0.076: 121.66,101.16 121.66,104.12 v1(121.25,104.53)
  IN3 w0.14: v1(116.79,57.14) 116.52,57.42 110.09,57.42 109.97,57.29 109.97,56.98 109.84,56.85 109.53,56.85 109.41,56.98 109.41,57.29 109.28,57.42 108.97,57.42 108.85,57.29 108.85,56.98 108.72,56.85 107.43,56.85 107.3,56.98 107.3,57.29 107.17,57.42 105.52,57.42 105.22,57.11 104.61,57.11 104.34,56.84 104.06,56.84 103.76,57.14 v1(103.58,57.14) 103.31,57.42 98.73,57.42 98.06,58.08 90.77,58.08 89.94,57.25 89.3,57.25 88.71,57.85 87.11,57.85 86.4,57.14 85.95,57.14 85.56,56.75 85.33,56.75 84.94,57.14 v1(84.78,57.14) 83.88,56.24 74.48,56.24 74.35,56.36 74.35,56.65 74.23,56.78 73.92,56.78 73.8,56.65 73.8,56.36 73.67,56.24 73.36,56.24 73.24,56.36 73.24,56.95 73.11,57.07 72.59,57.07 72.36,56.84 72.08,56.84 71.78,57.14 v1(71.58,57.14) 69.92,57.14 69.3,57.77 68.33,57.77 67.83,57.26 66.2,57.26 v1(66.1,57.16)
  IN3 w0.152: v1(116.79,57.14) 116.97,57.14 117.27,56.84 117.57,56.84 117.8,57.07 118.26,57.07 119.05,56.28 124.21,56.28 125.08,55.41 127.53,55.41 129.19,57.07 129.19,63.89 128.48,64.6 128.48,70.34 128.3,70.52 128.3,73.24 127.69,73.85 127.69,74.83 126.55,75.98 126.11,75.98 125.06,77.03 125.06,82.4 122.08,85.38 122.08,88.3 121.55,88.83 121.55,99.25 121.66,99.36 121.66,101.16
  BOTTOM w0.076: v1(121.25,104.53) 120.35,105.43 120.35,107.31 120.37,107.32 120.37,108.92 120.63,109.19 120.63,109.25 U45.AU40
  BOTTOM w0.102: v1(71.58,57.14) 71.8,56.92 72.66,56.92 73.19,57.45 73.19,57.97 U50.R3 ; U52.R3 105.2,57.97 105.2,57.45 104.67,56.92 103.8,56.92 v1(103.58,57.14) ; v1(84.78,57.14) 85.01,56.92 85.87,56.92 86.4,57.45 86.4,57.97 U51.R3 ; U53.R3 118.41,57.97 118.41,57.45 117.88,56.92 117.01,56.92 v1(116.79,57.14) ; v1(66.1,57.16) 65.71,56.77 62.7,56.77
  BOTTOM w0.241: R750.2 62.55,56.77 62.7,56.77
M_A_A10: length 155.2
  TOP w0.102: U28.L7 71.61,61.73 v1(71.36,61.48) ; U30.L7 105.76,61.96 105.66,62.06 104.15,62.06 104.05,61.96 v1(104.05,61.49) ; v1(117.05,61.46) 117.92,61.46 117.99,61.54 117.99,61.91 118.07,61.99 118.79,61.99 118.97,61.8 U31.L7 ; U29.L7 87.08,61.73 87.18,61.63 87.18,61.39 87.08,61.29 86.65,61.29 86.57,61.37 86.57,61.45 86.47,61.55 v1(85.38,61.55)
  IN1 w0.178: v1(117.05,61.46) 115.95,61.46 115.02,60.53 115.02,60.19 114.87,60.03 112.73,60.03 112.61,60.16 112.61,60.82 112.23,61.2 109.46,61.2 108.87,60.61 108.37,60.61 107.78,61.2 105.08,61.2 104.79,61.49 v1(104.05,61.49) 103.93,61.49 103.59,61.15 101.63,61.15 100.54,60.05 97.88,60.05 97.27,60.66 92.34,60.66 91.73,60.05 90.38,60.05 89.44,60.99 86.78,60.99 86.41,61.36 85.95,61.36 85.79,61.52 85.41,61.52 v1(85.38,61.55) 85.05,61.55 84.95,61.45 84.57,61.45 82.91,59.8 81.75,59.8 81.67,59.72 80.91,59.72 80.12,60.51 78.32,60.51 77.4,61.42 76.23,61.42 75.9,61.75 73.59,61.75 73.26,61.42 71.41,61.42 v1(71.36,61.48) 69.05,61.48 68.92,61.35 67.95,61.35 67.6,61.69 67.24,61.69 67.05,61.5 66.07,61.5 v1(65.72,61.15)
  IN1 w0.203: v1(117.05,61.46) 117.63,61.46 117.99,61.11 118.44,61.11 118.83,60.72 119.69,60.72 119.95,60.97 122.33,60.97 122.83,61.47 124.35,61.47 124.53,61.66 126.27,61.66 127.49,62.87 v1(133.87,62.87)
  IN3 w0.076: v1(123.7,110.88) 124.12,110.47 124.12,109.84 123.94,109.66 123.94,105.62 124.67,104.89 124.67,100.11 125.1,99.68 125.1,99.55
  IN3 w0.152: 125.1,99.55 125.1,90.57 127.24,88.43 127.24,86.82 128.61,85.45 128.61,84.74 130.06,83.3 130.48,83.3 131.28,82.5 131.28,76.77 132.06,75.98 132.83,75.98 134.04,74.76 134.04,72.09 133.64,71.69 133.64,63.1 v1(133.87,62.87)
  BOTTOM w0.102: v1(117.05,61.46) 117.05,62.16 116.9,62.32 116.42,62.32 116.26,62.16 116.26,61.8 116.19,61.73 U53.L7 ; U51.L7 84.79,61.73 84.9,61.63 84.9,61.22 85.02,61.1 85.25,61.1 85.38,61.22 v1(85.38,61.55) ; 64.47,60.46 65.03,60.46 v1(65.72,61.15) ; U45.AP35 124.03,111.21 v1(123.7,110.88) ; U50.L7 70.87,61.73 70.98,61.83 70.98,62.44 71.08,62.54 71.26,62.54 71.36,62.44 v1(71.36,61.48) ; U52.L7 102.56,61.55 102.64,61.48 103.36,61.48 103.46,61.38 103.46,61.1 103.56,60.99 103.95,60.99 104.05,61.1 v1(104.05,61.49)
  BOTTOM w0.241: v1(60.84,60.33) 61.58,61.07 R742.2 62.62,60.37 63.03,60.37 63.12,60.46 64.47,60.46
M_A_A11: length 145.5
  TOP w0.102: R360.2 65.26,57.39 65.64,57.77 66.25,57.77 66.79,57.24 67.12,57.24 v1(67.65,57.77) ; U31.R7 118.97,58.2 118.46,57.69 118.46,57.53 118.15,57.22 117.56,57.22 v1(117.39,57.39) ; v1(72.18,57.39) 72.34,57.22 72.94,57.22 73.25,57.53 73.25,57.69 73.76,58.2 U28.R7 ; v1(104.18,57.39) 104.35,57.22 104.95,57.22 105.25,57.53 105.25,57.69 105.76,58.2 U30.R7 ; v1(85.39,57.39) 85.55,57.22 86.15,57.22 86.46,57.53 86.46,57.69 86.96,58.2 U29.R7
  IN1 w0.178: v1(117.39,57.39) 117.21,57.39 116.88,57.72 116.46,57.72 115.6,56.86 112.25,56.86 110.92,58.19 110.92,58.34 110.5,58.76 110.25,58.76 108.85,57.35 108.85,57.11 108.6,56.86 107.52,56.86 107.22,57.16 104.6,57.16 104.38,57.39 v1(104.18,57.39) 104,57.39 103.76,57.63 103.33,57.63 102.7,57.01 94.98,57.01 94.62,56.65 94.62,56.34 94.5,56.22 93.05,56.22 91.9,57.36 91.37,57.36 90.79,56.78 86.56,56.78 86.18,57.16 85.78,57.16 85.55,57.39 v1(85.39,57.39) 85.21,57.39 84.85,57.74 84.54,57.74 83.08,56.29 81.09,56.29 79.36,58.02 78.01,58.02 76.84,56.85 75.55,56.85 75.27,57.13 72.6,57.13 72.35,57.39 v1(72.18,57.39) 71.96,57.39 71.76,57.59 69.43,57.59 69.25,57.77 v1(67.65,57.77)
  IN1 w0.203: v1(117.39,57.39) 117.56,57.39 117.79,57.16 118.3,57.16 119.12,56.33 124.25,56.33 125.99,58.07 126.4,58.07 126.73,58.4 v1(127.47,58.4)
  IN3 w0.076: 120.61,101.91 120.2,102.32 120.2,103.92 120.46,104.17 120.46,106.99 v1(119.65,107.8)
  IN3 w0.152: 120.61,101.91 120.61,100.06 120.05,99.5 120.05,84.85 122.01,82.89 122.01,81.87 121.52,81.39 121.52,80.87 122.36,80.04 122.76,80.04 123.02,79.79 123.02,76.37 125.43,73.95 125.43,73.39 126.42,72.4 126.42,69.96 126.75,69.63 126.75,63.89 127.47,63.18 v1(127.47,58.4)
  BOTTOM w0.102: U52.R7 102.83,58.53 102.92,58.44 102.92,57.88 103.18,57.62 104.02,57.62 104.18,57.46 v1(104.18,57.39) ; v1(119.65,107.8) 119.95,108.1 U45.AW41 ; v1(117.39,57.39) 117.39,57.46 117.26,57.59 116.32,57.59 116.14,57.77 116.14,58.35 115.95,58.53 U53.R7 ; U51.R7 84.03,58.53 84.12,58.44 84.12,57.87 84.36,57.62 85.22,57.62 85.39,57.46 v1(85.39,57.39) ; U50.R7 70.85,58.53 70.91,58.47 70.91,57.83 71.12,57.62 71.94,57.62 v1(72.18,57.39)
M_A_A12: length 152.8
  TOP w0.102: v1(84.78,59.35) 84.96,59.18 86.02,59.18 86.42,59.58 86.42,60 86.54,60.13 U29.N7 ; v1(67.04,59.1) 66.52,59.62 65.44,59.62 64.98,59.17 64.47,59.17 ; v1(116.74,59.23) 116.92,59.05 117.89,59.05 118.53,59.69 118.53,59.92 118.74,60.13 U31.N7 ; v1(103.36,59.27) 103.52,59.11 104.43,59.11 104.56,59.24 104.89,59.24 105.76,60.12 U30.N7 ; v1(71.58,59.35) 71.8,59.13 72.34,59.13 72.61,59.39 73,59.39 73.29,59.69 73.29,60.03 73.39,60.13 U28.N7
  TOP w0.241: 64.47,59.17 63.34,59.17 R354.2
  IN3 w0.076: v1(119.65,109.1) 120.63,108.12 120.63,104.08 120.4,103.85 120.4,102.55 120.86,102.09
  IN3 w0.14: v1(116.74,59.23) 116.18,59.23 115.43,58.48 112.45,58.48 110.91,60.02 109.79,60.02 108.38,58.61 106.41,58.61 105.85,59.17 104.61,59.17 104.48,59.04 103.59,59.04 v1(103.36,59.27) 103.21,59.42 101.25,59.42 100.94,59.11 90.07,59.11 89.87,58.91 87.46,58.91 87.33,59.04 87.33,59.56 87.21,59.69 86.9,59.69 86.78,59.56 86.78,59 86.65,58.87 86.53,58.87 86.09,59.32 85.83,59.32 85.66,59.15 85.21,59.15 85.01,59.35 v1(84.78,59.35) 84.73,59.35 83.46,58.09 81.66,58.09 81.34,57.77 81.34,57.39 81.21,57.26 77.38,57.26 77.25,57.39 77.25,57.77 76.93,58.09 75.36,58.09 75.03,58.42 73.88,58.42 73.14,59.17 72.5,59.17 72.42,59.09 71.84,59.09 v1(71.58,59.35)
  IN3 w0.152: 120.86,102.09 120.86,99.91 120.43,99.48 120.43,86.17 120.99,85.61 120.99,84.42 122.96,82.45 122.96,80.35 123.37,79.93 123.37,76.51 125.79,74.1 125.79,73.67 126.86,72.6 126.86,70.14 127.19,69.81 127.19,64.07 127.9,63.35 127.9,57.62 127.65,57.36 126.58,57.36 126.39,57.17 125.65,57.17 124.55,58.28 119.08,58.28 118.3,59.06 117.71,59.06 117.64,58.99 116.98,58.99 v1(116.74,59.23)
  IN3 w0.178: v1(67.04,59.1) 67.36,59.1 68.26,60 69.86,60 70.51,59.35 v1(71.58,59.35)
  BOTTOM w0.102: v1(71.58,59.35) 70.91,60.02 70.91,60.43 70.76,60.58 70.25,60.58 70.16,60.49 70.16,60.21 70.25,60.13 U50.N7 ; U45.AU41 119.83,109.1 v1(119.65,109.1) ; U52.N7 102.26,60.13 102.17,60.21 102.17,60.49 102.26,60.58 102.76,60.58 102.91,60.43 102.91,60.02 103.23,59.7 103.23,59.4 v1(103.36,59.27) ; U53.N7 115.82,60.18 115.99,60.18 116.06,60.11 116.06,59.85 116.32,59.6 116.32,59.06 116.67,58.71 116.9,58.71 116.98,58.78 116.98,58.99 v1(116.74,59.23) ; U51.N7 83.43,60.13 83.35,60.21 83.35,60.46 83.46,60.58 83.89,60.58 84.12,60.35 84.12,60.02 v1(84.78,59.35)
M_A_A13: length 162
  TOP w0.102: U28.T3 70.56,56.47 71.4,55.63 72.56,55.63 v1(72.77,55.42) ; v1(117.98,55.42) 117.77,55.63 116.61,55.63 115.77,56.46 115.77,57.15 115.77,57.15 U31.T3 ; v1(104.77,55.42) 104.57,55.63 103.4,55.63 102.57,56.46 102.57,57.15 102.56,57.15 U30.T3 ; v1(85.98,55.42) 85.77,55.63 84.61,55.63 83.76,56.47 U29.T3 ; v1(69.05,55.36) 68.41,54.72 R370.2
  IN3 w0.076: 124.39,99.53 124.27,99.65 124.27,104.02 123.7,104.58 v1(123.7,110.23)
  IN3 w0.14: v1(69.05,55.36) 69.43,55.74 71.08,55.74 71.2,55.61 72.47,55.61 72.67,55.42 v1(72.77,55.42) 72.9,55.55 78.52,55.55 78.65,55.42 78.65,55.03 78.77,54.9 81.19,54.9 81.31,55.03 81.31,55.42 81.44,55.55 83.6,55.55 83.73,55.42 83.73,55.03 83.85,54.9 84.16,54.9 84.29,55.03 84.29,55.42 84.41,55.55 85.03,55.55 85.16,55.68 85.52,55.68 85.78,55.42 v1(85.98,55.42) 86.42,55.42 87.18,56.18 89.84,56.18 91.05,57.4 97.78,57.4 98.45,56.73 102.19,56.73 103.31,55.61 104.48,55.61 104.67,55.42 v1(104.77,55.42) 104.88,55.42 105.63,56.17 110.55,56.17 110.68,56.3 110.68,56.6 110.8,56.73 111.11,56.73 111.24,56.6 111.24,56.42 111.36,56.3 111.67,56.3 111.79,56.42 111.79,56.6 111.92,56.73 116.09,56.73 116.21,56.6 116.21,55.74 116.34,55.61 117.79,55.61 v1(117.98,55.42)
  IN3 w0.152: v1(117.98,55.42) 123.85,55.42 124.72,54.54 127.9,54.54 129.7,56.35 130.99,56.35 132.14,57.49 132.14,58.38 132.77,59.01 132.77,72.4 132.6,72.58 132.6,74.86 132.29,75.17 131.61,75.17 130.56,76.21 130.56,82.21 130.19,82.58 129.67,82.58 129.39,82.86 128.7,83.55 128.4,83.55 127.14,84.81 127.14,85.69 126.53,86.31 126.53,88.14 126.27,88.39 124.39,90.27 124.39,99.53
  BOTTOM w0.102: v1(123.7,110.23) 124.03,110.56 U45.AR35 ; U50.T3 73.87,57.61 73.87,57.18 73.69,57.01 73.69,56.44 73.87,56.27 73.87,56.11 73.71,55.95 73.54,55.95 73.41,56.08 73.27,56.08 73.15,55.96 73.15,55.82 73.31,55.66 73.31,55.53 73.07,55.29 72.9,55.29 v1(72.77,55.42) ; U53.T3 119.13,57.56 119.13,57.03 118.96,56.85 118.96,56.39 119.08,56.27 119.08,56.11 118.92,55.95 118.75,55.95 118.62,56.08 118.48,56.08 118.36,55.96 118.36,55.82 118.52,55.66 118.52,55.53 118.28,55.29 118.11,55.29 v1(117.98,55.42) ; v1(85.98,55.42) 86.11,55.29 86.28,55.29 86.52,55.53 86.52,55.66 86.36,55.82 86.36,55.96 86.47,56.08 86.62,56.08 86.75,55.95 86.91,55.95 87.08,56.11 87.08,56.27 86.9,56.44 86.9,56.88 87.08,57.06 87.08,57.61 U51.T3 ; U52.T3 105.93,57.56 105.93,57.03 105.75,56.85 105.75,56.39 105.87,56.27 105.87,56.11 105.71,55.95 105.54,55.95 105.41,56.08 105.27,56.08 105.15,55.96 105.15,55.82 105.31,55.66 105.31,55.53 105.07,55.29 104.9,55.29 v1(104.77,55.42)
M_A_A14: length 147.7
  TOP w0.102: v1(104.77,56.52) 104.54,56.76 104.54,56.88 104.64,56.98 105.09,56.98 105.35,56.71 105.63,56.71 105.93,57 105.93,57.56 U30.T7 ; U31.T7 119.13,57.56 119.13,57 118.84,56.71 118.56,56.71 118.3,56.98 117.84,56.98 117.75,56.88 117.75,56.76 v1(117.98,56.52) ; U28.T7 73.92,57.56 73.92,57 73.63,56.71 73.35,56.71 73.08,56.98 72.63,56.98 72.53,56.88 72.53,56.76 v1(72.77,56.52) ; v1(66.76,55.61) 66.38,55.23 R368.2 ; v1(85.98,56.52) 85.74,56.76 85.74,56.88 85.84,56.98 86.29,56.98 86.56,56.71 86.83,56.71 87.13,57 87.13,57.56 U29.T7
  IN1 w0.178: v1(66.76,55.61) 67.78,56.63 71.71,56.63 71.84,56.75 72.54,56.75 v1(72.77,56.52) 73,56.75 75.11,56.75 75.39,56.47 77,56.47 78.17,57.64 79.2,57.64 80.96,55.88 83.23,55.88 84.21,56.85 84.44,56.85 84.68,56.62 85.03,56.62 85.19,56.77 85.57,56.77 85.81,56.52 v1(85.98,56.52) 86.28,56.52 86.4,56.4 92.33,56.4 92.89,55.84 94.88,55.84 95,55.96 95,56.49 95.13,56.62 95.46,56.62 95.59,56.49 95.59,56.42 95.72,56.3 96.15,56.3 96.27,56.42 96.27,56.49 96.4,56.62 103.73,56.62 104.05,56.93 104.28,56.93 104.69,56.52 v1(104.77,56.52) 105.03,56.78 107.06,56.78 107.37,56.48 108.75,56.48 109.23,56.95 109.23,57.2 110.31,58.27 110.44,58.27 110.54,58.18 110.54,58.03 112.1,56.48 116.52,56.48 116.66,56.62 117.04,56.62 117.19,56.77 117.54,56.77 117.79,56.52 v1(117.98,56.52)
  IN1 w0.203: v1(126.83,57.85) 126.83,57.44 125.32,55.93 118.89,55.93 118.3,56.52 v1(117.98,56.52)
  IN3 w0.076: v1(119.65,105.8) 120.07,105.37 120.07,104.35 119.8,104.07 119.8,102.09 120.1,101.79 120.1,101.71
  IN3 w0.152: v1(126.83,57.85) 126.83,58.53 125.15,60.21 125.15,72.02 123.02,74.16 123.02,74.3 121.52,75.79 121.52,79.87 120.81,80.58 120.81,83.08 119.34,84.55 119.34,99.6 120.1,100.36 120.1,101.71
  BOTTOM w0.076: U45.AV42 118.96,108.45 118.96,106.49 v1(119.65,105.8)
  BOTTOM w0.102: v1(117.98,56.52) 117.79,56.72 116.45,56.72 115.77,57.4 U53.T7 ; U51.T7 83.76,57.4 84.44,56.72 85.78,56.72 v1(85.98,56.52) ; v1(72.77,56.52) 72.58,56.72 71.24,56.72 70.56,57.4 U50.T7 ; U52.T7 102.56,57.4 103.24,56.72 104.58,56.72 v1(104.77,56.52)
M_A_A15: length 145.7
  TOP w0.102: v1(72.77,59.84) 72.73,59.88 72.73,60.23 73.24,60.74 73.24,61.2 73.37,61.33 73.98,61.33 74.1,61.21 74.1,61.05 73.97,60.93 U28.M7 ; v1(104.77,59.71) 104.77,60.17 105.29,60.69 105.29,61.3 105.37,61.38 105.9,61.38 106,61.27 106,61.03 105.9,60.93 U30.M7 ; v1(66.35,60.79) 66.3,60.74 65.52,60.74 65.19,61.07 R346.2 ; v1(85.98,59.84) 85.72,59.84 85.57,59.99 85.57,60.25 85.82,60.5 86.03,60.5 86.25,60.28 86.36,60.28 86.52,60.45 86.52,60.56 86.41,60.67 86.41,60.94 86.48,61.02 86.87,61.02 U29.M7 ; U31.M7 119.19,60.93 119.26,61 119.26,61.25 119.19,61.32 118.6,61.32 118.5,61.22 118.5,60.99 117.98,60.48 v1(117.98,59.74)
  IN3 w0.076: v1(119.65,105.14) 119.24,104.73 119.24,104.3 119.59,103.94 119.59,101.84 119.72,101.71
  IN3 w0.14: v1(117.98,59.74) 117.84,59.88 117.11,59.88 116.9,59.67 116.02,59.67 115.7,59.35 112.06,59.35 111.06,60.36 109.65,60.36 108.24,58.95 106.55,58.95 106.17,59.33 106.17,60.16 106.03,60.3 105.43,60.3 104.85,59.71 v1(104.77,59.71) 104.44,59.71 104.21,59.94 103.85,59.94 103.71,59.8 101.15,59.8 100.81,59.47 95.92,59.47 95.21,60.18 92.46,60.18 92.12,59.84 89.68,59.84 89.14,59.29 87.82,59.29 87.69,59.42 87.69,59.88 87.54,60.03 86.45,60.03 86.25,59.84 v1(85.98,59.84) 85.85,59.84 85.63,60.05 85.12,60.05 84.98,59.92 84.58,59.92 83.09,58.43 81.49,58.43 80.98,57.92 80.98,57.73 80.86,57.61 77.73,57.61 77.61,57.73 77.61,57.92 77.1,58.43 75.5,58.43 75.17,58.76 74.13,58.76 73.05,59.84 v1(72.77,59.84) 72.64,59.97 71.95,59.97 71.81,59.83 70.66,59.83 69.54,60.94 67.71,60.94 67.57,60.79 v1(66.35,60.79)
  IN3 w0.152: v1(117.98,59.74) 118.51,59.74 119.52,58.73 122.72,58.73 124.72,60.73 124.72,71.69 122.66,73.75 122.66,74.15 121.11,75.7 121.11,79.66 120.75,80.02 120.46,80.02 119.69,80.78 119.69,83.69 118.98,84.4 118.98,99.65 119.85,100.52 119.85,101.58 119.72,101.71
  BOTTOM w0.076: v1(119.65,105.14) 118.79,106 118.79,108.81 119.2,109.22 U45.AU42
  BOTTOM w0.102: v1(85.98,59.84) 85.79,60.03 85.12,60.03 85.05,59.95 85.05,59.85 84.97,59.78 84.69,59.78 84.34,60.13 84.34,60.43 83.84,60.93 U51.M7 ; U52.M7 102.77,60.93 103.12,60.58 103.12,60.11 103.45,59.78 103.71,59.78 103.86,59.93 104.2,59.93 104.41,59.71 v1(104.77,59.71) ; v1(72.77,59.84) 72.64,59.97 72.01,59.97 71.81,59.78 71.44,59.78 71.11,60.11 71.11,60.6 70.79,60.93 U50.M7 ; v1(117.98,59.74) 117.86,59.86 117.09,59.86 116.94,59.72 116.5,59.72 116.26,59.95 116.26,60.43 U53.M7
M_A_BS#0: length 147.8
  TOP w0.102: U28.M2 69.71,60.98 69.71,61.3 69.79,61.39 70.59,61.39 71.1,60.87 71.91,60.87 v1(72.18,60.6) ; U30.M2 101.66,61.03 101.66,61.25 101.76,61.35 103.31,61.35 104.12,60.55 v1(104.16,60.55) ; v1(117.12,60.54) 117.12,60.78 117.04,60.85 116.71,60.85 116.19,61.38 114.92,61.38 114.82,61.27 114.82,61.08 U31.M2 ; U29.M2 82.96,61.3 83.04,61.38 83.17,61.38 83.3,61.5 83.47,61.5 83.65,61.32 83.83,61.32 84.29,60.87 85.17,60.87 v1(85.39,60.65)
  IN3 w0.14: v1(117.12,60.54) 117.09,60.56 116.43,60.56 115.56,59.7 112.2,59.7 111.2,60.7 109.5,60.7 108.09,59.29 106.69,59.29 106.51,59.47 106.51,60.51 106.38,60.64 105.29,60.64 104.96,60.31 104.4,60.31 v1(104.16,60.55) 104.06,60.55 103.91,60.7 103.35,60.7 102.9,60.24 101.1,60.24 100.69,59.83 98.36,59.83 97.57,60.61 92.41,60.61 91.98,60.18 89.98,60.18 89.2,60.95 86.83,60.95 86.3,60.43 85.8,60.43 85.57,60.65 v1(85.39,60.65) 85.28,60.76 85.09,60.76 84.96,60.88 84.96,60.88 84.94,60.91 84.53,60.91 84.26,60.64 84.26,60.08 83.55,59.37 81.64,59.37 81.05,58.77 75.65,58.77 75.31,59.1 74.27,59.1 72.99,60.39 72.39,60.39 v1(72.18,60.6) 72.1,60.68 70.32,60.68 69.71,61.3 67.47,61.3 v1(67.42,61.25)
  IN3 w0.152: v1(117.12,60.54) 117.42,60.23 118.91,60.23 119.97,59.17 122.51,59.17 124.28,60.94 124.28,71.49 121.93,73.85 121.93,74.38 121.68,74.63 121.49,74.63 120.16,75.96 120.16,79.72 119.25,80.63 119.25,83.64 118.37,84.51 118.37,86.65 118.32,86.7 118.32,97.67 118.63,97.98 118.63,99.81 119.41,100.59 v1(119.41,100.9)
  BOTTOM w0.076: 123.4,106.21 123.4,106.82 123.5,106.91 123.5,107.31 123.52,107.32 123.52,108.68 123.68,108.85 123.68,108.87 123.85,109.04 123.87,109.04 123.93,109.09 U45.AU35
  BOTTOM w0.102: U53.M2 119.42,61.28 118.84,61.28 117.93,60.36 117.3,60.36 v1(117.12,60.54) ; v1(67.42,61.25) 66.05,59.88 65.31,59.88 65.24,59.8 R744.2 ; U51.M2 87.51,60.93 87.44,61 87.44,61.27 87.36,61.35 86.83,61.35 86.57,61.1 86.57,60.9 86.17,60.5 85.53,60.5 v1(85.39,60.65) ; v1(104.16,60.55) 104.39,60.32 104.91,60.32 105.43,60.84 105.43,61.12 105.64,61.33 106.16,61.33 U52.M2 ; U50.M2 74.24,60.93 73.8,61.38 73.54,61.38 73.24,61.07 73.24,60.69 73,60.45 72.32,60.45 v1(72.18,60.6)
  BOTTOM w0.241: v1(119.41,100.9) 120.3,100.9 v3(123.05,103.64) 123.4,104 123.4,106.21
M_A_BS#1: length 167.8
  TOP w0.102: U30.N8 106.22,59.79 105.73,59.79 105.2,59.26 105.2,58.47 104.82,58.08 103.72,58.08 v1(103.56,58.25) ; v1(84.76,58.25) 84.94,58.06 85.96,58.06 86.41,58.51 86.41,59.26 86.93,59.79 87.42,59.79 U29.N8 ; v1(71.55,58.25) 71.74,58.06 72.74,58.06 73.2,58.52 73.2,59.26 73.73,59.79 74.21,59.79 U28.N8 ; U31.N8 119.43,59.79 118.96,59.79 118.41,59.24 118.41,58.48 117.99,58.06 117.75,58.06 117.72,58.03 116.93,58.03 v1(116.76,58.2)
  IN1 w0.178: v1(66.58,58.2) 66.63,58.25 v1(71.55,58.25) 71.72,58.25 71.99,57.97 72.37,57.97 72.55,58.15 72.99,58.15 73.32,58.48 74.16,58.48 74.72,57.92 77.37,57.92 77.85,58.4 79.51,58.4 81.23,56.69 82.9,56.69 84.46,58.25 v1(84.76,58.25) 84.92,58.25 85.2,57.97 85.63,57.97 85.81,58.15 86.19,58.15 86.93,57.41 87.82,57.41 88.15,57.74 88.63,57.74 89.21,57.16 90.63,57.16 91.21,57.74 92.06,57.74 92.42,57.39 102.32,57.39 103.18,58.25 v1(103.56,58.25) 103.72,58.25 104,57.97 104.42,57.97 104.6,58.15 105.63,58.15 106.01,57.77 108.72,57.77 110.25,59.29 110.5,59.29 111.3,58.49 111.3,58.35 112.33,57.32 115.45,57.32 116.32,58.2 v1(116.76,58.2)
  IN1 w0.203: v1(116.76,58.2) 116.98,58.2 117.21,57.97 117.63,57.97 117.76,58.1 118.53,58.1 118.97,57.66 121.9,57.66 122.09,57.85 124.17,57.85 125.34,59.01 128.46,59.01 128.81,59.37 132.34,59.37 132.91,59.94 132.91,60.17 v1(133.44,60.69)
  IN3 w0.076: v1(124.1,104.79) 124.47,104.42 124.47,99.86 124.75,99.58
  IN3 w0.152: 124.75,99.58 124.75,90.42 126.88,88.29 126.88,86.46 127.5,85.84 127.5,84.96 127.78,84.68 128.55,83.91 128.85,83.91 129.64,83.11 129.81,82.94 130.33,82.94 130.92,82.35 130.92,76.51 131.81,75.63 132.67,75.63 133.03,75.27 133.03,72.76 133.21,72.58 133.21,60.92 v1(133.44,60.69)
  BOTTOM w0.076: v1(124.1,104.79) 123.72,105.17 123.72,106.74 123.67,106.79 123.67,107.24 123.68,107.26 123.68,108.45 U45.AV35
  BOTTOM w0.102: v1(71.55,58.25) 71.72,58.42 71.72,58.82 71.62,58.92 71.26,58.92 70.94,59.24 70.94,59.61 70.84,59.71 70.4,59.71 70.24,59.88 70.06,59.88 69.9,59.71 69.45,59.71 69.38,59.79 69.38,60 69.5,60.13 U50.N8 ; v1(116.76,58.2) 116.76,58.31 116.11,58.96 116.11,59.5 115.89,59.71 115.69,59.71 115.45,59.95 115.28,59.95 115,59.67 114.49,59.67 114.44,59.72 114.44,59.9 114.66,60.13 U53.N8 ; 62.63,57.96 65.17,57.96 65.23,58.02 66.4,58.02 v1(66.58,58.2) ; U52.N8 101.38,60.13 101.3,60.05 101.3,59.72 101.38,59.65 101.53,59.65 101.61,59.72 102.86,59.72 102.94,59.65 102.94,59.11 103.2,58.85 103.47,58.85 103.58,58.74 103.58,58.27 v1(103.56,58.25) ; v1(84.76,58.25) 84.93,58.42 84.93,58.82 84.83,58.92 84.47,58.92 84.14,59.24 84.14,59.64 84.07,59.71 82.62,59.71 82.52,59.82 82.52,60 82.65,60.13 U51.N8
  BOTTOM w0.241: 62.63,57.96 62.5,57.96 R746.2
