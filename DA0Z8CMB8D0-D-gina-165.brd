# Allegro board DA0Z8CMB8D0-D-gina-165.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
CARD-CS1R-111-H-N-11P
  round 1.651 hole 1.651 unplated: (-12.65,0) (12.65,0)
  rect 0.991x2.54 smd: 1(-7.57,8.245) 2(-5.07,8.245) 3(-2.57,8.245) 4(-0.07,8.245) 5(2.43,8.245) 6(4.93,8.245) 7(7.43,8.245) 8(9.055,8.245) 9(-10.07,8.245) 10(10.875,8.245) 11(-11.755,8.245)
  rect 2.057x2.489 smd: 12(-15.225,-8.35) 13(15.225,-8.35)
CC0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
CC0603
  rect 0.813x0.711 smd: 1(0.737,0) 2(-0.737,0)
CC0805
  rect 0.94x1.346 smd: 1(0.895,0) 2(-0.895,0)
CC1206
  rect 1.6x1.6 smd: 1(1.702,0) 2(-1.702,0)
CC1808
  rect 2.159x2.286 smd: 1(-2.349,0) 2(2.349,0)
CC1812
  rect 1.778x3.2 smd: 1(2.54,0) 2(-2.54,0)
CC3528
  rect 2.032x2.413 smd: 1(1.6,0) 2(-1.6,0)
CC7343
  rect 2.413x2.819 smd: 1(-3.2,0) 2(3.2,0)
CHOKE-ETQP4LR36WFC-4P
  custom 0.953x0.953 smd: 1(-5.916,0) 2(5.916,0)
  rect 2.464x0.254 smd: 3(-4.1,0) 4(4.1,0)
CHOKE-PCMC063T-3R3MN-SMT
  rect 1.854x3.505 smd: 1(-3.275,0) 2(3.275,0)
CHOKE-PCMC063T-R82MN-4P-SMT
  custom 0.591x0.591 smd: 1(-3.596,0) 2(3.596,0)
  rect 1.473x0.305 smd: 3(-2.452,0) 4(2.452,0)
CHOKE-WCM2012-4P
  rect 0.889x0.406 smd: 1(-0.85,0.4) 2(0.85,0.4) 3(0.85,-0.4) 4(-0.85,-0.4)
D-DO-214AC
  rect 1.88x2.032 smd: 1(-2.1,0) 2(2.1,0)
DDR-DS1SK-20401-STD-204P-SMT
  round 1.6 hole 1.6 unplated: (-33.4,0)
  round 1.092 hole 1.092 unplated: (33.4,0)
  rect 0.305x2.007 smd: 1(-31.65,-4.1) 2(-31.35,4.1) 3(-31.05,-4.1) 4(-30.75,4.1) 5(-30.45,-4.1) 6(-30.15,4.1) 7(-29.85,-4.1) 8(-29.55,4.1) 9(-29.25,-4.1) 10(-28.95,4.1) 11(-28.65,-4.1) 12(-28.35,4.1) 13(-28.05,-4.1) 14(-27.75,4.1) 15(-27.45,-4.1) 16(-27.15,4.1) 17(-26.85,-4.1) 18(-26.55,4.1) 19(-26.25,-4.1) 20(-25.95,4.1) 21(-25.65,-4.1) 22(-25.35,4.1) 23(-25.05,-4.1) 24(-24.75,4.1) 25(-24.45,-4.1) 26(-24.15,4.1) 27(-23.85,-4.1) 28(-23.55,4.1) 29(-23.25,-4.1) 30(-22.95,4.1) 31(-22.65,-4.1) 32(-22.35,4.1) 33(-22.05,-4.1) 34(-21.75,4.1) 35(-21.45,-4.1) 36(-21.15,4.1) 37(-20.85,-4.1) 38(-20.55,4.1) 39(-20.25,-4.1) 40(-19.95,4.1) 41(-19.65,-4.1) 42(-19.35,4.1) 43(-19.05,-4.1) 44(-18.75,4.1) 45(-18.45,-4.1) 46(-18.15,4.1) 47(-17.85,-4.1) 48(-17.55,4.1) 49(-17.25,-4.1) 50(-16.95,4.1) 51(-16.65,-4.1) 52(-16.35,4.1) 53(-16.05,-4.1) 54(-15.75,4.1) 55(-15.45,-4.1) 56(-15.15,4.1) 57(-14.85,-4.1) 58(-14.55,4.1) 59(-14.25,-4.1) 60(-13.95,4.1) 61(-13.65,-4.1) 62(-13.35,4.1) 63(-13.05,-4.1) 64(-12.75,4.1) 65(-12.45,-4.1) 66(-12.15,4.1) 67(-11.85,-4.1) 68(-11.55,4.1) 69(-11.25,-4.1) 70(-10.95,4.1) 71(-10.65,-4.1) 72(-10.35,4.1) 73(-7.65,-4.1) 74(-7.35,4.1) 75(-7.05,-4.1) 76(-6.75,4.1) 77(-6.45,-4.1) 78(-6.15,4.1) 79(-5.85,-4.1) 80(-5.55,4.1) 81(-5.25,-4.1) 82(-4.95,4.1) 83(-4.65,-4.1) 84(-4.35,4.1) 85(-4.05,-4.1) 86(-3.75,4.1) 87(-3.45,-4.1) 88(-3.15,4.1) 89(-2.85,-4.1) 90(-2.55,4.1) 91(-2.25,-4.1) 92(-1.95,4.1) 93(-1.65,-4.1) 94(-1.35,4.1) 95(-1.05,-4.1) 96(-0.75,4.1) 97(-0.45,-4.1) 98(-0.15,4.1) 99(0.15,-4.1) 100(0.45,4.1) 101(0.75,-4.1) 102(1.05,4.1) 103(1.35,-4.1) 104(1.65,4.1) 105(1.95,-4.1) 106(2.25,4.1) 107(2.55,-4.1) 108(2.85,4.1) 109(3.15,-4.1) 110(3.45,4.1) 111(3.75,-4.1) 112(4.05,4.1) 113(4.35,-4.1) 114(4.65,4.1) 115(4.95,-4.1) 116(5.25,4.1) 117(5.55,-4.1) 118(5.85,4.1) 119(6.15,-4.1) 120(6.45,4.1) 121(6.75,-4.1) 122(7.05,4.1) 123(7.35,-4.1) 124(7.65,4.1) 125(7.95,-4.1) 126(8.25,4.1) 127(8.55,-4.1) 128(8.85,4.1) 129(9.15,-4.1) 130(9.45,4.1) 131(9.75,-4.1) 132(10.05,4.1) 133(10.35,-4.1) 134(10.65,4.1) 135(10.95,-4.1) 136(11.25,4.1) 137(11.55,-4.1) 138(11.85,4.1) 139(12.15,-4.1) 140(12.45,4.1) 141(12.75,-4.1) 142(13.05,4.1) 143(13.35,-4.1) 144(13.65,4.1) 145(13.95,-4.1) 146(14.25,4.1) 147(14.55,-4.1) 148(14.85,4.1) 149(15.15,-4.1) 150(15.45,4.1) 151(15.75,-4.1) 152(16.05,4.1) 153(16.35,-4.1) 154(16.65,4.1) 155(16.95,-4.1) 156(17.25,4.1) 157(17.55,-4.1) 158(17.85,4.1) 159(18.15,-4.1) 160(18.45,4.1) 161(18.75,-4.1) 162(19.05,4.1) 163(19.35,-4.1) 164(19.65,4.1) 165(19.95,-4.1) 166(20.25,4.1) 167(20.55,-4.1) 168(20.85,4.1) 169(21.15,-4.1) 170(21.45,4.1) 171(21.75,-4.1) 172(22.05,4.1) 173(22.35,-4.1) 174(22.65,4.1) 175(22.95,-4.1) 176(23.25,4.1) 177(23.55,-4.1) 178(23.85,4.1) 179(24.15,-4.1) 180(24.45,4.1) 181(24.75,-4.1) 182(25.05,4.1) 183(25.35,-4.1) 184(25.65,4.1) 185(25.95,-4.1) 186(26.25,4.1) 187(26.55,-4.1) 188(26.85,4.1) 189(27.15,-4.1) 190(27.45,4.1) 191(27.75,-4.1) 192(28.05,4.1) 193(28.35,-4.1) 194(28.65,4.1) 195(28.95,-4.1) 196(29.25,4.1) 197(29.55,-4.1) 198(29.85,4.1) 199(30.15,-4.1) 200(30.45,4.1) 201(30.75,-4.1) 202(31.05,4.1) 203(31.35,-4.1) 204(31.65,4.1)
  rect 3.505x4.597 smd: 205(32.8,12) 206(-32.8,12)
DSM
  rect 1.016x0.508 smd: 1(-1.3,0) 2(1.321,0)
DSMV
  rect 1.016x0.762 smd: 1(-1.27,0) 2(1.27,0)
DSUB-10296-00021-15P
  round 0.965 hole 0.711: 1(-4.58,0.1) 2(-2.29,0.1) 3(0,0.1) 4(2.29,0.1) 5(4.58,0.1) 6(-5.725,0.1) 7(-3.435,0.1) 8(-1.145,0.1) 9(1.145,0.1) 10(3.435,0.1) 11(-4.58,1.5) 12(-2.29,1.5) 13(0,1.5) 14(2.29,1.5) 15(4.58,1.5)
  oval 0.889x2.794 hole 0.61x2.489: 16(-10.05,0) 17(10.05,0)
ECAP6_3X6_1-7_2
  rect 3.505x1.6 smd: 1(2.8,0) 2(-2.8,0)
ESD8-2X1-5
  rect 0.305x0.66 smd: 1(-0.75,-0.45) 2(-0.25,-0.45) 3(0.25,-0.45) 4(0.75,-0.45) 5(0.75,0.45) 6(0.25,0.45) 7(-0.25,0.45) 8(-0.75,0.45)
GS12401-1011-9H-40P-R
  round 0.762 hole 0.762 unplated: (-10.5,0) (10.5,0)
  rect 0.254x1.143 smd: 1(9.75,2.125) 2(9.25,2.125) 3(8.75,2.125) 4(8.25,2.125) 5(7.75,2.125) 6(7.25,2.125) 7(6.75,2.125) 8(6.25,2.125) 9(5.75,2.125) 10(5.25,2.125) 11(4.75,2.125) 12(4.25,2.125) 13(3.75,2.125) 14(3.25,2.125) 15(2.75,2.125) 16(2.25,2.125) 17(1.75,2.125) 18(1.25,2.125) 19(0.75,2.125) 20(0.25,2.125) 21(-0.25,2.125) 22(-0.75,2.125) 23(-1.25,2.125) 24(-1.75,2.125) 25(-2.25,2.125) 26(-2.75,2.125) 27(-3.25,2.125) 28(-3.75,2.125) 29(-4.25,2.125) 30(-4.75,2.125) 31(-5.25,2.125) 32(-5.75,2.125) 33(-6.25,2.125) 34(-6.75,2.125) 35(-7.25,2.125) 36(-7.75,2.125) 37(-8.25,2.125) 38(-8.75,2.125) 39(-9.25,2.125) 40(-9.75,2.125)
  rect 1.499x2.997 smd: 41(12.25,0) 42(-12.25,0)
  rect 2.794x1.499 smd: 43(5.7,-2.05) 44(-5.7,-2.05)
H-C150D150N
  round 3.81 hole 3.81 unplated: (0,0)
H-C197D138P2
  round 5.004 hole 3.505: 1(0,0)
H-C217D138P2
  round 5.512 hole 3.505: 1(0,0)
H-C236D157P2
  round 5.994 hole 3.988: 1(0,0)
H-C236D165P2
  round 5.994 hole 4.191: 1(0,0)
H-TC197BC142D142P2
  round 3.607 hole 3.607: 1(0,0)
HDMI-C12826-11905-L-19P-SMT
  round 0.813 hole 0.559: 1(-4.5,5.375) 2(-4,6.925) 3(-3.5,5.375) 4(-3,6.925) 5(-2.5,5.375) 6(-2,6.925) 7(-1.5,5.375) 8(-1,6.925) 9(-0.5,5.375) 10(0,6.925) 11(0.5,5.375) 12(1,6.925) 13(1.5,5.375) 14(2,6.925) 15(2.5,5.375) 16(3,6.925) 17(3.5,5.375) 18(4,6.925) 19(4.5,5.375)
  oval 1.397x2.692 hole 0.787x2.108: 20(-9.15,0) 21(-9.15,7.1) 22(9.15,0) 23(9.15,7.1)
HG-C236D118P2
  round 5.994 hole 2.997: 1(0,0)
  round 1.016 hole 0.61: 2(0,2.413) 3(1.706,1.706) 4(2.413,0) 5(1.706,-1.706) 6(0,-2.413) 7(-1.706,-1.706) 8(-2.413,0) 9(-1.706,1.706)
HG-C276D118P2
  round 7.01 hole 2.997: 1(0,0)
  round 1.016 hole 0.61: 2(0,2.794) 3(1.976,1.976) 4(2.794,0) 5(1.976,-1.976) 6(0,-2.794) 7(-1.976,-1.976) 8(-2.794,0) 9(-1.976,1.976)
HG-ZRQ-1
  custom 2.088x2.088 hole 4.191: 1(0,0)
  round 1.016 hole 0.61: 2(0,3.556) 3(2.514,2.514) 4(3.556,0) 5(2.514,-2.514) 6(0,-3.556) 7(-2.514,-2.514) 8(-3.556,0) 9(-2.514,2.514)
IMD
  rect 1.016x0.813 smd: 1(1.2,-1) 3(1.2,1) 4(-1.2,1) 6(-1.2,-1)
  rect 1.016x0.61 smd: 2(1.2,0) 5(-1.2,0)
JOPEN25X30_S
  custom 0.159x0.159 smd: 1(-0.368,0) 2(0.368,0)
L2_5X1_8-1_8-SMT
  rect 1.194x2.007 smd: 1(-1.2,0) 2(1.2,0)
LED19-123-Y2ST1D-C30-2T-4P
  rect 1.092x0.61 smd: 1(0.95,0.45) 2(0.95,-0.45) 3(-0.95,-0.45) 4(-0.95,0.45)
LQFP128-16X16-4-1_6H
  rect 0.203x1.499 smd: 1(-6.2,-7.85) 2(-5.8,-7.85) 3(-5.4,-7.85) 4(-5,-7.85) 5(-4.6,-7.85) 6(-4.2,-7.85) 7(-3.8,-7.85) 8(-3.4,-7.85) 9(-3,-7.85) 10(-2.6,-7.85) 11(-2.2,-7.85) 12(-1.8,-7.85) 13(-1.4,-7.85) 14(-1,-7.85) 15(-0.6,-7.85) 16(-0.2,-7.85) 17(0.2,-7.85) 18(0.6,-7.85) 19(1,-7.85) 20(1.4,-7.85) 21(1.8,-7.85) 22(2.2,-7.85) 23(2.6,-7.85) 24(3,-7.85) 25(3.4,-7.85) 26(3.8,-7.85) 27(4.2,-7.85) 28(4.6,-7.85) 29(5,-7.85) 30(5.4,-7.85) 31(5.8,-7.85) 32(6.2,-7.85) 65(6.2,7.85) 66(5.8,7.85) 67(5.4,7.85) 68(5,7.85) 69(4.6,7.85) 70(4.2,7.85) 71(3.8,7.85) 72(3.4,7.85) 73(3,7.85) 74(2.6,7.85) 75(2.2,7.85) 76(1.8,7.85) 77(1.4,7.85) 78(1,7.85) 79(0.6,7.85) 80(0.2,7.85) 81(-0.2,7.85) 82(-0.6,7.85) 83(-1,7.85) 84(-1.4,7.85) 85(-1.8,7.85) 86(-2.2,7.85) 87(-2.6,7.85) 88(-3,7.85) 89(-3.4,7.85) 90(-3.8,7.85) 91(-4.2,7.85) 92(-4.6,7.85) 93(-5,7.85) 94(-5.4,7.85) 95(-5.8,7.85) 96(-6.2,7.85)
  rect 1.499x0.203 smd: 33(7.85,-6.2) 34(7.85,-5.8) 35(7.85,-5.4) 36(7.85,-5) 37(7.85,-4.6) 38(7.85,-4.2) 39(7.85,-3.8) 40(7.85,-3.4) 41(7.85,-3) 42(7.85,-2.6) 43(7.85,-2.2) 44(7.85,-1.8) 45(7.85,-1.4) 46(7.85,-1) 47(7.85,-0.6) 48(7.85,-0.2) 49(7.85,0.2) 50(7.85,0.6) 51(7.85,1) 52(7.85,1.4) 53(7.85,1.8) 54(7.85,2.2) 55(7.85,2.6) 56(7.85,3) 57(7.85,3.4) 58(7.85,3.8) 59(7.85,4.2) 60(7.85,4.6) 61(7.85,5) 62(7.85,5.4) 63(7.85,5.8) 64(7.85,6.2) 97(-7.85,6.2) 98(-7.85,5.8) 99(-7.85,5.4) 100(-7.85,5) 101(-7.85,4.6) 102(-7.85,4.2) 103(-7.85,3.8) 104(-7.85,3.4) 105(-7.85,3) 106(-7.85,2.6) 107(-7.85,2.2) 108(-7.85,1.8) 109(-7.85,1.4) 110(-7.85,1) 111(-7.85,0.6) 112(-7.85,0.2) 113(-7.85,-0.2) 114(-7.85,-0.6) 115(-7.85,-1) 116(-7.85,-1.4) 117(-7.85,-1.8) 118(-7.85,-2.2) 119(-7.85,-2.6) 120(-7.85,-3) 121(-7.85,-3.4) 122(-7.85,-3.8) 123(-7.85,-4.2) 124(-7.85,-4.6) 125(-7.85,-5) 126(-7.85,-5.4) 127(-7.85,-5.8) 128(-7.85,-6.2)
NGFF-APCI0076-P001A-75P-KE
  round 1.092 hole 1.092 unplated: (-10,0)
  round 1.6 hole 1.6 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
O-Z8C-1
  round 5.994 hole 2.997: 1(0,0)
  round 1.016 hole 0.61: 2(0,2.413) 3(1.706,1.706) 4(2.413,0) 5(1.706,-1.706) 6(0,-2.413) 7(-1.706,-1.706) 8(-2.413,0) 9(-1.706,1.706)
PHJK-2SJ3052-005111F-7P
  oval 1.194x2.108 hole 0.61x1.499: 1(-5.9,5.95) 2(5.9,5.95) 3(-5.9,-3.95) 4(-5.9,0) 5(5.9,3.45) 6(5.9,-3.7) 7(5.9,0.33)
POWER-5X6-1_27-7P
  rect 0.635x0.66 smd: 1(2.835,-1.905) 5(-2.835,1.905) 6(-2.835,0.635) 7(-2.835,-0.635) 8(-2.835,-1.905)
  custom 0.485x0.485 smd: 2(2.18,0.115)
  rect 2.159x3.988 smd: 9(-0.525,0)
POWER-6_5-1_84-3P
  rect 0.787x1.397 smd: 1(3.532,0.9) 2(3.532,-0.9)
  rect 4.699x3.607 smd: 3(-0.338,0)
PVQFN20-3_5X3_5-5-25P
  rect 0.279x0.838 smd: 1(-1,-1.725) 2(-0.5,-1.725) 3(0,-1.725) 4(0.5,-1.725) 5(1,-1.725) 11(1,1.725) 12(0.5,1.725) 13(0,1.725) 14(-0.5,1.725) 15(-1,1.725)
  rect 0.838x0.279 smd: 6(1.725,-1) 7(1.725,-0.5) 8(1.725,0) 9(1.725,0.5) 10(1.725,1) 16(-1.725,1) 17(-1.725,0.5) 18(-1.725,0) 19(-1.725,-0.5) 20(-1.725,-1)
  rect 2.057x2.057 smd: 21(0,0)
  round 0.61 hole 0.305: 22(-0.5,-0.5) 23(0.5,-0.5) 24(0.5,0.5) 25(-0.5,0.5)
QFN16-3X3-5-22P
  rect 0.305x0.991 smd: 1(-0.75,-1.6) 2(-0.25,-1.6) 3(0.25,-1.6) 4(0.75,-1.6) 9(0.75,1.6) 10(0.25,1.6) 11(-0.25,1.6) 12(-0.75,1.6)
  rect 0.991x0.305 smd: 5(1.6,-0.75) 6(1.6,-0.25) 7(1.6,0.25) 8(1.6,0.75) 13(-1.6,0.75) 14(-1.6,0.25) 15(-1.6,-0.25) 16(-1.6,-0.75)
  rect 1.702x1.702 smd: 17(0,0)
  round 0.508 hole 0.305: 18(-0.5,0.5) 19(0.5,0.5) 20(0,0) 21(-0.5,-0.5) 22(0.5,-0.5)
QFN20-3X3-4-26P
  rect 0.203x0.787 smd: 1(-0.8,-1.5) 2(-0.4,-1.5) 3(0,-1.5) 4(0.4,-1.5) 5(0.8,-1.5) 11(0.8,1.5) 12(0.4,1.5) 13(0,1.5) 14(-0.4,1.5) 15(-0.8,1.5)
  rect 0.787x0.203 smd: 6(1.5,-0.8) 7(1.5,-0.4) 8(1.5,0) 9(1.5,0.4) 10(1.5,0.8) 16(-1.5,0.8) 17(-1.5,0.4) 18(-1.5,0) 19(-1.5,-0.4) 20(-1.5,-0.8)
  rect 1.803x1.803 smd: 21(0,0)
  round 0.508 hole 0.305: 22(-0.5,-0.5) 23(0.5,-0.5) 24(0.5,0.5) 25(-0.5,0.5) 26(0,0)
QFN24-4X4-5-25P
  rect 0.279x0.991 smd: 1(-1.25,-2.1) 2(-0.75,-2.1) 3(-0.25,-2.1) 4(0.25,-2.1) 5(0.75,-2.1) 6(1.25,-2.1) 13(1.25,2.1) 14(0.75,2.1) 15(0.25,2.1) 16(-0.25,2.1) 17(-0.75,2.1) 18(-1.25,2.1)
  rect 0.991x0.279 smd: 7(2.1,-1.25) 8(2.1,-0.75) 9(2.1,-0.25) 10(2.1,0.25) 11(2.1,0.75) 12(2.1,1.25) 19(-2.1,1.25) 20(-2.1,0.75) 21(-2.1,0.25) 22(-2.1,-0.25) 23(-2.1,-0.75) 24(-2.1,-1.25)
  rect 2.591x2.591 smd: 25(0,0)
QFN32-4X4-4-42P-1H
  custom 0.05x0.05 smd: 1(-1.4,-2) 2(-1,-2) 3(-0.6,-2) 4(-0.2,-2) 5(0.2,-2) 6(0.6,-2) 7(1,-2) 8(1.4,-2) 9(2,-1.4) 10(2,-1) 11(2,-0.6) 12(2,-0.2) 13(2,0.2) 14(2,0.6) 15(2,1) 16(2,1.4) 17(1.4,2) 18(1,2) 19(0.6,2) 20(0.2,2) 21(-0.2,2) 22(-0.6,2) 23(-1,2) 24(-1.4,2) 25(-2,1.4) 26(-2,1) 27(-2,0.6) 28(-2,0.2) 29(-2,-0.2) 30(-2,-0.6) 31(-2,-1) 32(-2,-1.4)
  rect 2.794x2.794 smd: 33(0,0)
  round 0.61 hole 0.305: 34(-1,-1) 35(0,-1) 36(1,-1) 37(1,0) 38(1,1) 39(0,1) 40(-1,1) 41(-1,0) 42(0,0)
QFN48-6X6-4-49P-ALC280
  rect 0.203x0.991 smd: 1(-2.2,-3.1) 2(-1.8,-3.1) 3(-1.4,-3.1) 4(-1,-3.1) 5(-0.6,-3.1) 6(-0.2,-3.1) 7(0.2,-3.1) 8(0.6,-3.1) 9(1,-3.1) 10(1.4,-3.1) 11(1.8,-3.1) 12(2.2,-3.1) 25(2.2,3.1) 26(1.8,3.1) 27(1.4,3.1) 28(1,3.1) 29(0.6,3.1) 30(0.2,3.1) 31(-0.2,3.1) 32(-0.6,3.1) 33(-1,3.1) 34(-1.4,3.1) 35(-1.8,3.1) 36(-2.2,3.1)
  rect 0.991x0.203 smd: 13(3.1,-2.2) 14(3.1,-1.8) 15(3.1,-1.4) 16(3.1,-1) 17(3.1,-0.6) 18(3.1,-0.2) 19(3.1,0.2) 20(3.1,0.6) 21(3.1,1) 22(3.1,1.4) 23(3.1,1.8) 24(3.1,2.2) 37(-3.1,2.2) 38(-3.1,1.8) 39(-3.1,1.4) 40(-3.1,1) 41(-3.1,0.6) 42(-3.1,0.2) 43(-3.1,-0.2) 44(-3.1,-0.6) 45(-3.1,-1) 46(-3.1,-1.4) 47(-3.1,-1.8) 48(-3.1,-2.2)
  rect 4.394x4.394 smd: 49(0,0)
QFN48-6X6-4-49P-IT6513FN
  rect 0.203x1.016 smd: 1(-2.2,-3.088) 2(-1.8,-3.088) 3(-1.4,-3.088) 4(-1,-3.088) 5(-0.6,-3.088) 6(-0.2,-3.088) 7(0.2,-3.088) 8(0.6,-3.088) 9(1,-3.088) 10(1.4,-3.088) 11(1.8,-3.088) 12(2.2,-3.088) 25(2.2,3.088) 26(1.8,3.088) 27(1.4,3.088) 28(1,3.088) 29(0.6,3.088) 30(0.2,3.088) 31(-0.2,3.088) 32(-0.6,3.088) 33(-1,3.088) 34(-1.4,3.088) 35(-1.8,3.088) 36(-2.2,3.088)
  rect 1.016x0.203 smd: 13(3.088,-2.2) 14(3.088,-1.8) 15(3.088,-1.4) 16(3.088,-1) 17(3.088,-0.6) 18(3.088,-0.2) 19(3.088,0.2) 20(3.088,0.6) 21(3.088,1) 22(3.088,1.4) 23(3.088,1.8) 24(3.088,2.2) 37(-3.088,2.2) 38(-3.088,1.8) 39(-3.088,1.4) 40(-3.088,1) 41(-3.088,0.6) 42(-3.088,0.2) 43(-3.088,-0.2) 44(-3.088,-0.6) 45(-3.088,-1) 46(-3.088,-1.4) 47(-3.088,-1.8) 48(-3.088,-2.2)
  rect 4.369x4.369 smd: 49(0,0)
QFN64-9X9-5-65P-RTL8411
  rect 0.305x0.991 smd: 1(-3.75,-4.6) 2(-3.25,-4.6) 3(-2.75,-4.6) 4(-2.25,-4.6) 5(-1.75,-4.6) 6(-1.25,-4.6) 7(-0.75,-4.6) 8(-0.25,-4.6) 9(0.25,-4.6) 10(0.75,-4.6) 11(1.25,-4.6) 12(1.75,-4.6) 13(2.25,-4.6) 14(2.75,-4.6) 15(3.25,-4.6) 16(3.75,-4.6) 33(3.75,4.6) 34(3.25,4.6) 35(2.75,4.6) 36(2.25,4.6) 37(1.75,4.6) 38(1.25,4.6) 39(0.75,4.6) 40(0.25,4.6) 41(-0.25,4.6) 42(-0.75,4.6) 43(-1.25,4.6) 44(-1.75,4.6) 45(-2.25,4.6) 46(-2.75,4.6) 47(-3.25,4.6) 48(-3.75,4.6)
  rect 0.991x0.305 smd: 17(4.6,-3.75) 18(4.6,-3.25) 19(4.6,-2.75) 20(4.6,-2.25) 21(4.6,-1.75) 22(4.6,-1.25) 23(4.6,-0.75) 24(4.6,-0.25) 25(4.6,0.25) 26(4.6,0.75) 27(4.6,1.25) 28(4.6,1.75) 29(4.6,2.25) 30(4.6,2.75) 31(4.6,3.25) 32(4.6,3.75) 49(-4.6,3.75) 50(-4.6,3.25) 51(-4.6,2.75) 52(-4.6,2.25) 53(-4.6,1.75) 54(-4.6,1.25) 55(-4.6,0.75) 56(-4.6,0.25) 57(-4.6,-0.25) 58(-4.6,-0.75) 59(-4.6,-1.25) 60(-4.6,-1.75) 61(-4.6,-2.25) 62(-4.6,-2.75) 63(-4.6,-3.25) 64(-4.6,-3.75)
  rect 3.988x3.988 smd: 65(0,0)
RC0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
RC0603
  rect 0.813x0.711 smd: 1(0.737,0) 2(-0.737,0)
RC0805
  rect 0.94x1.346 smd: 1(0.895,0) 2(-0.895,0)
RC1206
  rect 1.6x1.6 smd: 1(1.702,0) 2(-1.702,0)
RC3216
  rect 3.2x0.94 smd: 1(0,0.825) 2(0,-0.825)
RJ45-JM361C-HP34AA03-9H-8P
  round 1.295 hole 0.889: 1(3.57,10.1) 2(2.55,11.2) 3(1.53,10.1) 4(0.51,11.2) 5(-0.51,10.1) 6(-1.53,11.2) 7(-2.55,10.1) 8(-3.57,11.2)
  oval 1.092x2.108 hole 0.61x1.6: 9(8.4,0) 10(8.4,7.8) 11(-8.4,0) 12(-8.4,7.8)
SATA-51205-0134T-001-13P-R
  round 1.397 hole 1.397 unplated: (-2,0)
  round 1.092 hole 1.092 unplated: (6.22,-0.3)
  rect 0.787x1.854 smd: 1(6.85,3.28) 2(5.58,3.28) 3(4.31,3.28) 4(3.04,3.28) 5(1.77,3.28) 6(0.5,3.28) 7(-0.77,3.28)
  rect 0.559x1.854 smd: 8(-3.07,3.28) 9(-3.87,3.28) 10(-4.67,3.28) 11(-5.47,3.28) 12(-6.27,3.28) 13(-7.07,3.28)
  rect 1.651x1.194 smd: 14(8.88,1.995) 15(-8.88,1.995)
  rect 1.397x1.651 smd: 16(4.5,-1.78) 17(-4.5,-1.78)
SC70-2_1-65-6P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,0) 6(-1.02,-0.65)
SENSOR-3X3-5-16P-SMT
  rect 0.762x0.254 smd: 1(-1.377,1) 2(-1.377,0.5) 3(-1.377,0) 4(-1.377,-0.5) 5(-1.377,-1) 9(1.377,-1) 10(1.377,-0.5) 11(1.377,0) 12(1.377,0.5) 13(1.377,1)
  rect 0.254x0.762 smd: 6(-0.5,-1.377) 7(0,-1.377) 8(0.5,-1.377) 14(0.5,1.377) 15(0,1.377) 16(-0.5,1.377)
SHORT0402
  rect 0.648x0.5 smd: 1(-0.39,0) 2(0.39,0)
SHORT0603
  rect 1.168x0.711 smd: 1(0.737,0) 2(-0.737,0)
SHORT0805
  rect 1.397x1.346 smd: 1(0.895,0) 2(-0.895,0)
SLP10-2_5X1-5-10P
  rect 0.203x0.686 smd: 1(-1,-0.437) 2(-0.5,-0.437) 4(0.5,-0.437) 5(1,-0.437) 6(1,0.437) 7(0.5,0.437) 9(-0.5,0.437) 10(-1,0.437)
  rect 0.406x1.549 smd: 3(0,0)
SO-8FL-5P-OA
  rect 0.991x0.762 smd: 1(3.73,-1.905) 2(3.73,-0.635) 3(3.73,0.635) 4(3.73,1.905)
  custom 1.132x1.132 smd: 5(0,0)
SOIC8-6-1_27
  rect 0.533x1.753 smd: 1(-1.905,-2.73) 2(-0.635,-2.73) 3(0.635,-2.73) 4(1.905,-2.73) 5(1.905,2.73) 6(0.635,2.73) 7(-0.635,2.73) 8(-1.905,2.73)
SOIC8-8-1_27
  rect 0.533x1.6 smd: 1(1.905,3.8) 2(0.635,3.8) 3(-0.635,3.8) 4(-1.905,3.8) 5(-1.905,-3.8) 6(-0.635,-3.8) 7(0.635,-3.8) 8(1.905,-3.8)
SON8-4_5X3_5-5-9P-SMT
  custom 0.05x0.05 smd: 1(-1.6,-1.6) 2(-1.2,-1.6) 3(-0.8,-1.6) 6(-0.8,1.6) 7(-1.2,1.6) 8(-1.6,1.6)
  custom 0.188x0.188 smd: 4(0.6,-1.6) 5(0.6,1.6)
  rect 4.039x2.21 smd: 9(0,0)
SON10-3X3-5-16P
  rect 0.279x0.838 smd: 1(-1,-1.475) 2(-0.5,-1.475) 3(0,-1.475) 4(0.5,-1.475) 5(1,-1.475) 6(1,1.475) 7(0.5,1.475) 8(0,1.475) 9(-0.5,1.475) 10(-1,1.475)
  custom 0.413x0.413 smd: 11(0,0)
  round 0.61 hole 0.305: 12(-0.75,-0.5) 13(0.75,-0.5) 14(0.75,0.5) 15(-0.75,0.5) 16(0,0)
SOT23-2_8-95-6P
  rect 1.346x0.508 smd: 1(1.325,-0.95) 2(1.325,0) 3(1.325,0.95) 4(-1.325,0.95) 5(-1.325,0) 6(-1.325,-0.95)
SOT23-5
  rect 1.016x0.711 smd: 1(1.2,-0.95) 2(1.2,0) 3(1.2,0.95) 4(-1.2,0.95) 5(-1.2,-0.95)
SOT23-5-2_8-95-5P-G708
  rect 1.194x0.533 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,-0.95)
SOT23_213-3_3-2
  rect 1.27x1.016 smd: 1(1.016,1.016) 2(1.016,-1.016) 3(-1.016,0)
SOT353-1-2_125-65-5P
  rect 1.245x0.279 smd: 1(1.045,-0.65) 2(1.045,0) 3(1.045,0.65) 4(-1.045,0.65) 5(-1.045,-0.65)
SPAD-E858X1268
  oval 2.718x1.626 hole 1.702x0.61: 1(-5.484,12.77) 2(-1.5,12.77) 3(0,3) 4(0,0) 5(-5.484,-9.23) 6(-1.5,-9.23)
SSOP5-P-A-TOSHIBA-B
  rect 1.067x0.305 smd: 1(0.85,-0.65) 2(0.85,0) 3(0.85,0.65) 4(-0.85,0.65) 5(-0.85,-0.65)
SW-TC901-AA1G-A160T-6P
  rect 0.991x1.702 smd: 1(-1.8,3.15) 2(1.8,3.15) 3(-1.8,-3.15) 4(1.8,-3.15)
  rect 0.457x0.991 smd: 5(-2.525,0) 6(2.525,0)
SW-TME-532-V-6P
  rect 1.803x1.092 smd: 1(-3.1,1.85) 2(3.1,1.85) 3(-3.1,-1.85) 4(3.1,-1.85)
  rect 0.991x0.61 smd: 5(0,2.5) 6(0,-2.5)
TDFN8-2X2-5-9P-MAX14566
  rect 0.305x0.711 smd: 1(-0.75,-0.99) 2(-0.25,-0.99) 3(0.25,-0.99) 4(0.75,-0.99) 5(0.75,0.99) 6(0.25,0.99) 7(-0.25,0.99) 8(-0.75,0.99)
  rect 1.295x0.711 smd: 9(0,0)
TP2050
  round 0.508 smd: 1(0,0)
TP2650
  round 0.66 smd: 1(0,0)
TP2675
  round 0.66 smd: 1(0,0)
TRF-LC401-8P
  rect 1.499x0.406 smd: 1(-2.175,-1.575) 2(-2.175,-0.875) 3(-2.175,0.875) 4(-2.175,1.575) 5(2.175,1.575) 6(2.175,0.875) 7(2.175,-0.875) 8(2.175,-1.575)
TSSOP28-6_4-65-SLB9635TT
  rect 0.406x1.295 smd: 1(-4.225,-3.05) 2(-3.575,-3.05) 3(-2.925,-3.05) 4(-2.275,-3.05) 5(-1.625,-3.05) 6(-0.975,-3.05) 7(-0.325,-3.05) 8(0.325,-3.05) 9(0.975,-3.05) 10(1.625,-3.05) 11(2.275,-3.05) 12(2.925,-3.05) 13(3.575,-3.05) 14(4.225,-3.05) 15(4.225,3.05) 16(3.575,3.05) 17(2.925,3.05) 18(2.275,3.05) 19(1.625,3.05) 20(0.975,3.05) 21(0.325,3.05) 22(-0.325,3.05) 23(-0.975,3.05) 24(-1.625,3.05) 25(-2.275,3.05) 26(-2.925,3.05) 27(-3.575,3.05) 28(-4.225,3.05)
UB2-C14793-10409-L-4P-R
  round 1.397 hole 0.787: 1(3.5,8.4) 2(1,8.4) 3(-1,8.4) 4(-3.5,8.4)
  oval 1.194x2.21 hole 0.61x1.6: 5(7.75,5.05) 6(-7.75,5.05) 7(7.75,0) 8(-7.75,0)
UB3-50928-0090A-001-9P
  round 1.194 hole 0.787: 1(3.5,10.4) 2(1,10.4) 3(-1,10.4) 4(-3.5,10.4) 5(-4,8.9) 6(-2,8.9) 7(0,8.9) 8(2,8.9) 9(4,8.9)
  oval 1.524x2.515 hole 0.508x1.499: 10(7.75,10.4) 11(-7.75,10.4) 12(-7.75,0) 13(7.75,0)
UMT_213-3-1_3
  rect 1.016x0.762 smd: 1(0.991,0.66) 2(0.991,-0.66) 3(-0.991,0)
unnamed
  round 1.016 smd: 1(0,0)
VQFN14-3_5X3_5-5-15P
  rect 0.838x0.279 smd: 1(-1.725,-0.75) 7(1.725,-0.75) 8(1.725,0.75) 14(-1.725,0.75)
  rect 0.279x0.838 smd: 2(-1,-1.725) 3(-0.5,-1.725) 4(0,-1.725) 5(0.5,-1.725) 6(1,-1.725) 9(1,1.725) 10(0.5,1.725) 11(0,1.725) 12(-0.5,1.725) 13(-1,1.725)
  rect 2.057x2.057 smd: 15(0,0)
WDFN5-3_05X3_05-65
  rect 0.66x0.432 smd: 1(1.385,-0.975) 2(1.385,-0.325) 3(1.385,0.325) 4(1.385,0.975)
  custom 0.575x0.575 smd: 5(-0.735,0)
XTL-3_2X1_5-2_5-0_8H
  rect 0.991x1.803 smd: 1(-1.25,0) 2(1.25,0)
XTL-3_2X2_5-2_2X1_6
  rect 1.397x1.194 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)
XTL-3_2X2_5-2_2X1_7
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)

## Nets
1.5V_VSNS: PR213.1 PR214.2 PU10.6
2.469V: PR155.1 PR159.2 PU8.3
3V3AUX: U43.F11
3V_LDO: PC52.1 PR191.1 PU5.3
3V_MAIN_PWGD: PR28.1 PR166.2 Q5.3 R66.2 R70.1
51211V_DRVH: PQ44.4 PU4.9
51211V_DRVL: PQ41.4 PU4.6
51211V_EN: PR171.2 PR172.2 PR175.2 PU4.3
51211V_FB: PR61.2 PR63.1 PU4.4
51211V_SW: PC42.2 PL5.1 PQ41.5 PQ44.1 PQ44.2 PQ44.3 PR53.1 PU4.8
51211V_TRIP: PR68.2 PU4.2
51211V_TST: PR165.2 PU4.5
51211V_VBST: PR71.2 PU4.10
+1.05V: C156.1 C175.2 C227.1 L10.1 L16.1 L30.1 PQ32.1 PQ32.2 PQ32.3 PR21.2 PR81.2 PR160.1 R128.1 R133.2 R144.1 R145.1 R165.1 R232.1 R401.2 R495.1 U15.5 U45.AG14 U45.J17 U45.R21 U45.T21
+1.5V: PC147.2 PC148.1 PC149.1 PL10.2 PQ54.1 PR123.1 PR214.1 R84.1 R392.2
+1.05V_DCPSUS1: C229.1 R264.2 U45.AD8 U45.AD10
+1.05V_DCPSUS2: C252.1 R263.1 U45.AH13
+1.05V_DCPSUS3: C174.2 C178.1 R119.2 U45.J13
+1.05V_DCPSUS4: C216.1 R262.2 U45.AB8
+1.05V_GFX: C89.2 C91.2 C97.1 C105.1 C106.2 C111.2 C118.1 C126.2 C131.1 C133.1 C141.1 C150.1 C160.1 C611.2 L13.2 L14.1 L15.1 PQ4.1 PQ4.2 PQ4.3 PR23.1 R67.1 U43.AA10 U43.AA12 U43.AA13 U43.AA16 U43.AA18 U43.AA19 U43.AA20 U43.AA21 U43.AA22 U43.AB22 U43.AB23 U43.AC23 U43.AC24 U43.AD24 U43.AD25 U43.AE25 U43.AE26 U43.AE27 U43.AF26 U43.AF27
+1.05V_S5: C102.2 C326.2 PC110.1 PC113.2 PL5.2 PQ4.5 PQ32.5 PR61.1 R119.1 R150.1 R151.1 R164.1 R166.2 R262.1 R263.2 R264.1 R594.2
+1.05V_VCCST: C51.1 C241.2 PC91.1 PR2.1 PR3.1 PR6.1 PR129.1 Q8.3 R96.2 R103.1 R109.1 R144.2 R499.2 R506.2 R548.2 R554.1 R578.1 U10.5 U45.AC22 U45.AE22 U45.AE23
+1.5VAVDD2: C479.1 C488.1 R392.1 U34.40
+1.35V_GFX: C2.2 C5.2 C10.1 C11.2 C12.2 C13.2 C15.1 C16.1 C17.1 C18.2 C19.1 C20.2 C21.1 C22.1 C23.1 C24.1 C25.1 C26.1 C27.2 C32.2 C37.1 C42.1 C45.1 C46.2 C55.1 C56.2 C57.2 C64.2 C65.2 C66.2 C67.2 C68.2 C69.2 C73.1 C76.1 C78.1 C79.2 C81.2 C83.2 C86.2 C88.1 C92.1 C98.2 C101.2 C107.2 C108.1 C109.2 C112.2 C113.2 C114.2 C117.2 C119.2 C120.1 C121.1 C122.2 C130.2 C137.2 C139.1 C145.2 C152.2 C155.1 C162.1 C172.2 C189.2 C197.2 C198.2 C199.1 C201.1 C202.1 C203.1 C204.2 C207.1 C208.2 C226.2 C524.2 C525.2 C526.2 C527.2 C529.1 C530.1 C531.2 C532.2 C533.2 C534.2 C535.2 C536.1 C537.1 C538.1 C539.1 C540.1 C541.1 C542.1 C545.1 C546.1 C548.2 C550.2 C563.2 C571.1 C573.2 C576.1 C577.1 C578.2 C579.2 C580.1 C581.2 C582.2 C583.2 C584.2 C587.2 C590.2 C591.1 C592.2 C596.2 C601.1 C603.2 C604.1 C608.1 C609.2 C610.2 C620.2 C628.2 C629.2 C639.2 C640.1 C641.2 C642.2 C643.1 C644.1 C645.2 C646.1 C647.1 C648.1 C650.1 C651.1 C652.2 C653.2 C654.1 C655.1 PC97.1 PC100.2 PL2.2 PQ10.1 PQ10.2 PQ10.3 PR154.1 PR162.1 R4.2 R10.2 R15.2 R17.2 R28.2 R35.2 R36.2 R39.2 R41.2 R42.2 R49.2 R63.2 R122.2 R172.1 R173.1 R174.1 R435.2 R441.2 R443.2 R454.2 R458.2 R461.2 R463.2 R469.2 R470.2 R471.2 R473.2 R490.2 R563.2 U11.A1 U11.A8 U11.B2 U11.C1 U11.C9 U11.D2 U11.D9 U11.E9 U11.F1 U11.G7 U11.H2 U11.H9 U11.K2 U11.K8 U11.N1 U11.N9 U11.R1 U11.R9 U12.A1 U12.A8 U12.B2 U12.C1 U12.C9 U12.D2 U12.D9 U12.E9 U12.F1 U12.G7 U12.H2 U12.H9 U12.K2 U12.K8 U12.N1 U12.N9 U12.R1 U12.R9 U13.A1 U13.A8 U13.B2 U13.C1 U13.C9 U13.D2 U13.D9 U13.E9 U13.F1 U13.G7 U13.H2 U13.H9 U13.K2 U13.K8 U13.N1 U13.N9 U13.R1 U13.R9 U16.A1 U16.A8 U16.B2 U16.C1 U16.C9 U16.D2 U16.D9 U16.E9 U16.F1 U16.G7 U16.H2 U16.H9 U16.K2 U16.K8 U16.N1 U16.N9 U16.R1 U16.R9 U38.A1 U38.A8 U38.B2 U38.C1 U38.C9 U38.D2 U38.D9 U38.E9 U38.F1 U38.G7 U38.H2 U38.H9 U38.K2 U38.K8 U38.N1 U38.N9 U38.R1 U38.R9 U39.A1 U39.A8 U39.B2 U39.C1 U39.C9 U39.D2 U39.D9 U39.E9 U39.F1 U39.G7 U39.H2 U39.H9 U39.K2 U39.K8 U39.N1 U39.N9 U39.R1 U39.R9 U41.A1 U41.A8 U41.B2 U41.C1 U41.C9 U41.D2 U41.D9 U41.E9 U41.F1 U41.G7 U41.H2 U41.H9 U41.K2 U41.K8 U41.N1 U41.N9 U41.R1 U41.R9 U43.B26 U43.C25 U43.E23 U43.E26 U43.F14 U43.F21 U43.G13 U43.G14 U43.G15 U43.G16 U43.G18 U43.G19 U43.G20 U43.G21 U43.H24 U43.H26 U43.J21 U43.K21 U43.L22 U43.L24 U43.L26 U43.M21 U43.N21 U43.R21 U43.T21 U43.V21 U43.W21 U44.A1 U44.A8 U44.B2 U44.C1 U44.C9 U44.D2 U44.D9 U44.E9 U44.F1 U44.G7 U44.H2 U44.H9 U44.K2 U44.K8 U44.N1 U44.N9 U44.R1 U44.R9
+1.35V_SUS: C242.2 C243.1 C244.1 C245.2 C268.2 C269.2 C270.1 C271.1 C272.1 C276.2 C291.1 C299.1 C306.1 C315.1 C316.2 C317.1 C318.2 C319.2 C320.2 C346.2 C347.1 C348.2 C349.2 C350.2 C351.1 C355.1 C356.1 C359.2 C363.2 C364.1 C365.1 C366.1 C367.2 C373.1 C374.2 C375.1 C376.1 C379.1 C380.1 C382.2 C383.1 C384.1 C385.1 C386.1 C388.1 C389.1 C392.1 C393.1 C395.1 C396.1 C398.1 C413.1 C415.1 C417.1 C418.2 C420.1 C421.1 C422.1 C424.1 C425.2 C428.1 C431.2 C432.1 C433.1 C434.1 C435.1 C440.1 C441.1 C442.1 C443.1 C444.1 C445.1 C446.1 C447.1 C448.1 C449.1 C450.1 C451.1 C452.1 C453.1 C454.1 C455.1 C456.1 C457.1 C458.1 C459.1 C461.2 C462.2 C463.2 C464.2 C465.2 C467.1 C694.1 C695.1 C696.1 C697.1 C698.1 C700.1 C702.1 C703.1 C704.1 C705.2 C708.1 C709.1 C712.1 C713.1 C715.1 C718.1 C719.1 C720.1 C723.1 C727.1 C728.1 C732.1 C733.1 C734.1 C735.1 C736.1 C737.2 C738.1 C739.1 C740.1 C742.1 C743.1 C744.1 C745.1 C746.1 C747.1 C748.1 C749.1 C750.1 C751.1 C752.1 C753.1 C754.1 C755.1 C756.2 C764.1 JDIM1.75 JDIM1.76 JDIM1.81 JDIM1.82 JDIM1.87 JDIM1.88 JDIM1.93 JDIM1.94 JDIM1.99 JDIM1.100 JDIM1.105 JDIM1.106 JDIM1.111 JDIM1.112 JDIM1.117 JDIM1.118 JDIM1.123 JDIM1.124 PC80.1 PC135.2 PC136.1 PC138.2 PL8.2 PQ10.5 PQ54.3 PU6.2 PU6.9 Q25.3 R282.2 R325.2 R333.1 R365.2 R375.1 U23.5 U28.A1 U28.A8 U28.B2 U28.C1 U28.C9 U28.D2 U28.D9 U28.E9 U28.F1 U28.G7 U28.H2 U28.H9 U28.K2 U28.K8 U28.N1 U28.N9 U28.R1 U28.R9 U29.A1 U29.A8 U29.B2 U29.C1 U29.C9 U29.D2 U29.D9 U29.E9 U29.F1 U29.G7 U29.H2 U29.H9 U29.K2 U29.K8 U29.N1 U29.N9 U29.R1 U29.R9 U30.A1 U30.A8 U30.B2 U30.C1 U30.C9 U30.D2 U30.D9 U30.E9 U30.F1 U30.G7 U30.H2 U30.H9 U30.K2 U30.K8 U30.N1 U30.N9 U30.R1 U30.R9 U31.A1 U31.A8 U31.B2 U31.C1 U31.C9 U31.D2 U31.D9 U31.E9 U31.F1 U31.G7 U31.H2 U31.H9 U31.K2 U31.K8 U31.N1 U31.N9 U31.R1 U31.R9 U45.AH26 U45.AJ31 U45.AJ33 U45.AJ37 U45.AN33 U45.AP43 U45.AR48 U45.AY35 U45.AY40 U45.AY44 U45.AY50 U50.A1 U50.A8 U50.B2 U50.C1 U50.C9 U50.D2 U50.D9 U50.E9 U50.F1 U50.G7 U50.H2 U50.H9 U50.K2 U50.K8 U50.N1 U50.N9 U50.R1 U50.R9 U51.A1 U51.A8 U51.B2 U51.C1 U51.C9 U51.D2 U51.D9 U51.E9 U51.F1 U51.G7 U51.H2 U51.H9 U51.K2 U51.K8 U51.N1 U51.N9 U51.R1 U51.R9 U52.A1 U52.A8 U52.B2 U52.C1 U52.C9 U52.D2 U52.D9 U52.E9 U52.F1 U52.G7 U52.H2 U52.H9 U52.K2 U52.K8 U52.N1 U52.N9 U52.R1 U52.R9 U53.A1 U53.A8 U53.B2 U53.C1 U53.C9 U53.D2 U53.D9 U53.E9 U53.F1 U53.G7 U53.H2 U53.H9 U53.K2 U53.K8 U53.N1 U53.N9 U53.R1 U53.R9
+3V: C192.2 C266.2 C267.2 C273.2 C275.2 C313.1 C345.1 C387.2 C662.1 C766.2 C768.1 CN17.1 JDIM1.199 L25.1 L29.1 L32.2 PQ47.1 PR33.2 PR65.2 PR66.2 PR72.2 PR79.1 PR114.2 PR136.2 PR167.2 PR217.2 Q1.2 Q2.2 Q3.2 Q17.2 Q20.2 Q20.5 Q26.2 Q30.2 Q38.2 R33.1 R40.2 R55.1 R59.2 R60.2 R64.2 R79.1 R88.1 R90.1 R91.2 R92.2 R94.2 R97.2 R98.2 R99.1 R104.1 R108.2 R110.2 R113.1 R114.2 R115.2 R117.2 R130.2 R131.2 R132.2 R134.1 R137.2 R139.2 R154.1 R155.2 R156.2 R157.2 R158.2 R159.2 R160.2 R186.1 R187.2 R190.2 R192.2 R196.2 R241.2 R257.2 R288.2 R293.2 R297.1 R306.1 R332.2 R344.2 R389.1 R397.1 R398.2 R399.2 R402.2 R408.1 R426.1 R446.1 R447.1 R482.1 R486.2 R514.1 R515.1 R517.1 R520.2 R523.2 R524.2 R525.2 R527.2 R528.2 R529.2 R531.2 R533.2 R534.2 R536.1 R538.2 R539.2 R540.1 R543.2 R544.2 R545.1 R549.1 R551.2 R560.1 R561.1 R569.1 R570.2 R574.2 R575.1 R576.1 R577.2 R580.1 R581.2 R582.1 R586.1 R587.1 R593.1 R596.1 R599.1 R669.2 R699.1 R705.1 R721.2 R749.1 R764.2 R766.1 R771.2 R774.2 R777.2 R782.2 U17.14 U20.5 U21.5 U22.5 U27.5 U46.4 U46.6 U55.8
+3V_DMIC: C516.1 C781.2 CN20.2 R426.2
+3V_EC: C407.1 R332.1 U32.11
+3V_GFX: C148.1 C161.1 C170.2 C171.1 C187.1 C188.1 C195.1 C196.1 C213.1 C214.1 PQ5.1 PR40.1 Q10.2 Q11.2 Q12.2 Q12.5 Q13.2 Q14.2 R65.2 R70.2 R71.2 R148.2 R169.2 R170.2 R171.2 R175.1 R176.1 R180.2 R182.2 R185.2 R361.2 R362.2 R380.2 R552.2 R566.2 R583.1 R584.2 R591.1 R605.2 R606.2 R608.2 R609.2 R610.2 R618.1 R624.2 R627.1 R629.2 R630.2 U43.AA8 U43.AA9 U43.AB8 U43.G8 U43.G9 U43.G10 U43.G12
+3V_MAIN_EN: R610.1 TP138.1 U43.A3
+3V_PCH_ME: C157.1 R76.1 R77.1 R80.1 R106.2 R494.1 U14.8
+3V_RTC: C249.2 C397.1 C682.1 C683.2 C716.1 D15.3 R665.1 R676.1 R677.2 R722.1 R726.1 U32.3 U45.AG10
+3V_RTC_0: CN9.1 Q42.1 R336.1
+3V_RTC_1: D15.1 R336.2
+3V_RTC_2: D15.2 R349.1
+3V_S5: C1.2 C6.2 C47.2 C58.2 C264.2 C265.2 C307.1 C623.2 C677.2 LED1.2 PQ45.1 PR8.2 PR18.2 PR84.1 PR133.2 PR178.2 Q19.2 Q19.5 Q21.2 Q21.5 Q22.2 Q22.5 Q23.1 R44.2 R138.2 R141.1 R146.1 R168.1 R202.1 R203.2 R204.1 R206.1 R208.1 R209.1 R210.2 R211.2 R213.2 R214.1 R219.2 R220.2 R221.2 R226.2 R228.2 R231.1 R240.1 R244.1 R255.1 R260.1 R273.1 R274.2 R277.2 R299.2 R300.2 R324.1 R494.2 R619.1 R622.1 R635.2 R636.1 R637.1 R641.1 R643.2 R646.1 R648.1 R650.2 R651.1 R767.1 RP2.5 RP2.10 U42.5 U47.5
+3V_TPM_VDD: C772.2 C776.1 C778.1 R765.1 R775.2 R780.2 R782.1 U56.10 U56.19 U56.24
+3V_WLAN: Q41.3 R713.1 R721.1
+3VCC_S5: C238.1 C292.2 Q23.3 R273.2 R723.2 U45.AA9 U45.AC9 U45.AE20 U45.AE21 U45.AH11
+3VCPVDD: C491.1 R774.1 U34.36
+3VDVDD: C494.1 C495.1 R398.1 U34.1
+3VDVDDIO: C499.1 C502.1 R408.2 U34.9
+3VPCU: C381.2 C391.2 C400.1 C405.1 CN6.12 D16.1 LED1.1 LED2.1 LED2.2 PC35.1 PC83.2 PC127.1 PC128.2 PC145.1 PL6.2 PQ5.3 PQ45.3 PQ47.3 PR49.2 PR55.2 PR59.2 PR80.1 PR85.1 PR94.2 PR97.2 PR101.2 PR193.2 PU10.1 PU10.2 PU10.16 Q28.1 Q41.1 R45.2 R212.2 R234.2 R235.2 R237.2 R238.2 R301.2 R310.2 R313.2 R315.2 R331.2 R337.1 R338.1 R349.2 R353.2 R439.2 R440.2 R686.2 R716.2 R717.2 R741.1 RP1.5 RP1.10 U26.5
+3VPCU_EC: C371.1 C372.1 C399.1 C402.1 C429.1 C767.1 L18.2 L20.1 R337.2 U32.26 U32.50 U32.92 U32.114 U32.121
+3VPCU_ECPLL: C369.1 L18.1 U32.127
+5V: C3.2 C4.2 C14.2 C41.2 C74.2 C426.2 C427.1 C471.1 C472.1 C473.1 C477.1 C485.2 C523.2 D2.2 D28.2 L21.1 L27.1 L31.2 PQ55.1 PQ55.2 PQ55.3 PR120.1 Q32.1 Q36.3 Q37.3 R230.1 R388.1 R393.2 R394.1 R395.2 R437.2 R445.1 R697.1 R698.2 R708.2 U5.5 U6.5 U33.1 U33.3
+5V_FAN1: CN10.4 R698.1
+5V_FAN2: CN4.4 R437.1
+5V_HDD: C338.1 C340.1 C344.1 C354.1 C358.1 C361.1 CN11.12 CN11.13 R708.1
+5V_KB: C468.2 C470.2 Q32.3 R382.1
+5V_KB_R: CN16.2 CN16.4 R382.2
+5V_S5: C209.1 C263.1 C693.1 PC18.2 PC96.1 PQ53.1 PQ53.2 PQ53.3 PR117.1 PR132.2 PR164.2 PU2.7 PU7.2 R280.1 R794.1 R797.1 U18.5 U19.5 U48.5
+5VA: C478.1 C480.2 C506.1 C507.1 L21.2 R391.1 R404.1 U33.4 U34.26
+5VMCU: L27.2 R475.1 R481.1 R489.1 U40.45
+5VPCU: C378.1 C717.1 PC41.2 PC72.2 PC141.2 PC146.1 PD6.2 PL9.1 PQ53.5 PQ55.5 PR186.2 PU4.7 PU5.14 PU6.12 R318.2 U25.5 U49.5
+5VPVDD1: C482.1 C487.1 R393.1 U34.41
+5VPVDD2: C484.1 C489.1 R395.1 U34.46
+15V: PR24.1 PR31.1 PR107.1 PR118.1 PR122.1 PR163.1
+15V_ALWP: PC70.2 PD7.1 PR107.2
+A3VPCU: C430.1 L20.2 U32.74
+V1.05DX_MODPHY: C173.2 C191.2 L11.1 L12.1 PR21.1 U45.K9 U45.L10 U45.M9
+V1.05M_VCCASW: C235.2 C239.1 C657.2 C659.2 R165.2 U45.AE9 U45.AF9 U45.AG8
+V1.05S_AIDLE: C194.1 R133.1 U45.N8 U45.P9
+V1.05S_APLLOPI: C236.1 C260.2 C661.2 L16.2 U45.AA21 U45.W21
+V1.05S_ASATA3PLL: C100.2 C104.2 C636.1 L11.2 R512.2 R513.1 U45.B11
+V1.05S_AUSB3PLL: C99.2 C103.2 C635.1 L12.2 R509.1 R510.2 U45.B18
+V1.05S_AXCK_DCB: C165.1 C618.2 C619.2 L30.2 U45.J18 U45.K19
+V1.05S_AXCK_LCPLL: C87.2 C96.2 C634.1 L10.2 R500.1 U45.A20
+V1.05S_CORE_PCH: C211.2 C231.1 C254.1 R128.2 U45.AE8 U45.AF22 U45.H11 U45.H15 U45.J11
+V1.5S_VCCATS: R84.2 U45.J15
+V1.05S_VCCUSBCORE: C253.1 R232.2 U45.AG16 U45.AG17
+V3.3DX_1.5DX_1.8DX_AUDIO: C251.2 R210.1 U45.AH14
+V3.3M_PSPI: C233.2 R154.2 R168.2 U45.Y8
+V3.3S_VCCPCORE: C176.2 R117.1 U45.V8 U45.W9
+V3.3S_VCCPTS: C205.1 R79.2 U45.K14 U45.K16
+V3.3S_VCCSDIO: C212.1 R113.2 U45.T9 U45.U8
+VCCIN: C59.2 C60.2 C62.2 C82.2 C90.1 C93.2 C94.1 C95.2 C177.2 C179.2 C180.1 C181.2 C182.1 C183.2 C184.1 C185.1 C210.2 C219.2 C220.2 C221.1 C222.2 C223.1 C224.2 C228.2 C246.2 C572.1 C586.1 C595.1 C602.2 C605.1 C606.2 C607.2 PC86.1 PC94.1 PC98.1 PC99.1 PL1.2 PR127.2 R522.1 U45.AB57 U45.AD57 U45.AG57 U45.C24 U45.C28 U45.C32 U45.C36 U45.C40 U45.C44 U45.C48 U45.C52 U45.C56 U45.E23 U45.E25 U45.E27 U45.E29 U45.E31 U45.E33 U45.E35 U45.E37 U45.E39 U45.E41 U45.E43 U45.E45 U45.E47 U45.E49 U45.E51 U45.E53 U45.E55 U45.E57 U45.F24 U45.F28 U45.F32 U45.F36 U45.F40 U45.F44 U45.F48 U45.F52 U45.F56 U45.F59 U45.G23 U45.G25 U45.G27 U45.G29 U45.G31 U45.G33 U45.G35 U45.G37 U45.G39 U45.G41 U45.G43 U45.G45 U45.G47 U45.G49 U45.G51 U45.G53 U45.G55 U45.G57 U45.H23 U45.J23 U45.K23 U45.K57 U45.L22 U45.M23 U45.M57 U45.P57 U45.U57 U45.W57
+VCCIO_OUT: C621.2 R495.2 R546.2 R555.1 R568.1 U45.A59
+VCCIOA_OUT: R107.2 U45.E20
+VCCPDSW: C240.2 C255.1 R211.1 R212.1 U45.AH10
+VCCRTCEXT: C225.2 U45.AE7
AGND_CPU: PC2.2 PC3.2 PC6.2 PC7.2 PC9.2 PC10.2 PC11.2 PC91.2 PR7.2 PR15.2 PR16.2 PR20.2 PR135.1 PR137.1 PR138.2 PR141.1 PR143.2 PR145.2 PR146.1 PR149.2 PU1.29 PU1.33 PU1.34 PU1.35 PU1.36 PU1.37 PU1.38 PU1.39 PU1.40 PU1.41 PU1.42
AGND_DDR: PC67.2 PC68.2 PC69.2 PR99.2 PR112.1 PR113.1 PR210.2 PU6.7 PU6.21 PU6.22 PU6.23 PU6.24 PU6.25 PU6.26
