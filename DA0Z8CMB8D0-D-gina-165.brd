# Allegro board DA0Z8CMB8D0-D-gina-165.brd (continued)
## Nets (continued)
GND: C1.1 C2.1 C3.1 C4.1 C5.1 C6.1 C7.1 C8.1 C9.1 C10.2 C11.1 C12.1 C13.1 C14.1 C15.2 C16.2 C17.2 C18.1 C19.2 C20.1 C21.2 C22.2 C23.2 C24.2 C25.2 C26.2 C27.1 C28.1 C29.1 C30.1 C31.2 C32.1 C33.1 C34.1 C35.1 C36.2 C37.2 C38.1 C39.1 C40.1 C41.1 C42.2 C43.2 C44.2 C45.2 C46.1 C47.1 C48.1 C49.1 C50.1 C51.2 C52.1 C53.1 C54.1 C55.2 C56.1 C57.1 C58.1 C59.1 C60.1 C61.2 C62.1 C63.2 C64.1 C65.1 C66.1 C67.1 C68.1 C69.1 C70.2 C71.2 C72.2 C73.2 C74.1 C75.2 C76.2 C77.2 C78.2 C79.1 C80.2 C81.1 C82.1 C83.1 C84.2 C85.2 C86.1 C87.1 C88.2 C89.1 C90.2 C91.1 C92.2 C93.1 C94.2 C95.1 C96.1 C97.2 C98.1 C99.1 C100.1 C101.1 C102.1 C103.1 C104.1 C105.2 C106.1 C107.1 C108.2 C109.1 C110.1 C111.1 C112.1 C113.1 C114.1 C115.2 C116.2 C117.1 C118.2 C119.1 C120.2 C121.2 C122.1 C123.1 C124.1 C125.1 C126.1 C127.2 C129.1 C130.1 C131.2 C133.2 C134.2 C135.1 C136.1 C137.1 C139.2 C140.1 C141.2 C142.1 C143.1 C145.1 C146.2 C148.2 C149.1 C150.2 C151.1 C152.1 C154.1 C155.2 C156.2 C157.2 C159.1 C160.2 C161.2 C162.2 C163.2 C165.2 C166.1 C167.1 C168.1 C169.1 C170.1 C171.2 C172.1 C173.1 C174.1 C175.1 C176.1 C177.1 C178.2 C179.1 C180.2 C181.1 C182.2 C183.1 C184.2 C185.2 C186.1 C187.2 C188.2 C189.1 C190.2 C191.1 C192.1 C193.2 C194.2 C195.2 C196.2 C197.1 C198.1 C199.2 C200.1 C201.2 C202.2 C203.2 C204.1 C205.2 C206.1 C207.2 C208.1 C209.2 C210.1 C211.1 C212.2 C213.2 C214.2 C215.1 C216.2 C217.1 C218.1 C219.1 C220.1 C221.2 C222.1 C223.2 C224.1 C225.1 C226.1 C227.2 C228.1 C229.2 C230.1 C231.2 C232.1 C233.1 C234.1 C235.1 C236.2 C237.1 C238.2 C239.2 C241.1 C242.1 C243.2 C244.2 C245.1 C246.1 C247.1 C248.1 C249.1 C250.2 C251.1 C252.2 C253.2 C254.2 C255.2 C256.1 C257.1 C258.2 C259.1 C260.1 C261.1 C262.2 C263.2 C264.1 C265.1 C266.1 C267.1 C268.1 C269.1 C270.2 C271.2 C272.2 C273.1 C274.2 C275.1 C276.1 C277.1 C278.1 C279.1 C280.1 C281.1 C282.1 C283.1 C284.1 C285.1 C286.2 C287.1 C288.1 C289.1 C290.1 C291.2 C292.1 C293.1 C294.1 C295.1 C296.1 C297.1 C298.1 C299.2 C300.1 C301.2 C302.2 C303.1 C306.2 C309.1 C310.2 C311.1 C312.1 C313.2 C314.1 C315.2 C316.1 C317.2 C318.1 C319.1 C320.1 C321.1 C322.1 C323.1 C324.2 C325.1 C326.1 C327.2 C328.2 C329.1 C331.2 C333.1 C334.1 C335.1 C336.1 C337.1 C338.2 C339.2 C340.2 C341.1 C342.1 C343.2 C344.2 C345.2 C346.1 C347.2 C348.1 C349.1 C350.1 C351.2 C352.1 C353.2 C354.2 C355.2 C356.2 C357.2 C358.2 C359.1 C360.1 C361.2 C362.1 C363.1 C364.2 C365.2 C366.2 C367.1 C369.2 C371.2 C372.2 C373.2 C374.1 C375.2 C376.2 C378.2 C379.2 C380.2 C381.1 C382.1 C383.2 C384.2 C385.2 C386.2 C387.1 C388.2 C389.2 C390.1 C391.1 C392.2 C393.2 C394.2 C395.2 C396.2 C397.2 C398.2 C399.2 C400.2 C401.2 C402.2 C403.2 C404.2 C406.2 C407.2 C408.2 C409.1 C410.2 C411.2 C412.2 C413.2 C414.2 C415.2 C416.2 C417.2 C418.1 C420.2 C421.2 C422.2 C423.2 C424.2 C425.1 C426.1 C427.2 C428.2 C429.2 C431.1 C432.2 C433.2 C434.2 C435.2 C436.2 C437.2 C438.2 C439.1 C440.2 C441.2 C442.2 C443.2 C444.2 C445.2 C446.2 C447.2 C448.2 C449.2 C450.2 C451.2 C452.2 C453.2 C454.2 C455.2 C456.2 C457.2 C458.2 C459.2 C460.2 C461.1 C462.1 C463.1 C464.1 C465.1 C466.2 C467.2 C468.1 C470.1 C471.2 C472.2 C473.2 C474.1 C475.1 C476.1 C477.2 C481.1 C482.2 C483.2 C484.2 C485.1 C487.2 C489.2 C491.2 C492.2 C493.2 C494.2 C495.2 C496.2 C497.2 C498.1 C499.2 C502.2 C503.2 C509.2 C512.2 C513.2 C514.2 C516.2 C517.2 C518.2 C519.2 C520.2 C521.1 C522.1 C523.1 C524.1 C525.1 C526.1 C527.1 C528.2 C529.2 C530.2 C531.1 C532.1 C533.1 C534.1 C535.1 C536.2 C537.2 C538.2 C539.2 C540.2 C541.2 C542.2 C543.1 C544.2 C545.2 C546.2 C547.1 C548.1 C549.2 C550.1 C551.1 C552.1 C561.1 C563.1 C564.1 C565.1 C566.1 C567.2 C568.1 C569.1 C570.1 C571.2 C572.2 C573.1 C576.2 C577.2 C578.1 C579.1 C580.2 C581.1 C582.1 C583.1 C584.1 C585.2 C586.2 C587.1 C588.2 C589.2 C590.1 C591.2 C592.1 C593.1 C594.1 C595.2 C596.1 C601.2 C602.1 C603.1 C604.2 C605.2 C606.1 C607.1 C608.2 C609.1 C610.1 C611.1 C618.1 C619.1 C620.1 C621.1 C622.1 C623.1 C628.1 C629.1 C630.2 C631.2 C634.2 C635.2 C636.2 C639.1 C640.2 C641.1 C642.1 C643.2 C644.2 C645.1 C646.2 C647.2 C648.2 C649.1 C650.2 C651.2 C652.1 C653.1 C654.2 C655.2 C656.1 C657.1 C658.1 C659.1 C660.1 C661.1 C662.2 C663.2 C664.1 C665.1 C674.2 C675.2 C676.1 C677.1 C678.1 C679.1 C682.2 C683.1 C688.1 C689.1 C690.1 C691.2 C692.2 C693.2 C694.2 C695.2 C696.2 C697.2 C698.2 C699.1 C700.2 C701.1 C702.2 C703.2 C704.2 C705.1 C706.2 C707.2 C708.2 C709.2 C710.2 C711.2 C712.2 C713.2 C714.2 C715.2 C716.2 C717.2 C718.2 C719.2 C720.2 C721.1 C722.2 C723.2 C724.2 C725.2 C726.2 C727.2 C728.2 C729.2 C730.2 C731.2 C732.2 C733.2 C734.2 C735.2 C736.2 C737.1 C738.2 C739.2 C740.2 C741.2 C742.2 C743.2 C744.2 C745.2 C746.2 C747.2 C748.2 C749.2 C750.2 C751.2 C752.2 C753.2 C754.2 C755.2 C756.1 C757.2 C758.2 C759.2 C760.1 C761.2 C762.2 C763.2 C764.2 C765.2 C766.1 C767.2 C768.2 C769.2 C770.2 C771.1 C772.1 C773.1 C774.1 C775.1 C776.2 C777.2 C778.2 C779.2 C781.1 CN1.9 CN1.10 CN1.11 CN1.12 CN2.2 CN2.5 CN2.8 CN2.11 CN2.17 CN2.20 CN2.21 CN2.22 CN2.23 CN3.5 CN3.6 CN3.7 CN3.8 CN3.10 CN3.16 CN3.17 CN4.3 CN4.5 CN4.6 CN5.4 CN5.5 CN5.6 CN5.7 CN5.8 CN6.5 CN6.6 CN6.9 CN6.13 CN6.14 CN7.9 CN7.12 CN7.15 CN7.18 CN7.21 CN7.24 CN7.29 CN7.41 CN7.42 CN7.43 CN7.44 CN8.4 CN8.7 CN8.10 CN8.11 CN8.12 CN8.13 CN9.2 CN10.3 CN10.5 CN10.6 CN11.1 CN11.4 CN11.7 CN11.10 CN11.11 CN11.14 CN11.15 CN11.16 CN11.17 CN12.1 CN12.7 CN12.18 CN12.33 CN12.39 CN12.45 CN12.51 CN12.57 CN12.63 CN12.69 CN12.75 CN12.76 CN12.77 CN13.4 CN13.7 CN13.10 CN13.11 CN13.12 CN13.13 CN14.8 CN14.10 CN14.12 CN14.14 CN15.27 CN15.28 CN16.1 CN16.5 CN16.6 CN17.3 CN17.6 CN17.7 CN17.8 CN18.5 CN18.6 CN18.7 CN18.8 CN19.3 CN19.6 CN19.12 CN19.13 CN20.1 CN20.5 CN20.6 CN22.5 CN22.6 CP1.1 CP1.3 CP1.5 CP1.7 CP2.1 CP2.3 CP2.5 CP2.7 CP3.1 CP3.3 CP3.5 CP3.7 CP4.1 CP4.3 CP4.5 CP4.7 CP5.1 CP5.3 CP5.5 CP5.7 CP6.1 CP6.3 CP6.5 CP6.7 D1.1 D3.2 D4.2 D6.2 D7.2 D8.2 D9.2 D10.2 D11.2 D12.2 D13.2 D21.2 D22.2 D27.1 D29.2 D30.2 D31.2 D32.2 D35.2 HOLE4.1 HOLE5.1 HOLE5.2 HOLE5.3 HOLE5.4 HOLE5.5 HOLE5.6 HOLE5.7 HOLE5.8 HOLE5.9 HOLE6.1(PIN1) HOLE6.2(PIN2) HOLE6.3(PIN3) HOLE6.4(PIN4) HOLE6.5(PIN5) HOLE6.6(PIN6) HOLE6.7(PIN7) HOLE6.8(PIN8) HOLE6.9(PIN9) HOLE7.1(PIN1) HOLE7.2(PIN2) HOLE7.3(PIN3) HOLE7.4(PIN4) HOLE7.5(PIN5) HOLE7.6(PIN6) HOLE7.7(PIN7) HOLE7.8(PIN8) HOLE7.9(PIN9) HOLE8.1(PIN1) HOLE8.2(PIN2) HOLE8.3(PIN3) HOLE8.4(PIN4) HOLE8.5(PIN5) HOLE8.6(PIN6) HOLE8.7(PIN7) HOLE8.8(PIN8) HOLE8.9(PIN9) HOLE9.1(PIN1) HOLE9.2(PIN2) HOLE9.3(PIN3) HOLE9.4(PIN4) HOLE9.5(PIN5) HOLE9.6(PIN6) HOLE9.7(PIN7) HOLE9.8(PIN8) HOLE9.9(PIN9) HOLE10.1(PIN1) HOLE10.2(PIN2) HOLE10.3(PIN3) HOLE10.4(PIN4) HOLE10.5(PIN5) HOLE10.6(PIN6) HOLE10.7(PIN7) HOLE10.8(PIN8) HOLE10.9(PIN9) HOLE11.1 HOLE11.2 HOLE11.3 HOLE11.4 HOLE11.5 HOLE11.6 HOLE11.7 HOLE11.8 HOLE11.9 HOLE12.1 HOLE13.1(PIN1) HOLE13.2(PIN2) HOLE13.3(PIN3) HOLE13.4(PIN4) HOLE13.5(PIN5) HOLE13.6(PIN6) HOLE13.7(PIN7) HOLE13.8(PIN8) HOLE13.9(PIN9) HOLE14.1(PIN1) HOLE14.2(PIN2) HOLE14.3(PIN3) HOLE14.4(PIN4) HOLE14.5(PIN5) HOLE14.6(PIN6) HOLE14.7(PIN7) HOLE14.8(PIN8) HOLE14.9(PIN9) HOLE15.1(PIN1) HOLE16.1(PIN1) HOLE16.2(PIN2) HOLE16.3(PIN3) HOLE16.4(PIN4) HOLE16.5(PIN5) HOLE16.6(PIN6) HOLE16.7(PIN7) HOLE16.8(PIN8) HOLE16.9(PIN9) HOLE17.1(PIN1) HOLE17.2(PIN2) HOLE17.3(PIN3) HOLE17.4(PIN4) HOLE17.5(PIN5) HOLE17.6(PIN6) HOLE17.7(PIN7) HOLE17.8(PIN8) HOLE17.9(PIN9) HOLE18.1 HOLE19.1 HOLE20.1(PIN1) HOLE20.2(PIN2) HOLE20.3(PIN3) HOLE20.4(PIN4) HOLE20.5(PIN5) HOLE20.6(PIN6) HOLE20.7(PIN7) HOLE20.8(PIN8) HOLE20.9(PIN9) HOLE21.1(PIN1) HOLE21.2(PIN2) HOLE21.3(PIN3) HOLE21.4(PIN4) HOLE21.5(PIN5) HOLE21.6(PIN6) HOLE21.7(PIN7) HOLE21.8(PIN8) HOLE21.9(PIN9) J2.2 JDIM1.2 JDIM1.3 JDIM1.8 JDIM1.9 JDIM1.11 JDIM1.13 JDIM1.14 JDIM1.19 JDIM1.20 JDIM1.25 JDIM1.26 JDIM1.28 JDIM1.31 JDIM1.32 JDIM1.37 JDIM1.38 JDIM1.43 JDIM1.44 JDIM1.46 JDIM1.48 JDIM1.49 JDIM1.54 JDIM1.55 JDIM1.60 JDIM1.61 JDIM1.63 JDIM1.65 JDIM1.66 JDIM1.71 JDIM1.72 JDIM1.127 JDIM1.128 JDIM1.133 JDIM1.134 JDIM1.136 JDIM1.138 JDIM1.139 JDIM1.144 JDIM1.145 JDIM1.150 JDIM1.151 JDIM1.153 JDIM1.155 JDIM1.156 JDIM1.161 JDIM1.162 JDIM1.167 JDIM1.168 JDIM1.170 JDIM1.172 JDIM1.173 JDIM1.178 JDIM1.179 JDIM1.184 JDIM1.185 JDIM1.187 JDIM1.189 JDIM1.190 JDIM1.195 JDIM1.196 JDIM1.205 JDIM1.206 L19.1 PAD1.1(PIN1) PAD1.2(PIN2) PAD1.3(PIN3) PAD1.4(PIN4) PAD1.5(PIN5) PAD1.6(PIN6) PC5.1 PC8.2 PC12.1 PC13.1 PC14.2 PC15.1 PC16.2 PC18.1 PC19.1 PC20.1 PC21.1 PC22.1 PC23.2 PC24.1 PC25.2 PC26.2 PC27.2 PC28.2 PC29.2 PC30.2 PC32.1 PC33.1 PC34.1 PC35.2 PC37.2 PC38.1 PC39.1 PC41.1 PC43.2 PC44.1 PC47.2 PC48.1 PC49.1 PC50.2 PC51.2 PC52.2 PC53.1 PC54.1 PC55.2 PC58.1 PC59.2 PC62.2 PC63.2 PC64.1 PC65.1 PC66.2 PC70.1 PC71.1 PC72.1 PC73.2 PC75.2 PC76.2 PC77.2 PC78.1 PC79.1 PC80.2 PC81.2 PC82.1 PC83.1 PC84.1 PC85.1 PC86.2 PC87.2 PC88.2 PC89.1 PC90.1 PC92.1 PC94.2 PC96.2 PC97.2 PC98.2 PC99.2 PC100.1 PC101.1 PC102.1 PC103.1 PC104.2 PC105.2 PC106.1 PC107.1 PC108.2 PC109.2 PC110.2 PC111.1 PC112.2 PC113.1 PC114.2 PC115.2 PC116.1 PC117.2 PC118.1 PC119.1 PC120.1 PC122.2 PC123.1 PC124.1 PC126.2 PC127.2 PC128.1 PC129.2 PC130.1 PC131.1 PC132.1 PC134.2 PC135.1 PC136.2 PC137.2 PC138.1 PC139.2 PC140.1 PC141.1 PC142.1 PC143.2 PC144.2 PC145.2 PC146.2 PC147.1 PC148.2 PC149.2 PD3.2 PD4.2 PD9.2 PJ1.3 PJ1.4 PJ2.1 PJ2.2 PJ2.9 PJ2.10 PQ1.1 PQ2.1 PQ3.1 PQ6.1 PQ7.1 PQ8.1 PQ11.4 PQ13.1 PQ13.4 PQ14.1 PQ16.1 PQ18.1 PQ19.1 PQ20.1 PQ21.1 PQ23.1 PQ24.1 PQ25.1 PQ26.1 PQ27.1 PQ28.1 PQ29.1 PQ30.1 PQ30.2 PQ30.3 PQ33.1 PQ34.1 PQ35.1 PQ37.1 PQ39.1 PQ39.2 PQ39.3 PQ40.1 PQ40.2 PQ40.3 PQ41.1 PQ41.2 PQ41.3 PQ42.1 PQ43.1 PQ48.1 PQ48.2 PQ48.3 PQ49.1 PQ49.2 PQ49.3 PQ51.1 PQ51.2 PQ51.3 PQ52.5 PQ52.6 PQ52.7 PR25.2 PR27.2 PR32.1 PR35.1 PR36.2 PR38.2 PR45.2 PR51.2 PR63.2 PR64.2 PR67.2 PR68.1 PR70.1 PR103.1 PR109.2 PR119.2 PR125.2 PR128.1 PR135.2 PR153.2 PR155.2 PR165.1 PR168.2 PR169.1 PR172.1 PR176.1 PR194.1 PR196.1 PR198.2 PR203.1 PR210.1 PR213.2 PR215.2 PU2.11 PU2.12 PU2.13 PU2.14 PU2.15 PU2.16 PU3.22 PU3.25 PU4.11 PU4.12 PU4.13 PU4.14 PU4.15 PU4.16 PU5.21 PU5.22 PU5.23 PU5.24 PU5.25 PU5.26 PU6.4 PU6.10 PU7.3 PU7.9 PU8.4 PU8.5 PU8.6 PU9.14 PU9.21 PU9.22 PU9.23 PU9.24 PU9.25 PU10.3 PU10.4 PU10.5 PU10.17 PU10.18 PU10.19 PU10.20 PU10.21 PU10.22 Q1.1 Q4.1 Q5.1 Q6.1 Q7.1 Q16.1 Q18.1 Q18.4 Q24.1 Q29.1 Q31.1 Q33.1 Q34.1 Q36.2 Q37.2 Q39.1 R5.1 R8.2 R9.1 R11.2 R12.2 R13.2 R16.1 R18.1 R30.1 R34.2 R37.2 R38.1 R40.1 R43.2 R46.2 R47.1 R48.1 R51.1 R52.1 R53.1 R54.1 R58.1 R61.2 R62.2 R66.1 R69.1 R86.1 R89.2 R93.2 R101.2 R116.2 R118.2 R120.2 R121.2 R123.1 R125.2 R126.2 R129.1 R135.2 R136.2 R140.2 R142.2 R143.2 R149.1 R152.1 R153.2 R161.1 R177.1 R179.1 R191.2 R194.1 R197.1 R198.2 R207.2 R216.2 R225.1 R227.2 R233.1 R247.2 R272.1 R283.1 R284.2 R287.2 R290.2 R304.1 R312.2 R314.2 R323.2 R327.1 R335.2 R341.2 R342.1 R343.1 R347.2 R356.1 R357.1 R366.1 R367.1 R374.1 R378.1 R379.1 R381.1 R383.2 R396.2 R400.1 R412.1 R413.2 R414.2 R417.2 R427.2 R436.1 R442.1 R444.1 R456.1 R457.1 R459.1 R462.1 R465.1 R466.2 R468.2 R476.1 R477.1 R478.1 R479.1 R480.1 R484.1 R485.1 R487.1 R491.2 R493.1 R498.2 R503.1 R504.1 R505.1 R508.2 R511.1 R516.2 R532.2 R535.1 R537.2 R541.2 R547.2 R553.2 R556.1 R557.2 R559.2 R562.2 R564.1 R567.2 R571.2 R585.2 R588.2 R589.2 R590.2 R592.2 R595.2 R602.1 R603.2 R604.1 R607.2 R611.2 R612.2 R613.2 R614.1 R623.1 R625.2 R626.2 R628.2 R631.2 R632.2 R633.1 R634.2 R638.2 R639.1 R640.1 R642.2 R644.1 R645.2 R647.2 R654.1 R660.2 R662.1 R663.2 R664.1 R668.2 R672.2 R674.1 R680.2 R687.2 R688.2 R720.2 R745.1 R752.1 R756.1 R757.1 R759.1 R763.1 R768.1 R770.1 R773.1 R778.1 R781.1 R789.2 R792.2 R796.2 RV1.2 SW1.3 SW1.5 SW1.6 SW2.2 SW2.5 SW2.6 U2.3 U3.3 U5.1 U5.3 U6.1 U6.3 U10.3 U11.A9 U11.B1 U11.B3 U11.B9 U11.D1 U11.D8 U11.E1 U11.E2 U11.E8 U11.F9 U11.G1 U11.G8 U11.G9 U11.J2 U11.J8 U11.M1 U11.M9 U11.P1 U11.P9 U11.T1 U11.T9 U12.A9 U12.B1 U12.B3 U12.B9 U12.D1 U12.D8 U12.E1 U12.E2 U12.E8 U12.F9 U12.G1 U12.G8 U12.G9 U12.J2 U12.J8 U12.M1 U12.M9 U12.P1 U12.P9 U12.T1 U12.T9 U13.A9 U13.B1 U13.B3 U13.B9 U13.D1 U13.D8 U13.E1 U13.E2 U13.E8 U13.F9 U13.G1 U13.G8 U13.G9 U13.J2 U13.J8 U13.M1 U13.M9 U13.P1 U13.P9 U13.T1 U13.T9 U14.4 U15.3 U16.A9 U16.B1 U16.B3 U16.B9 U16.D1 U16.D8 U16.E1 U16.E2 U16.E8 U16.F9 U16.G1 U16.G8 U16.G9 U16.J2 U16.J8 U16.M1 U16.M9 U16.P1 U16.P9 U16.T1 U16.T9 U17.7 U17.15 U18.2 U19.2 U20.3 U21.3 U22.3 U23.3 U24.24 U24.32 U24.65 U25.9 U26.3 U27.3 U28.A9 U28.B1 U28.B3 U28.B9 U28.D1 U28.D3 U28.D8 U28.E1 U28.E2 U28.E7 U28.E8 U28.F9 U28.G1 U28.G8 U28.G9 U28.J2 U28.J8 U28.M1 U28.M9 U28.P1 U28.P9 U28.T1 U28.T9 U29.A9 U29.B1 U29.B3 U29.B9 U29.D1 U29.D3 U29.D8 U29.E1 U29.E2 U29.E7 U29.E8 U29.F9 U29.G1 U29.G8 U29.G9 U29.J2 U29.J8 U29.M1 U29.M9 U29.P1 U29.P9 U29.T1 U29.T9 U30.A9 U30.B1 U30.B3 U30.B9 U30.D1 U30.D3 U30.D8 U30.E1 U30.E2 U30.E7 U30.E8 U30.F9 U30.G1 U30.G8 U30.G9 U30.J2 U30.J8 U30.M1 U30.M9 U30.P1 U30.P9 U30.T1 U30.T9 U31.A9 U31.B1 U31.B3 U31.B9 U31.D1 U31.D3 U31.D8 U31.E1 U31.E2 U31.E7 U31.E8 U31.F9 U31.G1 U31.G8 U31.G9 U31.J2 U31.J8 U31.M1 U31.M9 U31.P1 U31.P9 U31.T1 U31.T9 U32.1 U32.27 U32.49 U32.91 U32.113 U32.122 U33.2 U34.4 U34.49 U38.A9 U38.B1 U38.B3 U38.B9 U38.D1 U38.D8 U38.E1 U38.E2 U38.E8 U38.F9 U38.G1 U38.G8 U38.G9 U38.J2 U38.J8 U38.M1 U38.M9 U38.P1 U38.P9 U38.T1 U38.T9 U39.A9 U39.B1 U39.B3 U39.B9 U39.D1 U39.D8 U39.E1 U39.E2 U39.E8 U39.F9 U39.G1 U39.G8 U39.G9 U39.J2 U39.J8 U39.M1 U39.M9 U39.P1 U39.P9 U39.T1 U39.T9 U40.49 U41.A9 U41.B1 U41.B3 U41.B9 U41.D1 U41.D8 U41.E1 U41.E2 U41.E8 U41.F9 U41.G1 U41.G8 U41.G9 U41.J2 U41.J8 U41.M1 U41.M9 U41.P1 U41.P9 U41.T1 U41.T9 U42.3 U43.A2 U43.A26 U43.AA7 U43.AB7 U43.AB11 U43.AB14 U43.AB17 U43.AB20 U43.AB24 U43.AC2 U43.AC5 U43.AC8 U43.AC22 U43.AC26 U43.AD12 U43.AD13 U43.AD15 U43.AD16 U43.AD18 U43.AD19 U43.AD21 U43.AD22 U43.AE11 U43.AE14 U43.AE17 U43.AE20 U43.AF1 U43.AF5 U43.AF8 U43.AF11 U43.AF14 U43.AF17 U43.AF20 U43.AF23 U43.AG2 U43.AG26 U43.B1 U43.B5 U43.B8 U43.B11 U43.B14 U43.B17 U43.B20 U43.B23 U43.B27 U43.E2 U43.E5 U43.E8 U43.E11 U43.E14 U43.E17 U43.E20 U43.E22 U43.E25 U43.H2 U43.H5 U43.H23 U43.H25 U43.K11 U43.K13 U43.K15 U43.K17 U43.L2 U43.L5 U43.L10 U43.L12 U43.L14 U43.L16 U43.L18 U43.L23 U43.L25 U43.M11 U43.M13 U43.M15 U43.M17 U43.N10 U43.N12 U43.N14 U43.N16 U43.N18 U43.P2 U43.P5 U43.P11 U43.P13 U43.P15 U43.P17 U43.P23 U43.P26 U43.R10 U43.R12 U43.R14 U43.R16 U43.R18 U43.T11 U43.T13 U43.T15 U43.T17 U43.U2 U43.U5 U43.U10 U43.U12 U43.U14 U43.U16 U43.U18 U43.U23 U43.U26 U43.V11 U43.V13 U43.V15 U43.V17 U43.Y2 U43.Y5 U43.Y23 U43.Y26 U44.A9 U44.B1 U44.B3 U44.B9 U44.D1 U44.D8 U44.E1 U44.E2 U44.E8 U44.F9 U44.G1 U44.G8 U44.G9 U44.J2 U44.J8 U44.M1 U44.M9 U44.P1 U44.P9 U44.T1 U44.T9 U45.A11 U45.A14 U45.A18 U45.A24 U45.A28 U45.A32 U45.A36 U45.A40 U45.A44 U45.A48 U45.A52 U45.A56 U45.AA1 U45.AA58 U45.AB7 U45.AB10 U45.AB20 U45.AB22 U45.AC61 U45.AD3 U45.AD21 U45.AD63 U45.AE5 U45.AE10 U45.AE58 U45.AF11 U45.AF12 U45.AF14 U45.AF15 U45.AF17 U45.AF18 U45.AG1 U45.AG11 U45.AG21 U45.AG23 U45.AG60 U45.AG61 U45.AG62 U45.AG63 U45.AH16 U45.AH17 U45.AH19 U45.AH20 U45.AH22 U45.AH24 U45.AH28 U45.AH30 U45.AH32 U45.AH34 U45.AH36 U45.AH38 U45.AH40 U45.AH42 U45.AH44 U45.AH46 U45.AH49 U45.AH51 U45.AH53 U45.AH55 U45.AH57 U45.AJ13 U45.AJ14 U45.AJ23 U45.AJ25 U45.AJ27 U45.AJ29 U45.AJ35 U45.AJ39 U45.AJ41 U45.AJ43 U45.AJ45 U45.AJ47 U45.AJ50 U45.AJ52 U45.AJ54 U45.AJ56 U45.AJ58 U45.AJ60 U45.AJ63 U45.AK3 U45.AK23 U45.AK52 U45.AL10 U45.AL13 U45.AL17 U45.AL20 U45.AL22 U45.AL23 U45.AL26 U45.AL29 U45.AL31 U45.AL33 U45.AL36 U45.AL39 U45.AL40 U45.AL45 U45.AL46 U45.AL51 U45.AL52 U45.AL54 U45.AL57 U45.AL60 U45.AL61 U45.AM1 U45.AM17 U45.AM23 U45.AM31 U45.AM52 U45.AN7 U45.AN17 U45.AN23 U45.AN31 U45.AN32 U45.AN35 U45.AN36 U45.AN39 U45.AN40 U45.AN42 U45.AN43 U45.AN45 U45.AN46 U45.AN48 U45.AN49 U45.AN51 U45.AN52 U45.AN60 U45.AN63 U45.AP3 U45.AP10 U45.AP17 U45.AP20 U45.AP22 U45.AP23 U45.AP26 U45.AP29 U45.AP31 U45.AP38 U45.AP39 U45.AP48 U45.AP52 U45.AP54 U45.AP57 U45.AR5 U45.AR11 U45.AR15 U45.AR17 U45.AR23 U45.AR31 U45.AR33 U45.AR39 U45.AR43 U45.AR49 U45.AR52 U45.AT13 U45.AT35 U45.AT37 U45.AT40 U45.AT42 U45.AT43 U45.AT46 U45.AT49 U45.AT61 U45.AT62 U45.AT63 U45.AU1 U45.AU16 U45.AU18 U45.AU20 U45.AU22 U45.AU24 U45.AU26 U45.AU28 U45.AU30 U45.AU33 U45.AU51 U45.AU53 U45.AU55 U45.AU57 U45.AU59 U45.AV8 U45.AV14 U45.AV16 U45.AV20 U45.AV24 U45.AV28 U45.AV33 U45.AV34 U45.AV36 U45.AV39 U45.AV41 U45.AV43 U45.AV46 U45.AV49 U45.AV51 U45.AV55 U45.AV59 U45.AW4 U45.AW16 U45.AW24 U45.AW33 U45.AW35 U45.AW37 U45.AW40 U45.AW42 U45.AW44 U45.AW47 U45.AW50 U45.AW51 U45.AW59 U45.AW60 U45.AY4 U45.AY6 U45.AY11 U45.AY16 U45.AY18 U45.AY22 U45.AY24 U45.AY26 U45.AY30 U45.AY33 U45.AY51 U45.AY53 U45.AY57 U45.AY59 U45.B4 U45.B20 U45.B24 U45.B26 U45.B28 U45.B32 U45.B36 U45.B40 U45.B44 U45.B48 U45.B52 U45.B56 U45.B60 U45.C11 U45.C14 U45.C18 U45.C20 U45.C25 U45.C27 U45.C38 U45.C39 U45.C57 U45.D2 U45.D5 U45.D8 U45.D12 U45.D14 U45.D18 U45.D21 U45.D23 U45.D25 U45.D26 U45.D27 U45.D29 U45.D30 U45.D31 U45.D33 U45.D34 U45.D35 U45.D37 U45.D38 U45.D39 U45.D41 U45.D42 U45.D43 U45.D45 U45.D46 U45.D47 U45.D49 U45.D50 U45.D51 U45.D53 U45.D54 U45.D55 U45.D57 U45.D59 U45.D62 U45.D63 U45.E11 U45.E17 U45.F20 U45.F26 U45.F30 U45.F34 U45.F38 U45.F42 U45.F46 U45.F50 U45.F54 U45.F58 U45.F61 U45.G3 U45.G5 U45.G6 U45.G8 U45.G18 U45.G22 U45.H13 U45.H17 U45.H57 U45.J10 U45.J22 U45.J59 U45.J63 U45.K1 U45.K12 U45.L7 U45.L13 U45.L15 U45.L17 U45.L18 U45.L20 U45.L58 U45.L61 U45.M22 U45.N3 U45.N10 U45.N21 U45.P22 U45.P59 U45.P62 U45.P63 U45.R8 U45.R10 U45.R22 U45.T1 U45.T58 U45.U9 U45.U20 U45.U22 U45.U61 U45.V3 U45.V7 U45.V10 U45.V23 U45.V58 U45.W20 U45.W22 U45.Y10 U45.Y59 U45.Y63 U46.2 U46.5 U47.3 U48.2 U49.2 U50.A9 U50.B1 U50.B3 U50.B9 U50.D1 U50.D3 U50.D8 U50.E1 U50.E2 U50.E7 U50.E8 U50.F9 U50.G1 U50.G8 U50.G9 U50.J2 U50.J8 U50.M1 U50.M9 U50.P1 U50.P9 U50.T1 U50.T9 U51.A9 U51.B1 U51.B3 U51.B9 U51.D1 U51.D3 U51.D8 U51.E1 U51.E2 U51.E7 U51.E8 U51.F9 U51.G1 U51.G8 U51.G9 U51.J2 U51.J8 U51.M1 U51.M9 U51.P1 U51.P9 U51.T1 U51.T9 U52.A9 U52.B1 U52.B3 U52.B9 U52.D1 U52.D3 U52.D8 U52.E1 U52.E2 U52.E7 U52.E8 U52.F9 U52.G1 U52.G8 U52.G9 U52.J2 U52.J8 U52.M1 U52.M9 U52.P1 U52.P9 U52.T1 U52.T9 U53.A9 U53.B1 U53.B3 U53.B9 U53.D1 U53.D3 U53.D8 U53.E1 U53.E2 U53.E7 U53.E8 U53.F9 U53.G1 U53.G8 U53.G9 U53.J2 U53.J8 U53.M1 U53.M9 U53.P1 U53.P9 U53.T1 U53.T9 U54.5 U54.10 U54.12 U54.13 U54.15 U54.16 U55.4 U56.4 U56.11 U56.18 U56.25 Y1.2 Y1.4 Y2.2 Y2.4 Y3.2 Y3.4 Y4.2 Y4.4
VCC_SENSE: PC87.1 PR5.2 PR127.1 R526.2
VCC_SENSE_R: R522.2 R526.1 U45.E63
VCCRTC_3: Q42.3 R795.2
VCCRTC_4: R795.1 R797.2
VCCST_PWRGD: C622.2 R497.1 R499.1 R521.1 U15.2 U45.B59
VCCST_PWRGD_EN: R518.1 R519.1 U42.2
VCCST_PWRGD_R: R497.2 U42.4
VCCST_PWRGD_XDP: R254.2 TP86.1
VDD10: C296.2 C297.2 C303.2 C329.2 C335.2 C342.2 C352.2 L17.2 R286.1 U24.3 U24.8 U24.41 U24.52 U24.61
VDD33: C293.2 C294.2 C295.2 C298.2 C309.2 C311.2 Q27.2 R253.1 R291.2 R292.2 R295.2 R303.1 R319.1 U24.11 U24.58 U24.63 U24.64
VDD33_18: C314.2 R285.1 U24.53
VDDREG: C336.2 C341.2 R320.1 U24.46 U24.47
VIN: C258.1 C259.2 PC5.2 PC15.2 PC16.1 PC32.2 PC33.2 PC34.2 PC43.1 PC48.2 PC50.1 PC54.2 PC89.2 PC90.2 PC92.2 PC105.1 PC106.2 PC107.2 PC108.1 PC109.1 PC111.2 PC112.1 PC114.1 PC115.1 PC117.1 PC118.2 PC120.2 PC122.1 PC123.2 PC126.1 PC139.1 PC140.2 PC144.1 PD8.2 PQ12.5 PQ17.5 PQ22.1 PQ22.2 PQ22.3 PQ31.5 PQ38.5 PQ44.5 PQ46.5 PQ50.5 PQ52.2 PR19.1 PR22.1 PR26.1 PR39.1 PR52.1 PR69.2 PR95.1 PR115.1 PR121.1 PR124.1 PR177.2 PR192.2 PR204.1 PU7.5 R200.1 R205.1
VSS_SENSE: PC88.1 PR4.2 PR128.2 R530.2
VSS_SENSE_R: R530.1 R532.1 U45.E62
1.5GFX_DRVH: PQ31.4 PU2.9
1.5GFX_DRVL: PQ30.4 PU2.6
1.5GFX_EN: PC101.2 PR34.2 PU2.3
1.5GFX_FB: PR153.1 PR154.2 PU2.4
1.5GFX_SW: PC17.2 PL2.1 PQ30.5 PQ31.1 PQ31.2 PQ31.3 PR29.1 PU2.8
1.5GFX_TRIP: PR35.2 PU2.2
1.5GFX_TST: PR32.2 PU2.5
1.5GFX_VBST: PR30.2 PU2.10
2ND_MBCLK: Q12.6 Q19.3 R242.1 R300.1 U32.115
2ND_MBDATA: Q12.3 Q19.6 R243.1 R299.1 U32.116
27M_CRT_IN: C593.2 U40.34 Y2.3
27M_CRT_OUT: C594.2 U40.33 Y2.1
27M_XTAL_IN_R: C656.2 U43.C11 Y4.3
27M_XTAL_OUT: C658.2 U43.B10 Y4.1
1642_BOOT1: PR56.1 PU3.1
1642_BOOT2: PR50.1 PU3.18
1642_COMP: PC44.2 PR75.2 PU3.12
1642_EN: PR66.1 PR70.2 PR166.1 PR170.1 PU3.3
1642_FB: PC46.2 PR78.2 PU3.11
1642_FBRTN: PC45.2 PQ15.1 PR176.2 PR179.2 PR180.2 PU3.10
1642_ISEN1: PR62.1 PU3.15
1642_LGATE1: PQ40.4 PU3.23
1642_LGATE2: PQ39.4 PU3.20
1642_PGOOD: PR57.1 PR167.1 PU3.16
1642_PHASE1: PC40.1 PL3.2 PQ38.1 PQ38.2 PQ38.3 PQ40.5 PR41.1 PR46.1 PU3.24
1642_PHASE2: PC36.1 PL4.2 PQ12.1 PQ12.2 PQ12.3 PQ39.5 PR42.1 PR47.1 PU3.19
1642_PSI: PR174.1 PR178.1 PU3.4
1642_PVCC: PC38.2 PR62.2 PR164.1 PU3.21
1642_REFADJ: PR76.2 PU3.6
1642_REFIN: PR181.1 PR182.2 PU3.7
1642_TON: PC119.2 PR177.1 PU3.9
1642_TSNS: PR168.1 PR169.2 PR173.1 PU3.13
1642_UGATE1: PQ38.4 PR46.2 PU3.2
1642_UGATE2: PQ12.4 PR47.2 PU3.17
1642_VID: PR74.1 PU3.5
1642_VREF: PC47.1 PR77.1 PR173.2 PU3.8
24707_LX: PC125.1 PL7.2 PQ17.1 PQ17.2 PQ17.3 PQ48.5 PR93.1 PU9.19
24737_ACDET: PR189.2 PR196.2 PU9.6
24737_ACN: PC55.1 PC121.2 PR192.1 PU9.1
24737_ACP: PC53.2 PC121.1 PR188.1 PU9.2
24737_BM#: PQ21.2 PR94.1 PU9.11
24737_BST: PR201.2 PU9.17
24737_CMPIN: PR88.2 PR89.1 PR194.2 PU9.4
24737_CMPOUT: PQ18.2 PR89.2 PR90.2 PR193.1 PU9.3
24737_DH: PQ17.4 PU9.18
24737_DL: PQ48.4 PU9.15
24737_ILIM: PC130.2 PR97.1 PR102.2 PR203.2 PU9.10
24737_REGN: PC129.1 PD5.2 PU9.16
24737_SRN: PC132.2 PC133.1 PR205.1 PR209.1
24737_SRP: PC131.2 PC133.2 PR206.1 PR208.1
24737_VCC: PC58.2 PR73.2 PU9.20
51216_DRVH: PQ52.1 PU6.14
51216_DRVL: PQ52.8 PU6.11
51216_MODE: PR113.2 PU6.19
51216_REF: PC67.1 PR104.1 PU6.6
51216_REFIN: PC69.1 PR99.1 PR104.2 PU6.8
51216_S3: PR110.2 PR211.2 PR212.2 PU6.17
51216_S5: PR111.2 PR211.1 PU6.16
51216_SW: PC74.2 PL8.1 PQ52.9 PR105.1 PU6.13
51216_TRIP: PR112.2 PU6.18
51216_VBST: PR108.1 PU6.15
51225_CS1: PR82.2 PU5.1
51225_CS2: PR195.2 PU5.5
51225_DH1: PQ50.4 PU5.16
51225_DH2: PQ46.4 PU5.10
51225_DL1: PQ51.4 PU5.15
51225_DL2: PQ49.4 PU5.11
51225_EN1: PR197.1 PU5.20
51225_FB1: PR186.1 PR187.1 PU5.2
51225_FB2: PR80.2 PR190.1 PU5.4
51225_SW1: PC57.2 PL9.2 PQ50.1 PQ50.2 PQ50.3 PQ51.5 PR106.1 PU5.18
51225_SW2: PC56.1 PL6.1 PQ46.1 PQ46.2 PQ46.3 PQ49.5 PR83.1 PU5.8
51225_VBST1: PR92.2 PU5.17
51225_VBST2: PR91.1 PU5.9
51225_VCLK: PR86.1 PU5.19
51225_VIN: PC64.2 PR204.2 PU5.12
51624_B-RAMP: PR14.2 PR143.1 PU1.11
51624_COMP: PC4.2 PR1.1 PR126.2 PR131.2 PU1.26
51624_CSN1: PC7.1 PC95.2 PR13.2 PR140.2 PR150.1 PU1.18
51624_CSN2: PR138.1 PU1.19
51624_CSP1: PC9.1 PC95.1 PR12.2 PR140.1 PR151.1 PU1.17
51624_CSP2: PR8.1 PU1.20
51624_DROOP: PC1.1 PC4.1 PR131.1 PU1.25
51624_F-IMAX: PR16.1 PR142.2 PU1.10
51624_GFB: PR4.1 PU1.23
51624_IMON: PC10.1 PR139.1 PU1.13
51624_NC: PR137.2 PU1.4
51624_O-USR: PR15.1 PR144.2 PU1.9
51624_OCP-I: PR17.2 PR139.2 PR145.1 PU1.12
51624_PWM1: PU1.6 PU7.8
51624_PWM2: PR7.1 PU1.5
51624_SKIP#: PR136.1 PU1.7 PU7.1
51624_SLEWA: PR148.2 PR149.1 PU1.15
51624_THERM: PC11.1 PR146.2 PR147.1 PU1.14
51624_V5A: PC3.1 PR132.1 PU1.28
51624_VBAT: PR19.2 PU1.16
51624_VDD: PC6.1 PR133.1 PU1.2
51624_VFB: PR5.1 PU1.24
51624_VREF: PC2.1 PR14.1 PR126.1 PR142.1 PR144.1 PR147.2 PR148.1 PU1.27
51624_VRON: PR9.2 PR11.2 PR18.1 PR141.2 PU1.8
+DDR_VTT_RUN: C312.2 C322.2 C328.1 C331.1 C337.2 C343.1 C353.1 C360.2 C394.1 C414.1 C423.1 C725.1 C726.1 C729.1 C730.1 C731.1 C760.2 JDIM1.203 JDIM1.204 PC73.1 PC75.1 PU6.1 PU6.3 R334.1 R339.1 R340.1 R345.1 R346.1 R350.1 R351.1 R354.1 R355.1 R359.1 R360.1 R364.1 R368.1 R369.1 R370.1 R371.1 R372.1 R373.1 R719.1 R725.1 R731.1 R738.1 R739.1 R742.1 R743.1 R744.1 R746.1 R747.1 R750.1 R751.1
+FB_PLLAVDD: C110.2 C115.1 C116.1 C129.2 L13.1 U43.F16 U43.H22 U43.P22
+G_SEN_PW: C722.1 C724.1 R749.2 R754.2 R760.2 U54.1 U54.8 U54.14
+PCH_VCCDSW: C240.1 C250.1 U45.AG19 U45.AG20
+SMDDR_VREF_DIMM: C339.1 C357.1 C408.1 C411.1 C412.1 C436.1 C437.1 C438.1 C439.2 C466.1 C741.1 JDIM1.126 R363.2 R365.1 R366.2 U28.M8 U29.M8 U30.M8 U31.M8 U50.M8 U51.M8 U52.M8 U53.M8
+SMDDR_VREF_DQ0: C390.2 C401.1 C403.1 C404.1 C406.1 C758.1 C759.1 C762.1 C765.1 R322.2 R325.1 R327.2 U28.H1 U29.H1 U30.H1 U31.H1 U50.H1 U51.H1 U52.H1 U53.H1
+SMDDR_VREF_DQ1: C310.1 C321.2 C327.1 JDIM1.1 R279.2 R282.1 R283.2
+TPVDD: C761.1 CN18.1 CN18.2 L31.1 L32.1
+VGACORE: C123.2 C124.2 C125.2 C135.2 C136.2 C140.2 C142.2 C146.1 C149.2 C151.2 C154.2 C159.2 C168.2 C169.2 C186.2 C206.2 C215.2 C217.2 C232.2 C247.2 C248.2 C257.2 PC23.1 PC25.1 PC26.1 PC28.1 PC29.1 PC104.1 PL3.1 PL4.1 PR183.2 U43.K10 U43.K12 U43.K14 U43.K16 U43.K18 U43.L11 U43.L13 U43.L15 U43.L17 U43.M10 U43.M12 U43.M14 U43.M16 U43.M18 U43.N11 U43.N13 U43.N15 U43.N17 U43.P10 U43.P12 U43.P14 U43.P16 U43.P18 U43.R11 U43.R13 U43.R15 U43.R17 U43.T10 U43.T12 U43.T14 U43.T16 U43.T18 U43.U11 U43.U13 U43.U15 U43.U17 U43.V10 U43.V12 U43.V14 U43.V16 U43.V18
+VREF_CA_CPU: R358.2 U45.AP49
+VREFDQ_SA_M3: R305.1 U45.AR51
+VREFDQ_SB_M3: R268.1 U45.AP51
+WL_VDD: C688.2 C689.2 C690.2 C699.2 C701.2 C714.1 CN12.2 CN12.4 CN12.72 CN12.74 R245.2 R251.2 R265.2 R269.2 R700.2 R713.2
A_LAD0_R: CN12.64 R696.2
A_LAD1_R: CN12.66 R694.1 R695.2 R706.1 R707.1
A_LAD2_R: CN12.68 Q22.3 R252.1 R269.1 R693.2
A_LAD3_R: CN12.70 Q22.6 R248.1 R251.1 R691.2
A_LFRAME#_R: CN12.73 R270.2 R790.2
AC_PROTECT: PR90.1 U32.109
ACCEL_INTA: C721.2 D33.1 U45.AG3
ACCEL_INTA_R: D33.2 U54.11
ACIN: PQ13.3 PR49.1 U32.72
ACPRESENT: PR54.2 PR58.1 R239.1
ACZ_SDIN0_R: R405.1 U34.8
ADOGND: C478.2 C479.2 C480.1 C483.1 C486.2 C488.2 C500.2 C501.2 C504.2 C505.2 C506.2 C507.2 C514.1 C515.1 CN21.3 CN21.5 CN21.7 D23.2 D24.2 D25.2 D26.2 R381.2 R383.1 R390.1 R396.1 R407.2 R411.2 R413.1 R414.1 R417.1 R424.2 R427.1 R789.1 U34.25 U34.38
ALERT: R624.1 U43.F8
AMP_MUTE#: D18.1 U32.108
APS1: CN14.1 R723.1 R737.1
APS3: CN14.3 R716.1 R718.1 R737.2
APS7: CN14.7 R717.1 R718.2
APWORK: R377.1 R519.2 U32.30
APWROK_R: R377.2 R379.2 R653.2 U45.AB5
BAT-V: PC77.1 PC78.2 PC79.2 PC134.1 PC137.1 PJ2.7 PJ2.8 PQ22.5 PR207.2 PR209.2
BATLED0#: R432.1 R439.1 U32.29
BATLED1#: R433.1 R440.1 U32.25
BATT_EN#: PJ2.6 PR103.2
BC_CEN: R331.1 U25.1 U26.2
BEEP_1: C508.2 C509.1 R409.1 R412.2
BEEP_2: D19.1 D20.1 R409.2
BL#: Q18.2 Q18.3 R192.1
BL_ON: CN7.26 D5.2 Q16.3 Q18.6 R190.1
BOARD_ID0: R559.1 R561.2 U45.P1
BOARD_ID1: R547.1 R549.2 U45.R5
BOARD_ID2: R540.2 R541.1 U45.L4
BOARD_ID3: R88.2 R89.1 U45.C4
BOARD_ID4: R536.2 R537.1 U45.L3
BT_LED: CN12.16 TP150.1
BT_POWERON: R701.2 U32.104
BXTALOUT: R613.1 U43.C10
CARD_3V3: C300.2 C771.2 C773.2 C774.2 CN19.4 U24.13
CATERR#: TP28.1 U45.K61
CCD_PWR: C261.2 C262.1 CN7.32 CN7.33 R186.2
CFG0: R153.1 TP63.1 U45.AC60
CFG1: R136.1 TP45.1 U45.AC62
CFG2: TP44.1 U45.AC63
CFG3: R142.1 TP46.1 U45.AA63
CFG4: R143.1 TP55.1 U45.AA60
CFG5: TP128.1 U45.Y62
CFG6: TP40.1 U45.Y61
CFG7: TP53.1 U45.Y60
CFG8: R125.1 TP38.1 U45.V62
CFG9: R126.1 TP42.1 U45.V61
CFG10: R135.1 TP47.1 U45.V60
CFG11: TP131.1 U45.U60
CFG12: TP32.1 U45.T63
CFG13: TP129.1 U45.T62
CFG14: TP33.1 U45.T61
CFG15: TP41.1 U45.T60
CFG_RCOMP: R129.2 U45.V63
CK_XDP_N_R: R82.1 TP3.1
CK_XDP_P_R: R81.1 TP2.1
CL_CLK: TP135.1 U45.AF2
CL_DAT: TP133.1 U45.AD2
CL_RST#: TP140.1 U45.AF4
CLK_PCH_PCI3: R223.2 R224.2 U45.AN15
CLK_PCH_PCI4: R222.2 U45.AP15
CLK_PCI_EC: C288.2 R222.1 R348.2 U32.13
CLK_PCI_LPC: C289.2 R223.1 R275.1
CLK_PCI_LPC_R: CN12.71 R275.2 R791.2
CLK_PCIE_LAN_REQ#: Q26.1 R307.2 R600.1
CLK_PCIE_LANN: U24.28 U45.C41
CLK_PCIE_LANP: U24.27 U45.B42
CLK_PCIE_N0: TP106.1 U45.C43
CLK_PCIE_P0: TP107.1 U45.C42
CLK_PCIE_REQ0#: R576.2 TP126.1 U45.U2
CLK_PCIE_REQ1#: R572.2 R582.2 U45.Y5
CLK_PCIE_REQ2#: R596.2 R600.2 U45.AD1
CLK_PCIE_REQ3#: R545.2 R550.2 U45.N1
CLK_PCIE_REQ4#: R571.1 R573.2 R577.1 U45.U5
CLK_PCIE_REQ5#: R569.2 TP123.1 U45.T2
CLK_PCIE_VGA: U43.AE8 U45.B39
CLK_PCIE_VGA#: U43.AD8 U45.A39
CLK_PCIE_WIGIGN: R790.1 U45.B41
CLK_PCIE_WIGIGP: R791.1 U45.A41
CLK_PCIE_WLAN_REQ#_R: CN12.53 Q21.3 R250.1 R265.1
CLK_PCIE_WLANN: CN12.49 U45.B38
CLK_PCIE_WLANP: CN12.47 U45.C37
CLK_PCIE_XDPN: R82.2 U45.B35
CLK_PCIE_XDPP: R81.2 U45.A35
CLK_PEGA_REQ#: Q11.3 R147.2 R573.1
CLK_SCLK: C757.1 JDIM1.202 Q20.1 R241.1 R755.1 R772.1 TP89.1
CLK_SDATA: C763.1 JDIM1.200 Q20.4 R257.1 R761.1 R776.1 TP88.1
CLKRUN#: R131.1 R787.2 U32.93 U45.V5
COLOR_ENG: R670.2 U32.87
COMBO MIC JD: C515.2 R425.1 U34.48
COMBO_MIC: CN21.4 D25.1 R420.2 R421.2 R424.1 R425.2
CPU_DRAMRST#: R375.2 R376.1 U45.AV15
CRT_11: CN3.11 TP1.1
CRT_AUXN: C574.2 R476.2 U40.17 U45.B6
CRT_AUXN_C: C574.1 U40.19
CRT_AUXP: C575.2 R482.2 U40.18 U45.A6
CRT_AUXP_C: C575.1 U40.20
CRT_B1: C30.2 CN3.3 L4.2 U2.5 U2.6
CRT_BLU: C40.2 L4.1 R13.1 U40.8
CRT_CLK: R515.2 U45.D9
CRT_DATA: R514.2 U45.D11
CRT_G1: C29.2 CN3.2 L3.2 U2.2 U2.9
CRT_GRE: C39.2 L3.1 R12.1 U40.9
CRT_HPD: R484.2 U40.40 U45.A8
CRT_R1: C28.2 CN3.1 L2.2 U2.1 U2.10
CRT_RED: C38.2 L2.1 R11.1 U40.11
CRT_TXN0: C599.2 U45.C51
CRT_TXN0_C: C599.1 U40.27
CRT_TXN1: C597.2 U45.C53
CRT_TXN1_C: C597.1 U40.30
CRT_TXP0: C600.2 U45.C50
CRT_TXP0_C: C600.1 U40.26
CRT_TXP1: C598.2 U45.B54
CRT_TXP1_C: C598.1 U40.29
CRTHSYNC: C33.2 CN3.13 U3.1 U3.10 U5.4
CRTVDD5: C31.1 C36.1 C543.2 C547.2 CN3.9 Q36.1 R3.2 R448.2 U3.2 U3.9
CRTVSYNC: C34.2 CN3.14 U3.4 U3.7 U6.4
CS_BST1: PC93.1 PU7.7
CS_BSTR1: PR134.2 PU7.6
CS_SW1: PL1.1 PR10.1 PU7.4
D/C#: PR44.2 U32.107
DAC_VDDC: C52.2 C53.2 C54.2 C551.2 C562.2 L8.2 U40.7 U40.10
DACA_VDD: U43.W5
DACA_VREF: U43.AE2
DC_TEST_A3_B3: U45.A3 U45.B3
DC_TEST_A61_B61: U45.A61 U45.B61
DC_TEST_AY2_AW2: U45.AW2 U45.AY2
DC_TEST_AY3_AW3: U45.AW3 U45.AY3
DC_TEST_AY61_AW61: U45.AW61 U45.AY61
DC_TEST_AY62_AW62: U45.AW62 U45.AY62
DC_TEST_B62_B63: U45.B62 U45.B63
DC_TEST_C1_C2: U45.C1 U45.C2
DDCCLK: C35.2 CN3.15 R3.1 R467.1 R488.1 U3.5 U3.6
DDCDAT: C544.1 CN3.12 R448.1 R472.1 R483.1 U2.4 U2.7
DDR3_DRAMRST#: C362.2 C460.1 JDIM1.30 R376.2 U28.T2 U29.T2 U30.T2 U31.T2 U50.T2 U51.T2 U52.T2 U53.T2
DDR_PG_CTRL: R649.2 U45.AV61
DDR_VTTREF: PC68.1 PU6.5
DDR_VTTT_PG_CTRL: PR212.1 Q25.2 R280.2 U23.4
DEVSLP0: R132.1 R289.1 U45.P2
DEVSLP1: R544.1 TP26.1 U45.L2
DGPU_D: PC19.2 PQ5.2 PQ6.3 PR31.2
DGPU_D1: PC12.2 PQ3.3 PQ4.4 PR24.2
DGPU_D2: PC116.2 PQ10.4 PQ42.3 PR163.2
DGPU_EDIDCLK: R614.2 U43.A9
DGPU_EDIDDATA: R633.2 U43.B9
DGPU_EVENT#: R163.2 R534.1 U45.J3
DGPU_HOLD_RST#: R586.2 U22.1 U45.U4
DGPU_OPP#: Q10.3 R362.1 U32.18
DGPU_OTP#: Q15.3 R361.1 U32.76
DGPU_PGOK-1: C77.1 Q4.3 Q7.2 R59.1
DGPU_POK2: C63.1 Q4.2 R56.1
DGPU_PW_CTRL#: R556.2 R574.1 U45.P3
DGPU_PWR_EN: PR37.1 R592.1 R593.2 U45.Y3
DGPU_PWROK: Q7.3 R65.1 R69.2 R118.1 U45.T3
DGPU_SELECT#: R543.1 U45.L1
DIMM1_SA0: JDIM1.197 R284.1
DIMM1_SA1: JDIM1.201 R288.1
DMIC_CLK: R415.2 U34.3
DMIC_CLK_R: C512.1 CN20.3 D21.1 R415.1
DMIC_DATA: R416.2 U34.2
DMIC_DATA_R: C513.1 CN20.4 D22.1 R416.1
DNBSWON#: R236.1 U32.120
DP_UTIL: R502.2 R503.2 U45.A43
DPWROK: R681.2 U32.124
DPWROK_R: R679.1 R680.1 R681.1 U45.AV5
DSWVREN: R662.2 R677.1 U45.AW7
EAPD#: R403.2 R404.2 R406.2 R407.1
EC_FB_CLAMP: R184.2 R201.1 U32.77
EC_FPBACK#: Q16.2 U32.118
EC_PECR_R: R298.1 U32.117
EC_PWROK: R656.1 R666.2 R674.2 U32.33 U47.2
EC_PWROK_R: R352.1 R661.2 U45.AY7
ECAGND: C430.2 C469.1 L19.2 U32.75
EDP_AUXN: C681.2 U45.A45
EDP_AUXN_C: C681.1 CN7.10 R669.1
EDP_AUXP: C680.2 U45.B45
EDP_AUXP_C: C680.1 CN7.11 R668.1
EDP_HPD: CN7.25 R86.2 U45.D6
EDP_RCOMP: R107.1 U45.D20
EDP_TXN0: C673.2 U45.C45
EDP_TXN0_C: C285.2 C673.1 CN7.13
EDP_TXN1: C671.2 U45.A47
EDP_TXN1_C: C283.2 C671.1 CN7.16
EDP_TXN2: C669.2 U45.C47
EDP_TXN2_C: C281.2 C669.1 CN7.19
EDP_TXN3: C667.2 U45.A49
EDP_TXN3_C: C279.2 C667.1 CN7.22
EDP_TXP0: C672.2 U45.B46
EDP_TXP0_C: C284.2 C672.1 CN7.14
EDP_TXP1: C670.2 U45.B47
EDP_TXP1_C: C282.2 C670.1 CN7.17
EDP_TXP2: C668.2 U45.C46
EDP_TXP2_C: C280.2 C668.1 CN7.20
EDP_TXP3: C666.2 U45.B49
EDP_TXP3_C: C278.2 C666.1 CN7.23
ENSWREG: R291.1 U24.45
EVDD10: C323.2 C324.1 R286.2 U24.29
FAN1_PWM: Q40.1 U32.32
FAN2_PWM: Q35.1 U32.31
FAN2SIG: CN4.2 R447.2 U32.48
FAN_PWM_CN1: CN10.1 Q40.3 R697.2
FAN_PWM_CN2: CN4.1 Q35.3 R445.2
FANSIG: CN10.2 R699.2 U32.47
FB_CAL_PD_VDDQ: R172.2 U43.D22
FB_CAL_PU_GND: R161.2 U43.C24
FB_CAL_TERM_GND: R149.2 U43.B25
FB_CLAMP_MON: Q14.1 R181.1 U43.C6
FB_CLAMP_REQ#: R167.2 R380.1 U32.70
FB_VREF_PROBE: U43.D23
FBA_CMD0: R487.2 U13.K1 U16.K1 U41.K1 U43.C27 U44.K1
FBA_CMD1: U13.L2 U16.L2 U43.C26
FBA_CMD2: U41.L2 U43.E24 U44.L2
FBA_CMD3: R61.1 U13.K9 U16.K9 U41.K9 U43.F24 U44.K9
FBA_CMD4: R473.1 R480.2 U11.R7 U12.R7 U13.R7 U16.R7 U38.R3 U39.R3 U41.R3 U43.D27 U44.R3
FBA_CMD5: R485.2 R490.1 U11.R2 U12.R2 U13.R2 U16.R2 U38.R8 U39.R8 U41.R8 U43.D26 U44.R8
FBA_CMD6: R435.1 R436.2 U11.N8 U12.N8 U13.N8 U16.N8 U38.N2 U39.N2 U41.N2 U43.F25 U44.N2
FBA_CMD7: R443.1 R444.2 U11.N7 U12.N7 U13.N7 U16.N7 U38.N3 U39.N3 U41.N3 U43.F26 U44.N3
FBA_CMD8: R39.1 R54.2 U11.T8 U12.T8 U13.T8 U16.T8 U38.T8 U39.T8 U41.T8 U43.F23 U44.T8
FBA_CMD9: R58.2 R63.1 U11.N3 U12.N3 U13.N3 U16.N3 U38.N7 U39.N7 U41.N7 U43.G22 U44.N7
FBA_CMD10: R42.1 R53.2 U11.P3 U12.P3 U13.P3 U16.P3 U38.P7 U39.P7 U41.P7 U43.G23 U44.P7
FBA_CMD11: R457.2 R458.1 U11.J3 U12.J3 U13.J3 U16.J3 U38.J3 U39.J3 U41.J3 U43.G24 U44.J3
FBA_CMD12: R41.1 R52.2 U11.T7 U12.T7 U13.T7 U16.T7 U38.T3 U39.T3 U41.T3 U43.F27 U44.T3
FBA_CMD13: R49.1 R51.2 U11.N2 U12.N2 U13.N2 U16.N2 U38.N8 U39.N8 U41.N8 U43.G25 U44.N8
FBA_CMD14: R9.2 R10.1 U11.T3 U12.T3 U13.T3 U16.T3 U38.T7 U39.T7 U41.T7 U43.G27 U44.T7
FBA_CMD15: R441.1 R442.2 U11.K3 U12.K3 U13.K3 U16.K3 U38.K3 U39.K3 U41.K3 U43.G26 U44.K3
FBA_CMD16: R34.1 U11.K1 U12.K1 U38.K1 U39.K1 U43.M24
FBA_CMD17: U11.L2 U12.L2 U43.M23
FBA_CMD18: U38.L2 U39.L2 U43.K24
FBA_CMD19: R47.2 U11.K9 U12.K9 U38.K9 U39.K9 U43.K23
FBA_CMD20: R468.1 U11.T2 U12.T2 U13.T2 U16.T2 U38.T2 U39.T2 U41.T2 U43.M27 U44.T2
FBA_CMD21: R469.1 R478.2 U11.R8 U12.R8 U13.R8 U16.R8 U38.R2 U39.R2 U41.R2 U43.M26 U44.R2
FBA_CMD22: R470.1 R479.2 U11.P2 U12.P2 U13.P2 U16.P2 U38.P8 U39.P8 U41.P8 U43.M25 U44.P8
FBA_CMD23: R462.2 R463.1 U11.R3 U12.R3 U13.R3 U16.R3 U38.R7 U39.R7 U41.R7 U43.K26 U44.R7
FBA_CMD24: R4.1 R5.2 U11.P7 U12.P7 U13.P7 U16.P7 U38.P3 U39.P3 U41.P3 U43.K22 U44.P3
FBA_CMD25: R36.1 R38.2 U11.L3 U12.L3 U13.L3 U16.L3 U38.L7 U39.L7 U41.L7 U43.J23 U44.L7
FBA_CMD26: R15.1 R16.2 U11.P8 U12.P8 U13.P8 U16.P8 U38.P2 U39.P2 U41.P2 U43.J25 U44.P2
FBA_CMD27: R17.1 R18.2 U38.M3 U39.M3 U41.M3 U43.J24 U44.M3
FBA_CMD28: R454.1 R456.2 U11.L7 U12.L7 U13.L7 U16.L7 U38.L3 U39.L3 U41.L3 U43.K27 U44.L3
FBA_CMD29: R35.1 R48.2 U11.M2 U12.M2 U13.M2 U16.M2 U38.M2 U39.M2 U41.M2 U43.K25 U44.M2
FBA_CMD30: R471.1 R477.2 U11.M3 U12.M3 U13.M3 U16.M3 U43.J27
FBA_ZQ0: R562.1 U44.L8
FBA_ZQ1: R498.1 U41.L8
FBA_ZQ2: R121.1 U16.L8
FBA_ZQ3: R62.1 U13.L8
FBA_ZQ4: R466.1 U39.L8
FBA_ZQ5: R8.1 U38.L8
FBA_ZQ6: R46.1 U12.L8
FBA_ZQ7: R43.1 U11.L8
FBVDDQ_EN: PR34.1 PR60.1 R197.2 R218.1 U21.4
G_MBCLK: TP96.1 U32.94
G_MBCLK_R: R754.1 R755.2 U54.4
G_MBDATA: TP95.1 U32.95
G_MBDATA_R: R760.1 R761.2 U54.6
GC6_FB_EN: R189.2 R199.1 R531.1 R535.2 U45.J4
GPIO4: R524.1 U45.F2
GPIO5: R525.1 U45.F3
GPIO6: R98.1 U45.G4
GPIO7: R94.1 U45.F1
GPIO8: CN7.1 R213.1 U45.AU2
GPIO12_ACIN: Q10.1 R169.1 U43.D7
GPIO15: R140.1 R146.2 U45.AD6
GPIO24: R138.1 TP60.1 U45.AD5
GPIO25: R206.2 TP142.1 U45.AM4
GPIO28: R204.2 TP77.1 U45.AD7
GPIO36: R120.1 R134.2 TP36.1 U45.V6
GPIO37: R595.1 R599.2 TP134.1 U45.AC1
GPIO44: R231.2 TP82.1 U45.AK4
GPIO45: R209.2 TP70.1 U45.AG5
GPIO47: R141.2 TP51.1 U45.AB6
GPIO56: R208.2 TP74.1 U45.AG6
GPIO57: R648.2 TP143.1 U45.AP1
GPIO58: R203.1 TP81.1 U45.AL4
GPIO59: R202.2 TP83.1 U45.AT5
GPIO64: R523.1 U45.E3
GPIO65: R97.1 U45.F4
GPIO66: R516.1 R517.2 U45.D3
GPIO67: R92.1 U45.E4
GPIO68: R91.1 U45.C3
GPIO69: R520.1 U45.E2
GPIO84: R108.1 U45.L6
GPIO85: R158.1 U45.N6
GPIO86: R93.1 R99.2 U45.L8
GPIO87: R110.1 U45.R7
GPIO88: R157.1 U45.L5
GPIO89: R155.1 U45.N7
GPIO90: R539.1 U45.K2
GPIO91: R533.1 U45.J1
GPIO92: R159.1 U45.K3
GPIO93: R529.1 U45.J2
GPIO94: R527.1 U45.G1
GPO_NC: R287.1 U24.50
GPU_EVENT#: Q13.1 R178.1 R182.1 R630.1 U43.A4
GPU_GPIO16: TP136.1 U43.D5
GPU_PEX_RST_HOLD#: R609.1 TP137.1 U43.C4
GPU_THAL#: PR65.1 PU3.14
GPU_VCCP_SENSE: PR185.1 U43.F2
GPU_VSSP_SENSE: PR179.1 U43.F1
GPUT_CLK_L: Q12.1 R175.2 U43.D9
GPUT_DATA_L: Q12.4 R176.2 U43.D8
H_CPU_SVIDART#: R565.1 U45.L62
H_CPU_SVIDCLK: R579.1 U45.N63
H_CPU_SVIDDAT: R554.2 R555.2 R558.1 U45.L63
H_PECI: R298.2 U45.N62
H_PROCHOT#: PQ18.3 PR81.1 PR129.2 PU1.30 Q29.3 R542.1 R546.1 R548.1
H_PROCHOT#_R: R542.2 U45.K63
H_PWRGOOD_R: R508.1 U45.C61
H_SYS_PWROK_XDP: R261.2 R274.1 TP87.1
HDA_BCLK_R: R652.2 U45.AW8
HDA_RST#_R: R659.2 U45.AU8
HDA_SDO_R: R657.2 R658.1 U45.AU11
HDA_SYNC_R: C678.2 R684.2 U45.AV11
HDMI_5V: C549.1 CN2.18 D27.2 Q37.1
HDMI_DDCCLK_COM: Q3.1 R57.2 R60.1
HDMI_DDCCLK_MB: CN2.15 Q3.3 R50.1
HDMI_DDCCLK_SW: R57.1 U45.B9
HDMI_DDCDATA_COM: Q38.1 R486.1 R492.2
HDMI_DDCDATA_MB: CN2.16 Q38.3 R474.1
HDMI_DDCDATA_SW: R492.1 U45.C9
HDMI_MB_HP: Q2.3 R14.2 R37.1 RV1.1
HP-L: R419.2 U34.32
HP-L-1: R419.1 R423.1
HP-R: R418.2 U34.33
HP-R-1: R418.1 R422.1
HP_DET_CN: CN2.19 R14.1
HPL_SYS: CN21.1 D24.1 R423.2
HPOUT_JD: CN21.6 D26.1 R410.2
HPR_SYS: CN21.2 D23.1 R422.2
HSYNC: U5.2 U40.4
HWPG: D14.2 D34.2 D36.2 D37.2 D38.2 R344.1 U32.84
HWPG_1.05V: D14.1 Q34.3 R400.2 R402.1
HWPG_1.5V: D38.1 PR217.1 PU10.14
HWPG_1.05V_EC: Q39.3 R521.2
HWPG_1.05V_EC#: Q39.2 U32.16
HWPG_1.05V_S5: D34.1 PR72.1 PU4.1 R254.1
HWPG_1.5VGFX: PR33.1 PU2.1 R56.2
HWPG_VDDR: D36.1 PR114.1 PU6.20
I2CA_SCL: R631.1 U43.B7
I2CA_SDA: R611.1 U43.A7
ICLK_BIAS: R500.2 U45.C26
ICMNT: C469.2 PC124.2 PR88.1 PU9.7 U32.67
IFPA_IOVDD: U43.W6
IFPAB_PLLVDD_1: U43.V7
IFPAB_PLLVDD_2: U43.W7
IFPB_IOVDD: U43.Y6
IFPC_IOVDD: U43.P6
IFPC_PLLVDD_1: U43.M7
IFPC_PLLVDD_2: U43.N7
IFPD_IOVDD: U43.R6
IFPD_PLLVDD_1: U43.R7
IFPD_PLLVDD_2: U43.T7
IFPE_IOVDD: U43.H6
IFPEF_PLLVDD_1: U43.J7
IFPEF_PLLVDD_2: U43.K7
IFPF_IOVDD: U43.J6
IMVP_PWRGD: PR130.1 R506.1 R507.1 U10.2 U45.C59
IMVP_PWRGD_3V: Q8.2 R33.2 R683.2 U10.4 U47.1
INT_HDMI_HPD: Q2.1 R55.2 U45.C8
INT_HDMICLK+: C559.1 U45.B57
INT_HDMICLK+_C: C559.2 CN2.10 R25.1 R453.1
INT_HDMICLK-: C560.1 U45.A57
INT_HDMICLK-_C: C560.2 CN2.12 R26.1 R453.2
INT_HDMITX0N: C554.1 U45.B55
INT_HDMITX0N_C: C554.2 CN2.9 R20.1 R450.2
INT_HDMITX0P: C553.1 U45.A55
INT_HDMITX0P_C: C553.2 CN2.7 R19.1 R450.1
INT_HDMITX1N: C558.1 U45.B58
INT_HDMITX1N_C: C558.2 CN2.6 R24.1 R452.2
INT_HDMITX1P: C557.1 U45.C58
INT_HDMITX1P_C: C557.2 CN2.4 R23.1 R452.1
INT_HDMITX2N: C556.1 U45.C54
INT_HDMITX2N_C: C556.2 CN2.3 R22.1 R451.2
INT_HDMITX2P: C555.1 U45.C55
INT_HDMITX2P_C: C555.2 CN2.1 R21.1 R451.1
IOAC_LANPWR#: R330.2 U32.20
IOAC_RST#: R341.1 R704.2 R724.2 U27.2 U32.85
IOAC_WLANPWR#: Q41.2 R741.2 U32.81
IRQ_SERIRQ: R114.1 R769.1 U32.5 U45.T4
ISOLATEB: R290.1 R293.1 U24.38
ISPSCL: R467.2 U40.1 U40.15
ISPSDA: R472.2 U40.2 U40.16
IVDDO: C80.1 L9.1 U40.38 U40.39
IVDDO_18: C61.1 C71.1 C72.1 C75.1 L8.1 L9.2 L28.1 U40.22 U40.25 U40.31 U40.32
JTAG_TCK: R567.1 TP124.1 U43.AE5
JTAG_TDI: R552.1 TP122.1 U43.AE6
JTAG_TDO: TP120.1 U43.AF6
JTAG_TMS: R566.1 TP127.1 U43.AD6
JTAG_TRST#: R553.1 U43.AG4
KB_BL_LED: Q31.2 U32.88
L_SPK2: TP101.1 U34.24
L_SPK+: R428.1 U34.42
L_SPK+_1: C519.1 CN22.4 R428.2
L_SPK-: R429.1 U34.43
L_SPK-_1: C520.1 CN22.3 R429.2
LAN_DISABLE#: R220.1 U45.AM7
LAN_RESET: R247.1 U24.62
LAN_WAKE#: R308.1 R317.1
LAN_XTAL2: C301.1 R271.2 U24.60 Y1.1
LAN_XTALI: C302.1 R271.1 U24.59 Y1.3
LANWAKE#: Q27.1 R294.1 R303.2 U24.40
LCD_VIN: CN7.39 CN7.40 R200.2 R205.2
LCDVCC: C286.1 C675.1 C676.2 CN7.34 CN7.35 CN7.36 R229.2
LCDVCC_1: C287.2 C663.1 R229.1 U46.1
LED0/SPICSB: TP91.1 U24.51
LED1/SPICLK/EESK: TP90.1 U24.49
LED3/SPIDO/EEDO: TP92.1 U24.43
LID#: CN6.11 D5.1 U32.86
LM393_PIN2: PR157.2 PR158.2 PU8.2
LPC_LAD0: R696.1 U32.10 U45.AU14 U56.26
LPC_LAD1: R695.1 U32.9 U45.AW12 U56.23
LPC_LAD2: R693.1 U32.8 U45.AY12 U56.20
LPC_LAD3: R691.1 U32.7 U45.AW11 U56.17
LPC_LFRAME#: R270.1 U32.6 U45.AV12 U56.22
LVDS_BRIGHT: C674.1 CN7.27 R671.1 R672.1
M_A_A0: R747.2 U28.N3 U29.N3 U30.N3 U31.N3 U45.AU36 U50.N3 U51.N3 U52.N3 U53.N3
M_A_A1: R751.2 U28.P7 U29.P7 U30.P7 U31.P7 U45.AY37 U50.P7 U51.P7 U52.P7 U53.P7
M_A_A2: R359.2 U28.P3 U29.P3 U30.P3 U31.P3 U45.AR38 U50.P3 U51.P3 U52.P3 U53.P3
M_A_A3: R355.2 U28.N2 U29.N2 U30.N2 U31.N2 U45.AP36 U50.N2 U51.N2 U52.N2 U53.N2
M_A_A4: R364.2 U28.P8 U29.P8 U30.P8 U31.P8 U45.AU39 U50.P8 U51.P8 U52.P8 U53.P8
M_A_A5: R369.2 U28.P2 U29.P2 U30.P2 U31.P2 U45.AR36 U50.P2 U51.P2 U52.P2 U53.P2
M_A_A6: R373.2 U28.R8 U29.R8 U30.R8 U31.R8 U45.AV40 U50.R8 U51.R8 U52.R8 U53.R8
M_A_A7: R371.2 U28.R2 U29.R2 U30.R2 U31.R2 U45.AW39 U50.R2 U51.R2 U52.R2 U53.R2
M_A_A8: R372.2 U28.T8 U29.T8 U30.T8 U31.T8 U45.AY39 U50.T8 U51.T8 U52.T8 U53.T8
M_A_A9: R750.2 U28.R3 U29.R3 U30.R3 U31.R3 U45.AU40 U50.R3 U51.R3 U52.R3 U53.R3
M_A_A10: R742.2 U28.L7 U29.L7 U30.L7 U31.L7 U45.AP35 U50.L7 U51.L7 U52.L7 U53.L7
M_A_A11: R360.2 U28.R7 U29.R7 U30.R7 U31.R7 U45.AW41 U50.R7 U51.R7 U52.R7 U53.R7
M_A_A12: R354.2 U28.N7 U29.N7 U30.N7 U31.N7 U45.AU41 U50.N7 U51.N7 U52.N7 U53.N7
M_A_A13: R370.2 U28.T3 U29.T3 U30.T3 U31.T3 U45.AR35 U50.T3 U51.T3 U52.T3 U53.T3
M_A_A14: R368.2 U28.T7 U29.T7 U30.T7 U31.T7 U45.AV42 U50.T7 U51.T7 U52.T7 U53.T7
M_A_A15: R346.2 U28.M7 U29.M7 U30.M7 U31.M7 U45.AU42 U50.M7 U51.M7 U52.M7 U53.M7
M_A_BS#0: R744.2 U28.M2 U29.M2 U30.M2 U31.M2 U45.AU35 U50.M2 U51.M2 U52.M2 U53.M2
M_A_BS#1: R746.2 U28.N8 U29.N8 U30.N8 U31.N8 U45.AV35 U50.N8 U51.N8 U52.N8 U53.N8
M_A_BS#2: R351.2 U28.M3 U29.M3 U30.M3 U31.M3 U45.AY41 U50.M3 U51.M3 U52.M3 U53.M3
M_A_CAS#: R738.2 U28.K3 U29.K3 U30.K3 U31.K3 U45.AU34 U50.K3 U51.K3 U52.K3 U53.K3
M_A_CKE0: R334.2 U28.K9 U29.K9 U30.K9 U31.K9 U45.AU43
M_A_CKE1: R743.2 U45.AW43 U50.K9 U51.K9 U52.K9 U53.K9
M_A_CLK0: R731.2 U28.J7 U29.J7 U30.J7 U31.J7 U45.AV37
M_A_CLK0#: R739.2 U28.K7 U29.K7 U30.K7 U31.K7 U45.AU37
M_A_CLK1: R719.2 U45.AY36 U50.J7 U51.J7 U52.J7 U53.J7
M_A_CLK1#: R725.2 U45.AW36 U50.K7 U51.K7 U52.K7 U53.K7
M_A_CS#0: R345.2 U28.L2 U29.L2 U30.L2 U31.L2 U45.AP33
M_A_CS#1: R340.2 U45.AR32 U50.L2 U51.L2 U52.L2 U53.L2
M_A_DQ0: U30.G2 U45.AH63 U52.H8
M_A_DQ1: U30.H3 U45.AH62 U52.H7
M_A_DQ2: U30.F7 U45.AK63 U52.E3
M_A_DQ3: U30.H8 U45.AK62 U52.G2
M_A_DQ4: U30.E3 U45.AH61 U52.F7
M_A_DQ5: U30.F2 U45.AH60 U52.F8
M_A_DQ6: U30.F8 U45.AK61 U52.F2
M_A_DQ7: U30.H7 U45.AK60 U52.H3
M_A_DQ8: U28.G2 U45.AM63 U50.H8
M_A_DQ9: U28.H3 U45.AM62 U50.H7
M_A_DQ10: U28.H8 U45.AP63 U50.G2
M_A_DQ11: U28.F7 U45.AP62 U50.E3
M_A_DQ12: U28.E3 U45.AM61 U50.F7
M_A_DQ13: U28.F2 U45.AM60 U50.F8
M_A_DQ14: U28.H7 U45.AP61 U50.H3
M_A_DQ15: U28.F8 U45.AP60 U50.F2
M_A_DQ16: U30.D7 U45.AP58 U52.C3
M_A_DQ17: U30.C8 U45.AR58 U52.C2
M_A_DQ18: U30.C2 U45.AM57 U52.C8
M_A_DQ19: U30.C3 U45.AK57 U52.D7
M_A_DQ20: U30.A2 U45.AL58 U52.A7
M_A_DQ21: U30.A3 U45.AK58 U52.B8
M_A_DQ22: U30.B8 U45.AR57 U52.A2
M_A_DQ23: U30.A7 U45.AN57 U52.A3
M_A_DQ24: U28.A3 U45.AP55 U50.B8
M_A_DQ25: U28.C3 U45.AR55 U50.D7
M_A_DQ26: U28.B8 U45.AM54 U50.A2
M_A_DQ27: U28.A7 U45.AK54 U50.A3
M_A_DQ28: U28.C2 U45.AL55 U50.C8
M_A_DQ29: U28.A2 U45.AK55 U50.A7
M_A_DQ30: U28.D7 U45.AR54 U50.C3
M_A_DQ31: U28.C8 U45.AN54 U50.C2
M_A_DQ32: U31.F2 U45.AY58 U53.F8
M_A_DQ33: U31.E3 U45.AW58 U53.F7
M_A_DQ34: U31.H8 U45.AY56 U53.G2
M_A_DQ35: U31.F7 U45.AW56 U53.E3
M_A_DQ36: U31.H3 U45.AV58 U53.H7
M_A_DQ37: U31.H7 U45.AU58 U53.H3
M_A_DQ38: U31.G2 U45.AV56 U53.H8
M_A_DQ39: U31.F8 U45.AU56 U53.F2
M_A_DQ40: U29.F2 U45.AY54 U51.F8
M_A_DQ41: U29.E3 U45.AW54 U51.F7
M_A_DQ42: U29.F7 U45.AY52 U51.E3
M_A_DQ43: U29.H8 U45.AW52 U51.G2
M_A_DQ44: U29.H3 U45.AV54 U51.H7
M_A_DQ45: U29.G2 U45.AU54 U51.H8
M_A_DQ46: U29.F8 U45.AV52 U51.F2
M_A_DQ47: U29.H7 U45.AU52 U51.H3
M_A_DQ48: U29.A7 U45.AK40 U51.A3
M_A_DQ49: U29.C8 U45.AK42 U51.C2
M_A_DQ50: U29.A3 U45.AM43 U51.B8
M_A_DQ51: U29.C2 U45.AM45 U51.C8
M_A_DQ52: U29.C3 U45.AK45 U51.D7
M_A_DQ53: U29.A2 U45.AK43 U51.A7
M_A_DQ54: U29.B8 U45.AM40 U51.A2
M_A_DQ55: U29.D7 U45.AM42 U51.C3
M_A_DQ56: U31.A7 U45.AM46 U53.A3
M_A_DQ57: U31.B8 U45.AK46 U53.A2
M_A_DQ58: U31.A3 U45.AM49 U53.B8
M_A_DQ59: U31.A2 U45.AK49 U53.A7
M_A_DQ60: U31.D7 U45.AM48 U53.C3
M_A_DQ61: U31.C8 U45.AK48 U53.C2
M_A_DQ62: U31.C3 U45.AM51 U53.D7
M_A_DQ63: U31.C2 U45.AK51 U53.C8
M_A_DQS0: U30.F3 U45.AJ62 U52.F3
M_A_DQS1: U28.F3 U45.AN61 U50.F3
M_A_DQS2: U30.C7 U45.AN58 U52.C7
M_A_DQS3: U28.C7 U45.AN55 U50.C7
M_A_DQS4: U31.F3 U45.AW57 U53.F3
M_A_DQS5: U29.F3 U45.AW53 U51.F3
M_A_DQS6: U29.C7 U45.AL42 U51.C7
M_A_DQS7: U31.C7 U45.AL49 U53.C7
M_A_DQS#0: U30.G3 U45.AJ61 U52.G3
M_A_DQS#1: U28.G3 U45.AN62 U50.G3
M_A_DQS#2: U30.B7 U45.AM58 U52.B7
M_A_DQS#3: U28.B7 U45.AM55 U50.B7
M_A_DQS#4: U31.G3 U45.AV57 U53.G3
M_A_DQS#5: U29.G3 U45.AV53 U51.G3
M_A_DQS#6: U29.B7 U45.AL43 U51.B7
M_A_DQS#7: U31.B7 U45.AL48 U53.B7
M_A_ODT0: R333.2 U28.K1 U29.K1 U30.K1 U31.K1 U50.K1 U51.K1 U52.K1 U53.K1
M_A_RAS#: R339.2 U28.J3 U29.J3 U30.J3 U31.J3 U45.AY34 U50.J3 U51.J3 U52.J3 U53.J3
M_A_WE#: R350.2 U28.L3 U29.L3 U30.L3 U31.L3 U45.AW34 U50.L3 U51.L3 U52.L3 U53.L3
M_A_ZQ1: R374.2 U28.L8
M_A_ZQ2: R342.2 U29.L8
M_A_ZQ3: R378.2 U30.L8
M_A_ZQ4: R343.2 U31.L8
M_A_ZQ5: R745.2 U50.L8
M_A_ZQ6: R756.2 U51.L8
M_A_ZQ7: R752.2 U52.L8
M_A_ZQ8: R757.2 U53.L8
M_B_A0: JDIM1.98 U45.AP40
M_B_A1: JDIM1.97 U45.AR40
M_B_A2: JDIM1.96 U45.AP42
M_B_A3: JDIM1.95 U45.AR42
M_B_A4: JDIM1.92 U45.AR45
M_B_A5: JDIM1.91 U45.AP45
M_B_A6: JDIM1.90 U45.AW46
M_B_A7: JDIM1.86 U45.AY46
M_B_A8: JDIM1.89 U45.AY47
M_B_A9: JDIM1.85 U45.AU46
M_B_A10: JDIM1.107 U45.AK36
M_B_A11: JDIM1.84 U45.AV47
M_B_A12: JDIM1.83 U45.AU47
M_B_A13: JDIM1.119 U45.AK33
M_B_A14: JDIM1.80 U45.AR46
M_B_A15: JDIM1.78 U45.AP46
M_B_BS#0: JDIM1.109 U45.AL35
M_B_BS#1: JDIM1.108 U45.AM36
M_B_BS#2: JDIM1.79 U45.AU49
M_B_CAS#: JDIM1.115 U45.AM33
M_B_CKE0: JDIM1.73 U45.AY49
M_B_CKE1: JDIM1.74 U45.AU50
M_B_CLK0: JDIM1.101 U45.AN38
M_B_CLK0#: JDIM1.103 U45.AM38
M_B_CLK1: JDIM1.102 U45.AL38
M_B_CLK1#: JDIM1.104 U45.AK38
M_B_CS#0: JDIM1.114 U45.AM32
M_B_CS#1: JDIM1.121 U45.AK32
M_B_DQ0: JDIM1.129 U45.AY31
M_B_DQ1: JDIM1.132 U45.AW31
M_B_DQ2: JDIM1.143 U45.AY29
M_B_DQ3: JDIM1.141 U45.AW29
M_B_DQ4: JDIM1.130 U45.AV31
M_B_DQ5: JDIM1.131 U45.AU31
M_B_DQ6: JDIM1.140 U45.AV29
M_B_DQ7: JDIM1.142 U45.AU29
M_B_DQ8: JDIM1.6 U45.AY27
M_B_DQ9: JDIM1.4 U45.AW27
M_B_DQ10: JDIM1.15 U45.AY25
M_B_DQ11: JDIM1.16 U45.AW25
M_B_DQ12: JDIM1.5 U45.AV27
M_B_DQ13: JDIM1.17 U45.AU27
M_B_DQ14: JDIM1.7 U45.AV25
M_B_DQ15: JDIM1.18 U45.AU25
M_B_DQ16: JDIM1.149 U45.AM29
M_B_DQ17: JDIM1.147 U45.AK29
M_B_DQ18: JDIM1.159 U45.AL28
M_B_DQ19: JDIM1.160 U45.AK28
M_B_DQ20: JDIM1.148 U45.AR29
M_B_DQ21: JDIM1.146 U45.AN29
M_B_DQ22: JDIM1.157 U45.AR28
M_B_DQ23: JDIM1.158 U45.AP28
M_B_DQ24: JDIM1.22 U45.AN26
M_B_DQ25: JDIM1.24 U45.AR26
M_B_DQ26: JDIM1.33 U45.AR25
M_B_DQ27: JDIM1.35 U45.AP25
M_B_DQ28: JDIM1.21 U45.AK26
M_B_DQ29: JDIM1.23 U45.AM26
M_B_DQ30: JDIM1.36 U45.AK25
M_B_DQ31: JDIM1.34 U45.AL25
M_B_DQ32: JDIM1.164 U45.AY23
M_B_DQ33: JDIM1.165 U45.AW23
M_B_DQ34: JDIM1.177 U45.AY21
M_B_DQ35: JDIM1.174 U45.AW21
M_B_DQ36: JDIM1.163 U45.AV23
M_B_DQ37: JDIM1.166 U45.AU23
M_B_DQ38: JDIM1.175 U45.AV21
M_B_DQ39: JDIM1.176 U45.AU21
M_B_DQ40: JDIM1.40 U45.AY19
M_B_DQ41: JDIM1.41 U45.AW19
M_B_DQ42: JDIM1.52 U45.AY17
M_B_DQ43: JDIM1.51 U45.AW17
M_B_DQ44: JDIM1.39 U45.AV19
M_B_DQ45: JDIM1.53 U45.AU19
M_B_DQ46: JDIM1.50 U45.AV17
M_B_DQ47: JDIM1.42 U45.AU17
M_B_DQ48: JDIM1.192 U45.AR21
M_B_DQ49: JDIM1.182 U45.AR22
M_B_DQ50: JDIM1.193 U45.AL21
M_B_DQ51: JDIM1.183 U45.AM22
M_B_DQ52: JDIM1.180 U45.AN22
M_B_DQ53: JDIM1.191 U45.AP21
M_B_DQ54: JDIM1.194 U45.AK21
M_B_DQ55: JDIM1.181 U45.AK22
M_B_DQ56: JDIM1.69 U45.AN20
M_B_DQ57: JDIM1.67 U45.AR20
M_B_DQ58: JDIM1.56 U45.AK18
M_B_DQ59: JDIM1.58 U45.AL18
M_B_DQ60: JDIM1.59 U45.AK20
M_B_DQ61: JDIM1.57 U45.AM20
M_B_DQ62: JDIM1.68 U45.AR18
M_B_DQ63: JDIM1.70 U45.AP18
M_B_DQS0: JDIM1.137 U45.AV30
M_B_DQS1: JDIM1.12 U45.AW26
M_B_DQS2: JDIM1.154 U45.AM28
M_B_DQS3: JDIM1.29 U45.AM25
M_B_DQS4: JDIM1.171 U45.AV22
M_B_DQS5: JDIM1.47 U45.AW18
M_B_DQS6: JDIM1.188 U45.AM21
M_B_DQS7: JDIM1.64 U45.AM18
M_B_DQS#0: JDIM1.135 U45.AW30
M_B_DQS#1: JDIM1.10 U45.AV26
M_B_DQS#2: JDIM1.152 U45.AN28
M_B_DQS#3: JDIM1.27 U45.AN25
M_B_DQS#4: JDIM1.169 U45.AW22
M_B_DQS#5: JDIM1.45 U45.AV18
M_B_DQS#6: JDIM1.186 U45.AN21
M_B_DQS#7: JDIM1.62 U45.AN18
M_B_ODT0: TP78.1 U45.AL32
M_B_ODT0_DIMM: JDIM1.116 R709.2
M_B_ODT1_DIMM: JDIM1.120 R710.2
M_B_RAS#: JDIM1.110 U45.AM35
M_B_WE#: JDIM1.113 U45.AK35
MAIND: PC82.2 PQ25.3 PQ32.4 PQ47.2 PQ54.2 PQ55.4 PR118.2
MAINON: PQ23.2 PR109.1 PR110.1 PR171.1 PR218.2 R328.2 R347.1 U32.80
MAINON_ON_G: PQ19.2 PQ23.3 PQ25.2 PQ27.2 PQ28.2 PQ33.2 PR115.2 PR119.1
MBCLK: PD4.1 PR96.2 PR202.1 R301.1 U32.110
MBDATA: PD3.1 PR87.2 PR200.1 R313.1 U32.111
MCT1: R6.1 U4.3 U4.4
MCT2: R7.1 U7.1 U7.2
MCT3: R455.1 U36.3 U36.4
MCT4: R449.1 U35.1 U35.2
MDI0+: C9.2 R1.2 U1.4 U1.5 U24.1
MDI0-: C7.2 R2.2 U1.3 U1.6 U24.2
MDI1+: C50.2 R27.2 U8.2 U8.7 U24.4
MDI1-: C49.2 R29.2 U8.1 U8.8 U24.5
MDI2+: C521.2 R434.2 U1.1 U1.8 U24.6
MDI2-: C522.2 R438.2 U1.2 U1.7 U24.7
MDI3+: C552.2 R460.2 U8.4 U8.5 U24.9
MDI3-: C566.2 R464.2 U8.3 U8.6 U24.10
ME_WR#: R658.2 U32.106
MIC2-L: C510.2 U34.17
MIC2-R: C511.2 U34.18
MIC2-VREFO: R421.1 U34.29
MIC2_MIC: C510.1 C511.1 R420.1
MODPHY_EN: TP43.1 U45.Y2
MX0: C476.2 CN15.1 RP1.4 U32.58
MX1: C481.2 CN15.2 RP1.3 U32.59
MX2: CN15.3 CP4.4 RP1.2 U32.60
MX3: CN15.4 CP4.2 RP1.1 U32.61
MX4: CN15.5 CP5.8 RP1.6 U32.62
MX5: CN15.6 CP5.6 RP1.7 U32.63
MX6: CN15.7 CP5.4 RP1.9 U32.64
MX7: CN15.8 CP5.2 RP1.8 U32.65
MY0: CN15.26 CP6.8 U32.36
MY1: CN15.25 CP6.6 U32.37
MY2: CN15.24 CP6.4 U32.38
MY3: CN15.23 CP6.2 U32.39
MY4: CN15.22 CP1.8 U32.40
MY5: CN15.21 CP1.6 U32.41
MY6: CN15.20 CP1.4 U32.42
MY7: CN15.19 CP1.2 U32.43
MY8: CN15.18 CP2.8 U32.44
MY9: CN15.17 CP2.6 U32.45
MY10: CN15.16 CP2.4 U32.46
MY11: CN15.15 CP2.2 U32.51
MY12: CN15.14 CP3.8 U32.52
MY13: CN15.13 CP3.6 U32.53
MY14: CN15.12 CP3.4 U32.54
MY15: CN15.11 CP3.2 U32.55
MY16: CN15.10 CP4.6 U32.56
MY17: CN15.9 CP4.8 U32.57
N12E_SCL: R632.1 U43.C9
N12E_SDA: R612.1 U43.C8
NBSWON#: CN6.10 R310.1 R729.2 SW1.2 TP130.1 U32.125
NOA_STBN_0: TP132.1 U45.AA62
NOA_STBN_1: TP69.1 U45.U63
NOA_STBP_0: TP52.1 U45.AA61
NOA_STBP_1: TP141.1 U45.U62
NV_PLLVDD: C167.2 C234.2 L15.2 U43.L6
ODD_PRSNT#: R635.1 U45.AN3
OPI_COMP1: R654.2 U45.AY15
OPI_COMP2: R664.2 U45.AW15
PCBEEP: C508.1 U34.12
PCBEEP_EC: D20.2 U32.34
PCH_ACPRESENT: R219.1 R234.1 R239.2 U45.AJ8
PCH_AZ_CODEC_BITCLK: C498.2 C679.2 R652.1 U34.6
PCH_AZ_CODEC_RST#: C503.1 D17.1 R659.1 U34.11
PCH_AZ_CODEC_SDIN0: R405.2 U45.AY10
PCH_AZ_CODEC_SDOUT: R657.1 U34.5
PCH_AZ_CODEC_SYNC: R684.1 U34.10
PCH_BATLOW#: R226.1 R237.1 U45.AN4
PCH_BLON: Q18.5 R191.1 R193.2 U45.A9
PCH_BLON_EC: R193.1 U32.119
PCH_BRIGHT: R502.1 R671.2 U45.B8
PCH_INTVRMEN: R660.1 R676.2 U45.AV7
PCH_JTAG_TDO: R162.2 R164.2 U45.AE61
PCH_JTAGX: R594.1 R597.2 U45.AE63
PCH_PWRBTN#: R221.1 R235.1 R236.2 U45.AL7
PCH_PWROK: R352.2 R356.2 R518.2 U32.78
PCH_RSMRST#: R663.1 R678.2 U45.AW6
PCH_SLP_A#: R733.2 U45.AL5
PCH_SLP_LAN#: TP67.1 U45.AJ7
PCH_SLP_S0#: R598.1 R727.2
PCH_SLP_S0#_R: R598.2 U45.AF3
