# Allegro board DA0Z8CMB8D0-D-gina-165.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 78.5,133.99 78.5,123.05 76.32,120.87 72.78,120.87 72.4,121.25 66.3,121.25 66.18,121.38 66.18,122.27 66.3,122.39 72.91,122.39 73.16,122.14 73.16,122.14 73.61,121.69 74.42,121.69 74.69,121.95 74.69,124.68 75.07,125.06 75.07,127.47 75.32,127.73 76.34,127.73 76.34,130.78 76.84,131.28 76.84,133.41 76.84,133.7 76.85,133.71 76.85,133.94 76.98,134.07 78.42,134.07
GND on TOP (solid shape): 47.46,93.91 51.57,93.91 51.72,93.76 55.51,93.76 56.47,92.8 56.47,90.76 54.3,88.59 54.3,80.01 54.16,79.87 48.73,79.87 48.35,80.25 48.35,80.78 49.06,81.49 50.15,81.49 51.22,82.56 51.22,84.52 51.57,84.87 51.57,89.7 48.62,92.64 47.77,92.64 46.76,93.66 46.16,93.66 45.93,93.89 45.93,94.5 46.01,94.57 46.8,94.57
GND on TOP (solid shape): 41.36,99.42 41.36,98.79 41.61,98.54 41.61,96 41.23,95.61 38.95,95.61 38.82,95.74 38.82,98.54 38.85,98.61 38.93,98.64 39.23,98.78 39.28,99.12 39.3,99.23 39.29,99.35 39.28,99.36 39.29,99.39 39.58,99.68 41.11,99.68
GND on TOP (solid shape): 32.85,71.99 33.71,71.99 33.99,71.71 33.99,69.96 34.63,69.32 34.88,69.32 34.88,69.33 35.39,69.33 35.65,69.07 35.65,66.53 35.52,66.4 35.01,66.4 34.31,67.11 34.3,67.14 34.31,67.16 34.35,67.37 34.25,67.57 34.25,68.69 33.36,69.58 29.4,69.58 29.37,69.59 29.35,69.63 29.35,73.34 29.37,73.38 29.4,73.39 31.45,73.39
GND on TOP (solid shape): 236.46,3.64 236.46,3.51 236.44,3.2 236.55,2.9 236.56,2.89 236.56,2.65 236.45,2.54 233.37,2.54 233.26,2.65 233.26,3.41 233.38,3.54 234.45,3.54 234.47,3.54 234.49,3.52 235.03,3.29 235.57,3.52 235.6,3.54 235.67,3.54 235.92,3.79 236.31,3.79
GND on TOP (solid shape): 31.45,137.27 31.45,131.89 31.44,131.86 31.4,131.84 30.72,131.84 30.57,131.99 30.57,132.44 30.51,132.5 30.51,132.54 29.71,133.34 29.67,133.34 29.17,133.84 28.03,133.84 27.9,133.97 27.9,135.14 28.38,135.62 28.79,135.62 29.19,136.03 29.55,136.03 29.8,136.13 29.9,136.38 29.89,136.5 29.83,136.6 29.82,136.62 29.82,136.65 29.83,136.67 30.57,137.4 31.33,137.4
GND on TOP (solid shape): 47.13,147.92 47.13,147.79 46.87,147.54 46.87,147.29 46.95,147.21 47.01,147.12 47.13,147.03 47.13,146.9 47,146.78 46.75,146.78 46.63,146.89 46.63,146.91 46.63,146.93 46.53,147.25 46.21,147.35 46.18,147.35 46.16,147.36 46.11,147.41 46.1,147.4 46.09,147.41 45.83,147.41 45.76,147.49 45.76,147.92 45.88,148.05 47,148.05
GND on TOP (solid shape): 114.51,119.62 126.98,119.62 127.49,119.11 128.05,119.11 128.13,119.03 128.13,118.25 127.29,117.41 127.21,117.38 127.14,117.42 127.06,117.49 126.98,117.55 126.53,117.5 126.37,117.07 126.35,116.99 126.27,116.95 117.31,116.95 114.64,114.28 110.58,114.28 110.32,114.54 110.32,115.55 110.58,115.81 110.96,115.81 111.08,115.93 111.72,115.93 112.73,116.95 112.73,119.49 112.99,119.74 114.39,119.74
GND on TOP (solid shape): 178.14,51.88 178.14,49.39 177.89,49.13 177.86,49.13 177.76,49.03 176.49,49.03 175.37,47.91 175.37,46.59 175.22,46.45 174.45,46.45 174.11,46.11 170.42,46.11 170.27,46.26 170.27,47.13 173.29,47.13 173.29,47.07 173.3,47.02 173.31,46.97 173.33,46.92 173.36,46.88 173.4,46.84 173.44,46.81 173.49,46.78 173.54,46.76 173.59,46.75 173.64,46.74 173.7,46.75 173.75,46.76 173.8,46.78 173.84,46.81 173.89,46.84 173.92,46.88 173.95,46.92 173.98,46.97 173.99,47.02 174,47.07 174,47.13 173.99,47.18 173.98,47.23 173.95,47.28 173.92,47.32 173.89,47.36 173.84,47.4 173.8,47.42 173.75,47.44 173.7,47.45 173.64,47.46 173.59,47.45 173.54,47.44 173.49,47.42 173.44,47.4 173.4,47.36 173.36,47.32 173.33,47.28 173.31,47.23 173.3,47.18 173.29,47.13 170.27,47.13 170.27,50.78 170.77,51.29 172.98,51.29 173.95,52.26 177.76,52.26
GND on TOP (solid shape): 77.05,53.58 77.05,52.71 77.05,52.66 77.03,52.63 77,52.58 76.98,52.53 76.97,52.47 76.97,52.42 76.97,52.38 76.97,52.36 76.03,51.42 72.73,51.42 72.48,51.67 72.48,52.87 76.08,52.87 76.08,52.81 76.09,52.76 76.11,52.71 76.13,52.66 76.16,52.62 76.19,52.58 76.24,52.55 76.28,52.52 76.33,52.5 76.38,52.49 76.44,52.48 76.49,52.49 76.54,52.5 76.59,52.52 76.64,52.55 76.68,52.58 76.72,52.62 76.75,52.66 76.77,52.71 76.79,52.76 76.79,52.81 76.79,52.87 76.79,52.92 76.77,52.97 76.75,53.02 76.72,53.06 76.68,53.1 76.64,53.14 76.59,53.16 76.54,53.18 76.49,53.19 76.44,53.2 76.38,53.19 76.33,53.18 76.28,53.16 76.24,53.14 76.19,53.1 76.16,53.06 76.13,53.02 76.11,52.97 76.09,52.92 76.08,52.87 72.48,52.87 72.48,53.07 73.11,53.7 76.92,53.7
GND on TOP (solid shape): 45.86,129.35 45.86,129.07 46.23,128.71 46.78,128.71 46.8,128.69 47.86,128.69 48.09,128.46 48.09,128.13 47.46,127.49 46.69,127.49 46.49,127.29 46.49,125.94 46.39,125.72 46.46,125.48 46.19,125.21 46.19,123.55 46.06,123.43 45.68,123.43 45.55,123.55 45.55,124.06 45.32,124.29 45.32,125.39 44.93,125.79 44.92,125.79 44.86,125.87 44.78,125.93 44.59,126.13 44.28,126.13 44.1,125.95 44.1,125.72 43.85,125.47 42.22,125.47 41.74,125.95 41.74,126.22 42.05,126.53 42.05,127.36 42.18,127.5 43.34,127.5 43.52,127.68 43.52,128.82 43.39,128.95 43.39,128.97 43.37,128.97 43.18,129.16 43.18,129.42 43.29,129.53 43.66,129.53 44.29,128.9 44.63,128.9 44.75,129.01 44.82,129.08 44.84,129.15 45.25,129.56 45.65,129.56
GND on TOP (solid shape): 26.84,104.5 26.92,104.48 26.95,104.4 27.3,104.05 27.66,104.4 27.69,104.48 27.76,104.5 27.8,104.5 27.83,104.49 27.83,104.48 28.15,104.28 28.47,104.48 28.48,104.49 28.5,104.5 29.53,104.5 29.64,104.43 29.78,104.4 29.81,104.4 29.98,104.23 29.98,100.57 29.8,100.39 29.8,99.55 29.93,99.42 29.93,97.01 29.8,96.88 29.17,96.88 25.99,100.06 25.99,103.74 26.76,104.5
GND on TOP (solid shape): 238.69,85.71 238.69,85.46 238.69,85.43 238.67,85.42 238.23,84.28 239.2,83.55 248.92,83.55 248.96,83.54 248.97,83.5 248.97,80.32 248.96,80.28 248.92,80.27 239.2,80.27 238.23,79.54 238.67,78.4 238.69,78.39 238.69,78.36 238.69,78.09 238.44,77.83 236.69,77.83 234.91,79.61 234.91,84.44 236.43,85.96 238.44,85.96
GND on TOP (solid shape): 134.32,142.48 134.32,139.09 134.29,139.04 134.27,139.03 134.1,138.92 134.02,138.74 134.02,138.65 134.04,138.56 134.05,138.55 134.04,138.52 133.94,138.41 131.78,138.41 131.66,138.54 131.66,139.43 131.4,139.68 127.47,139.68 126.83,139.05 126.73,139.05 126.69,139.06 126.68,139.09 126.19,139.38 126.04,138.83 126.05,138.8 126.04,138.76 125.94,138.67 125.94,138.08 125.61,137.75 124.29,137.75 124.04,138.01 124.04,138.39 124.05,138.42 124.08,138.44 124.39,138.79 124.08,139.15 124.06,139.15 124.04,139.18 124.04,141.21 124.16,141.33 132.55,141.33 132.74,141.53 132.79,141.53 132.79,141.58 133.05,141.84 133.05,142.48 133.18,142.6 134.2,142.6
GND on TOP (solid shape): outline of 102 points within 40.4,147.16 42.81,151.98
GND on TOP (solid shape): outline of 112 points within 46.06,117.08 53.68,124.06
GND on TOP (solid shape): 76.13,152 78.08,152 78.63,151.46 78.63,149 78.62,149 78.62,137.25 78.11,136.74 77.8,136.74 77.71,136.84 77.71,138.42 77.48,138.65 76.72,138.65 76.59,138.78 76.59,140.17 76.97,140.55 76.97,143.22 76.59,143.6 76.59,146.52 76.79,146.72 76.79,147.95 77.35,148.51 77.35,149.95 77.1,150.21 75.83,150.21 75.57,149.95 66.98,149.95 66.68,150.03 66.39,149.95 65.21,149.95 65.19,149.96 65.17,149.97 65.14,150 64.66,150 64.62,150.02 64.61,150.05 64.61,150.46 64.58,150.65 64.49,150.81 64.48,150.85 64.49,150.88 65.24,151.63 65.26,151.64 65.51,151.68 65.71,151.82 65.76,151.86 66.13,151.86 66.38,152.11 67.02,152.11 67.32,152.03 67.62,152.11 68.16,152.11 68.46,152.03 68.76,152.11 69.69,152.11 69.98,152.03 70.27,152.1 70.3,152.11 70.41,152.21 70.49,152.3 70.7,152.51 70.7,154.03 71.18,154.52 73.62,154.52
GND on TOP (solid shape): outline of 113 points within 162.01,73.9 163.79,85.07
GND on TOP (solid shape): 125.77,173.45 125.81,173.44 125.82,173.4 125.82,169.02 125.81,168.98 125.77,168.97 125.63,168.97 125.13,168.76 124.92,168.26 124.92,166.86 125.13,166.36 125.63,166.15 125.77,166.15 125.81,166.14 125.82,166.1 125.82,162.26 126.03,161.76 126.53,161.55 128.33,161.55 128.48,161.4 128.48,160.28 128.23,160.03 121.24,160.03 113.9,167.37 111.97,167.37 111.85,167.5 111.85,168.13 111.92,168.2 114.99,168.2 115.02,168.19 115.04,168.17 116.72,167.23 117.96,168.71 117.96,170.4 117.97,170.44 118.01,170.45 124.46,170.45 124.46,173.4 124.47,173.44 124.51,173.45
GND on TOP (solid shape): 238.69,67.8 238.69,67.46 238.69,67.43 238.67,67.42 238.23,66.28 239.2,65.55 248.32,65.55 248.36,65.54 248.37,65.5 248.37,64.52 248.36,64.48 248.32,64.47 247.98,64.47 246.91,64.03 246.47,62.96 246.47,31.56 246.91,30.49 247.98,30.05 248.38,30.05 249.43,29.62 249.87,28.56 249.87,23.58 249.51,23.22 245.32,23.22 243.54,25 243.54,28.3 244.94,29.7 244.94,29.93 245.2,30.18 245.2,51.42 244.95,51.67 244.95,55.35 244.43,55.86 239.61,55.86 238.97,56.5 238.97,59.29 235.29,62.98 235.29,66.91 236.31,67.93 238.56,67.93
GND on TOP (solid shape): outline of 141 points within 39.51,128.87 48.9,136.62
GND on TOP (solid shape): 47.11,160.39 47.11,160.17 47.1,160.17 47.1,158.48 47.07,158.43 47.02,158.44 46.97,158.46 46.52,158.91 46.52,160.07 46.54,160.48 46.16,160.64 45.9,160.39 45.98,160.04 45.99,160.03 46.01,159.99 46.01,158.7 46.61,158.1 46.61,158.1 46.76,157.95 46.97,157.94 47.06,157.93 47.1,157.84 47.1,157.44 47.11,157.33 47.11,157.31 47.1,157.29 47,157.19 46.77,157.19 46.75,157.2 46.73,157.21 46.44,157.37 46.14,157.21 46.12,157.2 46.1,157.19 45.86,157.19 45.35,157.7 45.35,157.84 45.35,157.86 45.37,157.88 45.5,158.15 45.37,158.43 45.35,158.45 45.35,158.47 45.35,158.69 45.38,158.74 45.39,158.74 45.57,159.05 45.39,159.36 45.38,159.37 45.35,159.41 45.35,159.77 45.37,159.91 45.35,160.03 45.35,160.04 45.35,160.62 45.6,160.87 46.62,160.87
GND on TOP (solid shape): 92.89,171.95 92.93,171.94 92.94,171.9 92.94,170.45 99.39,170.45 99.43,170.44 99.44,170.4 99.44,168.71 100.68,167.23 102.36,168.17 102.38,168.19 102.4,168.2 103.22,168.2 103.31,168.16 103.32,168.07 103.32,167.65 103.54,167.28 103.75,167.06 103.78,166.98 103.75,166.91 103.66,166.82 103.59,166.71 103.57,166.69 103.55,166.68 103.34,166.68 101.87,165.21 96.99,165.21 95.97,164.19 95.97,158.38 92.26,154.67 88.35,154.67 86.45,156.57 86.45,160.64 87.08,161.27 87.08,163.67 86.98,163.76 86.87,163.81 86.76,163.87 86.46,163.87 85.68,164.65 85.67,164.68 85.68,164.69 85.71,164.95 85.61,165.19 87.53,165.19 88.5,165.25 88.97,166.1 88.97,171.9 88.98,171.94 89.02,171.95
GND on TOP (solid shape): outline of 153 points within 57.03,131.41 62.11,134.2
GND on TOP (solid shape): outline of 188 points within 82,50.97 113.62,61.07
GND on TOP (solid shape): outline of 191 points within 35.52,125.59 39.76,136.64
GND on TOP (solid shape): outline of 341 points within 122.01,97.65 130.39,103.87
GND on TOP (solid shape): outline of 804 points within 28.03,137.65 41.11,146.8
GND on TOP (solid shape): outline of 880 points within 0.51,0.51 249.87,173.95
GND on TOP (solid shape): outline of 1048 points within 141.24,93.84 249.87,173.95
GND on BOTTOM (solid shape): 19.24,119.31 19.24,117.1 19.07,116.94 16.37,116.94 15.53,117.78 15.53,119.18 15.86,119.51 19.04,119.51
GND on BOTTOM (solid shape): 64.78,122.27 64.78,121.38 64.65,121.25 60.84,121.25 60.47,121.63 60.47,122.27 60.59,122.39 64.65,122.39
GND on BOTTOM (solid shape): 141.82,149.06 141.82,147.15 141.59,146.92 136.97,146.92 136.86,147.02 136.86,149.06 136.97,149.16 141.72,149.16
GND on BOTTOM (solid shape): 203.84,56.07 203.84,54.26 203.67,54.09 202.32,54.09 202.22,54.19 202.22,55.86 202.55,56.19 203.72,56.19
GND on BOTTOM (solid shape): 228.3,95.61 228.3,93.46 228.05,93.2 224.24,93.2 223.35,94.09 223.35,95.11 224.11,95.87 228.05,95.87
GND on BOTTOM (solid shape): 30.99,157.01 30.99,155.21 30.7,154.92 29.47,154.92 29.22,155.18 29.22,156.89 29.48,157.14 30.86,157.14
GND on BOTTOM (solid shape): 6.87,120.86 6.87,119.14 6.69,118.96 4.66,118.96 4.48,119.14 4.48,120.79 4.71,121.01 6.71,121.01
GND on BOTTOM (solid shape): 48.14,69.83 48.14,67.09 48.01,66.96 47.53,66.96 46.69,67.8 45.93,67.8 45.81,67.93 45.81,69.83 46.19,70.21 47.76,70.21
GND on BOTTOM (solid shape): 162.52,69.83 162.52,65.39 161.76,64.63 159.72,64.63 159.47,64.88 159.47,65.01 159.09,65.39 159.09,69.96 159.22,70.09 162.26,70.09
GND on BOTTOM (solid shape): 171.54,64.83 171.54,63.69 171.28,63.43 171.28,61.93 170.9,61.55 166.1,61.55 165.97,61.68 165.97,63.84 167.06,64.93 171.43,64.93
GND on BOTTOM (solid shape): 179.28,84.72 179.28,81.09 178.9,80.71 175.52,80.71 175.35,80.88 175.35,84.41 175.7,84.77 179.23,84.77
GND on BOTTOM (solid shape): 234.87,41.65 236.75,41.65 236.94,41.46 236.94,38.08 236.81,37.96 232.75,37.96 232.62,38.08 232.62,41.77 232.88,42.02 234.5,42.02
GND on BOTTOM (solid shape): 48.09,77.81 48.09,75.8 47.84,75.55 45.81,75.55 44.41,76.95 44.41,78.6 44.51,78.6 44.83,78.91 46.99,78.91
GND on BOTTOM (solid shape): 21.04,123.58 21.04,121.65 20.79,121.4 18.49,121.4 16.38,123.5 16.38,124.18 16.39,124.22 16.43,124.23 20.39,124.23
GND on BOTTOM (solid shape): 116.49,53.67 117.62,53.67 117.65,53.7 122.51,53.7 122.77,53.45 122.77,52.69 121.5,51.42 115.02,51.42 114.77,51.67 114.77,53.58 114.89,53.7 116.45,53.7
GND on BOTTOM (solid shape): 184.26,52.54 184.26,51.32 184.64,50.94 184.64,50.63 184.44,50.43 183.32,50.43 182.15,51.6 182.15,52.33 182.46,52.64 184.16,52.64
GND on BOTTOM (solid shape): 199.55,66.48 199.55,65.85 199.48,65.77 199.22,65.77 199.09,65.64 199.09,63.99 198.84,63.74 195.92,63.74 195.92,66.4 196.05,66.53 199.5,66.53
GND on BOTTOM (solid shape): 196.22,75.83 196.22,75.22 195.82,74.81 195.82,73.92 195.97,73.77 196.48,73.77 196.58,73.67 196.58,73.03 196.27,72.73 193.25,72.73 193.15,72.83 193.15,75.78 193.28,75.9 196.15,75.9
GND on BOTTOM (solid shape): 38.44,89.9 38.44,88.73 38.21,88.5 35.59,88.5 35.44,88.66 35.44,88.98 35.47,89.01 35.47,89.39 35.44,89.42 35.44,89.47 34.71,90.2 34.71,91.78 34.94,92.01 36.33,92.01
GND on BOTTOM (solid shape): 39.15,84.31 39.15,80.4 38.84,80.09 35.08,80.09 34.5,80.67 34.5,82.15 34.63,82.28 35.16,82.28 35.59,81.85 37.29,81.85 37.75,82.31 37.75,84.16 37.96,84.36 39.1,84.36
GND on BOTTOM (solid shape): 53.77,84.82 53.77,82.32 54.31,81.77 54.31,80.08 53.89,79.66 51.98,79.66 51.62,80.02 51.62,80.65 51.39,80.88 50.2,80.88 50.2,84.72 50.35,84.88 53.71,84.88
GND on BOTTOM (solid shape): 58.86,166.15 58.86,164.79 57.92,163.85 57.92,163.54 57.79,163.41 57.41,163.41 57.16,163.67 51.06,163.67 50.94,163.54 50.3,163.54 50.17,163.67 50.17,166.21 50.3,166.34 58.68,166.34
GND on BOTTOM (solid shape): 105.58,154.54 105.77,154.52 105.96,154.54 105.97,154.54 106.13,154.54 106.26,154.42 106.26,150.1 106.13,149.97 101.81,149.97 101.69,150.1 101.69,154.42 101.81,154.54 105.57,154.54
GND on BOTTOM (solid shape): 105.75,41.97 105.75,39.82 105.55,39.62 100.31,39.62 99.96,39.97 99.89,40.15 99.8,40.33 99.8,41.62 99.81,41.64 99.82,41.66 100.36,42.2 100.76,42.6 105.11,42.6
GND on BOTTOM (solid shape): 158.3,122.8 158.3,122.79 158.3,122.59 158.15,122.44 157.51,122.44 157.06,121.98 157.06,121.47 156.98,121.4 156.6,121.4 156.52,121.47 156.52,122.03 157.16,122.67 157.16,122.97 157.23,123.05 158.05,123.05
GND on BOTTOM (solid shape): 134.45,154.16 138.64,154.16 138.9,153.91 138.9,152.76 138.77,152.64 136.1,152.64 135.72,153.02 134.2,153.02 133.82,152.64 133.82,151.11 133.18,150.48 130.77,150.48 130.26,150.99 130.26,154.54 130.51,154.8 133.82,154.8
GND on BOTTOM (solid shape): 187.16,79.08 187.16,74.99 187.08,74.91 185.96,74.91 185.78,75.09 184.21,75.09 184.03,75.27 184.03,76.46 184.01,76.49 183.98,76.49 183.8,76.67 182.05,76.67 182.05,79.03 182.66,79.64 186.6,79.64
GND on BOTTOM (solid shape): 205.27,48.98 205.27,45 205.22,44.82 205.26,44.64 205.27,44.63 205.27,44.45 204.23,43.42 201.15,43.42 200.62,43.95 200.62,48.5 201.25,49.13 205.11,49.13
GND on BOTTOM (solid shape): 217.76,86.34 217.76,86.29 217.76,86.28 217.71,86.08 217.76,85.89 217.76,84.06 217.64,83.93 213.83,83.93 213.7,84.06 213.7,86.34 213.83,86.47 217.64,86.47
GND on BOTTOM (solid shape): 191.6,70.8 191.6,65.49 190.47,64.36 187.17,64.36 187.16,64.35 187.16,64.47 187.16,64.49 187.16,66.77 187.41,67.03 189.53,67.03 189.95,67.45 189.95,71.08 190.08,71.21 191.19,71.21
GND on BOTTOM (solid shape): 31.03,165.55 40.14,165.55 40.52,165.16 40.52,164.68 40.4,164.56 38.49,164.56 37.86,163.92 31.99,163.92 31.61,164.3 30.74,164.3 30.49,164.05 30.49,161.89 30.87,161.51 30.87,158.84 30.78,158.75 29.42,158.75 29.09,159.08 29.09,164.94 29.73,165.57 31,165.57
GND on BOTTOM (solid shape): 188.27,62.77 190.86,62.77 191.09,62.54 191.09,58.91 190.95,58.77 190.17,58.77 189.92,58.53 189.92,57.74 189.82,57.64 186.29,57.64 185.89,58.05 185.89,58.84 185.9,58.85 185.9,60.32 184.49,61.73 184.49,62.54 184.72,62.77 188.22,62.77 188.25,62.8
GND on BOTTOM (solid shape): 55.21,76.31 55.21,76.31 55.29,76.24 55.29,73.9 55.28,73.87 55.25,73.85 55.24,73.84 55.21,73.85 55.21,73.81 55.2,73.78 55.16,73.76 51.77,73.76 51.49,74.04 51.49,76.1 51.71,76.32 52.65,76.32 52.65,76.33 55.19,76.33
GND on BOTTOM (solid shape): 205.39,67.45 205.39,64.45 204.68,63.74 201.84,63.74 201.25,63.15 201.25,62.39 201.48,62.16 202.9,62.16 202.98,62.09 202.98,58.48 202.5,58 200.67,58 200.57,58.1 200.57,59.9 199.63,60.84 199.63,63.31 200.26,63.94 200.26,64.86 200.82,65.41 202.6,65.41 203.08,65.9 203.08,67.5 203.23,67.65 205.19,67.65
GND on BOTTOM (solid shape): 233.63,90.28 233.89,90.22 234.15,90.28 234.8,90.28 235.11,90.14 235.45,90.2 235.48,90.2 235.51,90.19 235.54,90.15 235.54,88.76 235.16,88.38 231.35,88.38 231.23,88.5 231.23,89.9 231.35,90.03 232.88,90.03 233.13,90.28
GND on BOTTOM (solid shape): 78.5,133.99 78.5,123.02 76.34,120.86 72.79,120.86 72.4,121.25 71.74,121.25 66.3,121.25 66.18,121.38 66.18,122.27 66.3,122.39 72.91,122.39 73.16,122.14 73.16,122.13 73.5,121.8 74.45,121.8 74.69,122.04 74.69,124.68 75.07,125.06 75.07,127.47 75.32,127.73 76.1,127.73 76.34,127.97 76.34,130.87 76.84,131.38 76.84,133.82 76.84,133.82 76.84,133.99 76.92,134.07 78.42,134.07
GND on BOTTOM (solid shape): 171.41,52.66 177.3,52.66 177.83,52.13 177.83,50.5 177.85,50.49 177.85,49.81 177.89,49.77 177.89,48.75 177.5,48.37 174.45,48.37 173.89,48.92 169.05,48.92 168.11,49.87 168.11,51.08 168.11,51.1 168.12,51.12 168.26,51.42 168.12,51.72 168.11,51.74 168.11,51.76 168.11,53.63 168.26,53.78 170.29,53.78
GND on BOTTOM (solid shape): 44.92,100.62 44.92,99.83 44.73,99.64 42.01,99.64 41.49,99.12 41.49,97.06 41.46,97.04 41.46,95.77 41.49,95.77 41.87,95.39 42.73,95.39 42.96,95.16 42.96,94.07 42.91,94.01 40.29,94.01 39.99,93.71 38.54,93.71 38.41,93.84 38.41,95.18 38.69,95.46 38.69,98.2 39.35,98.87 39.35,99.88 39.84,100.36 40.04,100.56 40.03,100.84 40.03,100.86 40.03,100.89 40.31,101.16 44.37,101.16
GND on BOTTOM (solid shape): 101.4,53.7 101.42,53.7 101.44,53.68 101.76,53.48 102.08,53.68 102.09,53.69 102.11,53.7 104.27,53.7 104.45,53.65 104.64,53.7 110.32,53.7 110.7,53.32 110.7,51.16 110.58,51.04 98.13,51.04 97.75,51.42 97.75,53.2 98.26,53.7
GND on BOTTOM (solid shape): 110.86,129.87 110.86,129.84 110.88,129.82 110.89,129.78 110.89,129.72 110.88,129.68 110.86,129.66 110.86,129.63 110.83,129.56 110.83,129.53 110.83,129.52 110.83,129.14 110.9,129.07 110.9,128.72 111.31,128.32 111.65,128.32 111.72,128.25 111.72,128.13 111.46,127.87 111.34,127.87 110.83,128.38 110.58,128.38 110.07,127.87 109.94,127.87 109.81,128 109.81,128.81 109.92,128.92 109.92,129 109.94,129.02 110.07,129.02 110.32,129.27 110.32,129.52 110.37,129.58 110.41,129.58 110.54,129.7 110.57,129.77 110.7,129.9 110.83,129.9
GND on BOTTOM (solid shape): 131.34,48.11 132.07,48.11 132.41,47.77 132.41,47.69 132.41,46.7 132.41,46.6 132.55,46.46 133.8,46.46 133.83,46.45 133.84,46.43 133.85,46.41 133.85,44.81 133.8,44.75 132.2,44.75 132.17,44.76 132.16,44.78 132.15,44.81 132.15,45.64 132.1,45.7 130.9,45.7 130.7,45.9 130.7,46.19 130.9,46.19 130.9,46.01 130.91,46 131.9,46 131.91,46 131.91,46.19 131.9,46.2 130.91,46.2 130.9,46.19 130.7,46.19 130.7,46.99 130.45,47.24 129,47.24 128.9,47.35 128.9,48.44 129,48.54 130.91,48.54
GND on BOTTOM (solid shape): 28.29,105.5 28.29,104.63 28.28,104.59 28.24,104.58 27.64,104.58 27.62,104.58 27.6,104.6 26.94,104.4 27.6,104.21 27.62,104.23 27.64,104.23 28.4,104.23 30.36,102.27 30.36,100.75 29.44,99.83 26.76,99.83 26.18,100.4 26.18,105.2 26.7,105.72 28.08,105.72
GND on BOTTOM (solid shape): 59.52,55.86 59.52,54.47 59.14,54.09 59.14,53.15 59.1,53.07 59.01,53.06 58.56,52.71 59.01,52.37 59.1,52.36 59.14,52.27 59.14,51.68 58.89,51.42 57.03,51.42 56.82,51.63 56.82,51.83 56.83,51.9 56.82,51.97 56.82,52.49 56.83,52.56 56.82,52.63 56.82,56.09 57.36,56.63 58.76,56.63
GND on BOTTOM (solid shape): 95.59,70.6 97.37,70.6 97.75,70.21 97.75,68.56 97.72,68.53 97.7,68.53 97.38,68.17 97.7,67.82 97.73,67.8 97.75,67.77 97.75,66.02 97.72,65.99 97.7,65.99 97.38,65.63 97.7,65.28 97.73,65.26 97.75,65.23 97.75,65.13 97.37,64.75 93.18,64.75 92.8,65.13 92.8,71.1 93.18,71.48 94.7,71.48
GND on BOTTOM (solid shape): 11.9,149.46 12.15,149.36 12.4,149.46 14.18,149.46 14.56,149.08 14.56,143.49 14.31,143.24 10.88,143.24 10.37,143.75 10.37,146.94 10.43,147.03 10.55,147.01 11.15,147.26 10.55,147.52 10.43,147.49 10.37,147.59 10.37,149.08 10.75,149.46
GND on BOTTOM (solid shape): 65.36,53.58 65.36,52.43 64.78,51.85 64.78,51.5 64.7,51.42 63.97,51.42 63.12,52.26 63.12,52.6 63.13,52.63 63.14,52.64 63.11,53.26 62.59,52.92 62.57,52.85 62.49,52.82 61.43,52.82 61.17,53.07 61.17,53.73 61.19,53.76 61.2,53.77 61.37,53.95 61.38,54.2 61.39,54.3 61.48,54.34 64.6,54.34
GND on BOTTOM (solid shape): 124.42,150.86 124.42,141.72 124.16,141.46 123.4,141.46 123.15,141.72 123.15,142.48 122.64,142.99 119.46,142.99 119.42,143 119.41,143.04 119.41,143.09 119.08,143.42 119.08,146.62 119.13,146.71 119.22,146.71 122.53,147.47 122.89,150.85 122.89,150.99 123.02,151.11 124.16,151.11
GND on BOTTOM (solid shape): 238.69,85.71 238.69,85.46 238.69,85.43 238.67,85.42 238.23,84.28 239.2,83.55 248.92,83.55 248.96,83.54 248.97,83.5 248.97,80.32 248.96,80.28 248.92,80.27 239.2,80.27 238.23,79.54 238.67,78.4 238.69,78.39 238.69,78.36 238.69,78.09 238.44,77.83 236.81,77.83 235.42,79.23 235.42,84.06 237.32,85.96 238.44,85.96
GND on BOTTOM (solid shape): 77.56,53.58 77.56,53.14 77.52,53.07 77.44,53.04 77.36,53.04 77.27,53.02 77,53.02 76.93,52.95 76.84,52.92 76.76,52.98 76.12,52.99 76.54,52.5 76.63,52.48 76.67,52.4 76.67,52.13 75.24,50.71 75.24,49.69 75.85,49.08 78.95,49.08 79.21,48.83 79.21,48.5 79.33,48.37 80.98,48.37 81.11,48.24 81.11,46.72 81.03,46.64 71.15,46.64 70.95,46.85 70.95,49.13 70.54,49.54 69.66,49.54 69.53,49.67 69.53,51.47 69.73,51.67 71.71,51.67 72.09,52.05 72.09,52.94 72.48,53.32 73.24,53.32 73.62,53.7 77.43,53.7
GND on BOTTOM (solid shape): outline of 91 points within 79.21,103.23 84.79,108.19
GND on BOTTOM (solid shape): outline of 97 points within 141.19,139.18 146.9,146.9
GND on BOTTOM (solid shape): outline of 105 points within 47.41,85.35 71.05,94.47
GND on BOTTOM (solid shape): outline of 120 points within 30.31,46.72 37.88,52.31
GND on BOTTOM (solid shape): 238.69,67.8 238.69,67.46 238.69,67.43 238.67,67.42 238.23,66.28 239.2,65.55 248.32,65.55 248.36,65.54 248.37,65.5 248.37,64.52 248.36,64.48 248.32,64.47 247.98,64.47 246.91,64.03 246.47,62.96 246.47,31.56 246.91,30.49 247.98,30.05 248.38,30.05 249.43,29.62 249.87,28.56 249.87,23.58 249.51,23.22 245.32,23.22 243.54,25 243.54,28.3 244.94,29.7 244.94,29.98 245.2,30.24 245.2,51.39 244.95,51.64 244.95,55.36 244.94,55.36 244.43,55.86 239.61,55.86 238.97,56.5 238.97,59.29 235.29,62.98 235.29,64.88 236.68,66.28 236.68,66.75 236.76,67.22 237.47,67.93 238.57,67.93
GND on BOTTOM (solid shape): 72.64,154.5 73.64,154.5 76.14,152 78.06,152 78.62,151.44 78.62,137.25 78.11,136.74 77.8,136.74 77.69,136.85 77.69,138.43 77.48,138.65 76.72,138.65 76.59,138.78 76.59,140.17 76.97,140.55 76.97,143.22 76.59,143.6 76.59,146.52 76.84,146.78 76.84,147.79 77.35,148.3 77.35,149.95 77.1,150.21 75.83,150.21 75.57,149.95 66.48,149.95 66.18,150.03 65.88,149.95 65.24,149.95 65.23,149.96 64.74,149.96 64.61,150.09 64.61,150.46 64.57,150.66 64.47,150.83 64.47,151.36 64.54,151.45 64.58,151.56 64.59,151.58 64.98,151.97 65.02,151.99 65.05,151.97 65.25,151.88 65.5,151.93 65.52,151.92 65.59,151.85 65.94,151.85 66.12,152.04 66.14,152.04 66.25,152.06 66.35,152.11 67.02,152.11 67.32,152.03 67.62,152.11 68.16,152.11 68.46,152.03 68.75,152.1 68.76,152.11 69.03,152.11 69.17,152.26 69.17,153.91 69.45,154.18 69.46,154.18 69.58,154.25 69.66,154.35 69.69,154.37 69.73,154.37 70.05,154.35 70.35,154.5 71.12,154.5 71.2,154.58 71.26,154.58 71.36,154.59 71.47,154.63 71.57,154.76 71.6,154.77 72.37,154.77
GND on BOTTOM (solid shape): outline of 147 points within 56.07,73.14 78.95,81.52
GND on BOTTOM (solid shape): outline of 169 points within 29.04,66.79 35.9,87.99
GND on BOTTOM (solid shape): 61.97,139.41 61.99,139.4 62.01,139.38 62.07,139.3 62.16,139.24 62.21,139.15 62.16,139.06 62.02,138.92 61.98,138.73 61.96,138.66 61.89,138.63 61.65,138.34 61.92,138.07 61.94,138.07 62.39,137.62 62.39,137.61 63.03,137.51 62.69,138.06 62.67,138.07 62.65,138.08 62.46,138.26 62.44,138.35 62.49,138.43 62.64,138.57 62.69,138.77 62.71,138.84 62.78,138.88 62.98,139.02 62.99,139.27 62.99,139.36 63.08,139.41 63.59,139.41 63.61,139.4 63.62,139.38 63.67,139.31 63.74,139.25 63.76,139.23 63.76,139.21 63.76,139.09 63.76,139.07 63.74,139.05 63.59,138.67 63.89,138.4 63.89,137.52 62.99,136.62 61.16,136.62 60.91,136.87 60.91,137.26 60.84,137.32 60.84,137.7 61.23,138.09 61.24,138.09 61.39,138.45 61.04,138.62 61.03,138.61 61,138.62 60.97,138.65 60.97,139.28 61.1,139.41
GND on BOTTOM (solid shape): outline of 183 points within 140.55,128.13 143.34,129.65
GND on BOTTOM (solid shape): outline of 185 points within 40.4,146.78 42.81,152.11
GND on BOTTOM (solid shape): 125.77,173.45 125.81,173.44 125.82,173.4 125.82,169.02 125.81,168.98 125.77,168.97 125.63,168.97 125.13,168.76 124.92,168.26 124.92,166.86 125.13,166.36 125.63,166.15 125.77,166.15 125.81,166.14 125.82,166.1 125.82,162.26 126.03,161.76 126.53,161.55 128.33,161.55 128.48,161.4 128.48,160.28 128.23,160.03 126.53,160.03 126.51,160 120.89,160 114.52,166.37 114.36,166.52 114.2,166.68 113.86,166.68 113.83,166.69 113.81,166.71 113.28,167.04 112.75,166.71 112.73,166.69 112.7,166.68 111.57,166.68 111.54,166.69 111.52,166.71 110.99,167.04 110.46,166.71 110.44,166.69 110.42,166.68 110.35,166.68 110.31,166.69 110.3,166.73 110.3,167.49 110.33,167.54 110.42,167.58 110.5,167.54 111.26,167.34 111.54,168.06 111.55,168.16 111.63,168.2 114.99,168.2 115.02,168.19 115.04,168.17 116.72,167.23 117.96,168.71 117.96,170.4 117.97,170.44 118.01,170.45 124.46,170.45 124.46,173.4 124.47,173.44 124.51,173.45
GND on BOTTOM (solid shape): outline of 279 points within 30.57,128.13 34.88,130.92
GND on BOTTOM (solid shape): 92.89,171.95 92.93,171.94 92.94,171.9 92.94,170.45 99.39,170.45 99.43,170.44 99.44,170.4 99.44,168.71 100.68,167.23 102.36,168.17 102.38,168.19 102.4,168.2 103.48,168.2 103.56,168.16 103.57,168.06 104.12,167.27 104.67,168.06 104.68,168.16 104.76,168.2 105.77,168.2 105.85,168.16 105.86,168.06 106.41,167.27 106.96,168.06 106.97,168.16 107.05,168.2 108.06,168.2 108.14,168.16 108.15,168.06 108.35,167.4 109.04,167.39 109.15,167.39 109.2,167.3 109.2,167.02 109.15,166.93 109.04,166.93 108.55,167.03 108.17,166.71 108.15,166.69 108.13,166.68 106.99,166.68 106.96,166.69 106.94,166.71 106.41,167.04 105.88,166.71 105.86,166.69 105.83,166.68 104.7,166.68 104.67,166.69 104.65,166.71 104.12,167.04 103.59,166.71 103.57,166.69 103.55,166.68 103.34,166.68 101.87,165.21 96.99,165.21 95.97,164.19 95.97,158.4 92.24,154.67 88.35,154.67 86.45,156.57 86.45,160.64 87.08,161.27 87.08,163.36 86.57,163.87 85.89,163.87 85.46,164.29 85.43,164.37 85.48,164.45 85.71,164.79 85.61,165.19 87.53,165.19 88.5,165.25 88.97,166.1 88.97,171.9 88.98,171.94 89.02,171.95
GND on BOTTOM (solid shape): outline of 350 points within 48.6,104.89 75.9,110.73
GND on BOTTOM (solid shape): outline of 386 points within 113.75,113.9 132.67,120.89
GND on BOTTOM (solid shape): outline of 712 points within 0.51,0.51 249.87,173.95
GND on BOTTOM (solid shape): outline of 1378 points within 141.24,93.84 249.87,173.95
GND on SGND (solid shape): outline of 2813 points within 0.51,0.51 249.87,173.95
GND on IN1 (solid shape): 106.26,154.42 106.26,150.1 106.13,149.97 101.81,149.97 101.69,150.1 101.69,154.42 101.69,154.42 106.25,154.42
GND on IN1 (solid shape): 217.76,87.87 217.76,84.06 217.64,83.93 214.33,83.93 213.7,84.57 213.7,87.87 213.83,87.99 217.64,87.99
GND on IN1 (solid shape): 228.3,95.61 228.3,93.33 228.05,93.07 224.49,93.07 223.35,94.22 223.35,94.98 224.11,95.74 228.18,95.74
GND on IN1 (solid shape): 131.53,139.05 131.53,137.4 131.2,137.07 131.16,137.07 130.35,136.26 128.87,136.26 127.85,137.28 127.85,139.05 127.87,139.07 131.51,139.07
GND on IN1 (solid shape): 156.42,104.89 156.42,101.58 156.3,101.46 155.72,101.46 155.44,101.74 154.72,101.74 154.39,102.07 154.39,104.89 154.52,105.01 156.3,105.01
GND on IN1 (solid shape): 236.94,42.02 236.94,38.08 236.81,37.96 232.75,37.96 232.62,38.08 232.62,42.15 232.75,42.27 236.69,42.27
GND on IN1 (solid shape): 103.72,146.29 103.72,145.78 104.35,145.14 104.35,143.75 103.84,143.24 99.4,143.24 99.15,143.49 99.15,144.38 99.91,145.14 99.91,146.29 100.03,146.41 103.59,146.41
GND on IN1 (solid shape): 63.66,119.95 63.7,119.93 63.71,119.9 63.71,117.84 62.95,117.08 60.66,117.08 60.03,116.44 59.65,116.44 59.39,116.7 59.39,119.9 59.41,119.93 59.44,119.95
GND on IN1 (solid shape): outline of 2005 points within 0.51,0.51 249.87,173.95
GND on IN1 (solid shape): outline of 2996 points within 141.24,23.22 249.87,173.95
GND on IN2 (solid shape): 106.26,154.42 106.26,150.1 106.13,149.97 101.81,149.97 101.69,150.1 101.69,154.42 101.81,154.54 106.13,154.54
GND on IN2 (solid shape): 156.42,104.89 156.42,101.58 156.3,101.46 154.52,101.46 154.39,101.58 154.39,104.89 154.52,105.01 156.3,105.01
GND on IN2 (solid shape): 217.76,87.87 217.76,84.06 217.64,83.93 213.83,83.93 213.7,84.06 213.7,87.87 213.83,87.99 217.64,87.99
GND on IN2 (solid shape): 228.3,95.61 228.3,93.33 228.05,93.07 224.37,93.07 223.35,94.09 223.35,95.11 224.11,95.87 228.05,95.87
GND on IN2 (solid shape): 234.22,41.61 236.79,41.61 236.94,41.46 236.94,38.08 236.81,37.96 232.75,37.96 232.62,38.08 232.62,41.89 232.75,42.02 233.82,42.02
GND on IN2 (solid shape): 63.71,120 63.71,117.84 62.95,117.08 60.66,117.08 60.03,116.44 59.65,116.44 59.39,116.7 59.39,120 59.52,120.13 63.59,120.13
GND on IN2 (solid shape): 131.53,139.18 131.53,136.64 131.4,136.51 130.64,136.51 130.13,136 128.36,136 127.72,136.64 127.72,139.18 127.85,139.3 131.4,139.3
GND on IN2 (solid shape): 103.72,146.29 103.72,145.78 104.35,145.14 104.35,143.75 103.84,143.24 99.4,143.24 99.15,143.49 99.15,144.38 99.91,145.14 99.91,146.29 100.03,146.41 103.59,146.41
GND on IN2 (solid shape): outline of 1259 points within 235.31,23.22 249.87,140.95
GND on IN2 (solid shape): outline of 1658 points within 141.24,93.84 248.37,173.95
GND on IN2 (solid shape): outline of 1971 points within 0.51,0.51 249.87,173.95
GND on SVCC (solid shape): 246.31,29.03 247.98,28.53 248.35,28.53 248.35,23.23 245.3,23.23 243.16,25.36 243.16,26.47 243.35,26.65 243.42,26.91 243.42,28.48 245.05,30.1 245.14,30.23 245.19,30.38
GND on SVCC (solid shape): 237.13,152.3 237.01,151.25 237.32,150.25 237.32,140.03 237.14,139.62 237.03,139.19 236.78,138.95 236.48,138.95 236.25,139.3 236.02,139.66 236.06,140.11 235.62,140.23 233.39,142.97 230.81,145.39 233.56,147.82 231.86,151.07 233.08,152.3
GND on SVCC (solid shape): outline of 1496 points within 64.35,62.21 162.9,170.43
GND on SVCC (solid shape): outline of 1517 points within 153.37,2.03 248.35,153.32
GND on IN3 (solid shape): 106.26,154.42 106.26,150.1 106.13,149.97 101.81,149.97 101.69,150.1 101.69,154.42 101.81,154.54 106.13,154.54
GND on IN3 (solid shape): 131.53,139.18 131.53,136.64 131.02,136.13 128.37,136.13 127.72,136.78 127.72,139.18 127.75,139.21 131.5,139.21
GND on IN3 (solid shape): 156.42,104.89 156.42,101.58 156.3,101.46 154.64,101.46 154.39,101.71 154.39,104.89 154.52,105.01 156.3,105.01
GND on IN3 (solid shape): 228.3,95.61 228.3,93.33 228.05,93.07 224.37,93.07 223.35,94.09 223.35,95.11 224.11,95.87 228.05,95.87
GND on IN3 (solid shape): 236.94,42.15 236.94,38.08 236.81,37.96 233.26,37.96 233.18,38.04 233.18,38.08 233.18,38.09 233.18,41.64 233.81,42.27 236.81,42.27
GND on IN3 (solid shape): 63.71,120 63.71,117.84 62.95,117.08 60.66,117.08 60.03,116.44 59.65,116.44 59.39,116.7 59.39,120 59.52,120.13 63.59,120.13
GND on IN3 (solid shape): 103.72,146.29 103.72,145.78 104.35,145.14 104.35,143.75 103.84,143.24 99.4,143.24 99.15,143.49 99.15,144.38 99.91,145.14 99.91,146.29 100.03,146.41 103.59,146.41
GND on IN3 (solid shape): 215.44,87.83 217.71,87.83 217.75,87.81 217.76,87.78 217.76,84.06 217.64,83.93 213.83,83.93 213.7,84.06 213.7,87.87 213.83,87.99 215.27,87.99
GND on IN3 (solid shape): 238.35,66.01 238.72,65.67 239.2,65.55 248.32,65.55 248.36,65.54 248.37,65.5 248.37,64.52 248.36,64.48 248.32,64.47 247.98,64.47 246.91,64.03 246.47,62.96 246.47,31.56 246.91,30.49 247.98,30.05 248.38,30.05 249.43,29.62 249.87,28.56 249.87,23.61 249.49,23.22 245.32,23.22 243.54,25 243.54,28.58 245.2,30.24 245.2,51.43 244.95,51.67 244.95,55.33 244.41,55.86 241.54,55.86 238.95,58.45 238.95,59.32 235.31,62.95 235.31,64.8 236.52,66.01
GND on IN3 (solid shape): outline of 339 points within 235.31,71.13 248.97,85.81
GND on IN3 (solid shape): outline of 1743 points within 141.24,88.35 249.87,173.95
GND on IN3 (solid shape): outline of 1930 points within 0.51,0.51 249.87,173.95
GND on SGND1 (solid shape): outline of 2820 points within 0.51,0.51 249.87,173.95
VDD10 on TOP (solid shape): 225.44,79.81 225.44,75.74 224.87,75.17 223.86,75.17 223.61,75.42 223.61,77.71 223.35,77.96 223.35,79.99 223.48,80.12 225.13,80.12
VDD10 on IN2 (solid shape): 222.84,89.65 222.84,87.74 223.73,86.85 223.73,79.87 225.51,78.09 225.51,76.82 225.26,76.56 224.11,76.56 221.57,79.1 218.8,79.1 218.74,79.14 218.7,79.17 218.65,79.2 218.6,79.22 218.55,79.23 218.5,79.23 218.45,79.23 218.4,79.22 218.35,79.2 218.3,79.17 218.26,79.14 218.2,79.1 215.35,79.1 215.22,79.23 215.22,80.25 215.38,80.4 216.44,80.4 216.44,80.35 216.45,80.3 216.47,80.24 216.49,80.2 216.52,80.15 216.56,80.11 216.6,80.08 216.64,80.05 216.69,80.03 216.74,80.02 216.8,80.02 216.85,80.02 216.9,80.03 216.95,80.05 217,80.08 217.04,80.11 217.08,80.15 217.11,80.2 217.13,80.24 217.15,80.3 217.15,80.35 217.15,80.4 217.15,80.45 217.13,80.51 217.11,80.55 217.08,80.6 217.04,80.64 217,80.67 216.95,80.7 216.9,80.72 216.85,80.73 216.8,80.73 216.74,80.73 216.69,80.72 216.64,80.7 216.6,80.67 216.56,80.64 216.52,80.6 216.49,80.55 216.47,80.51 216.45,80.45 216.44,80.4 215.38,80.4 215.99,81.01 218.4,81.01 222.51,85.12 222.51,86.29 221.51,87.3 221.51,89.2 222.08,89.77 222.72,89.77
VDD33 on TOP (solid shape): 216.11,73.9 216.11,73.13 216.01,72.88 216.11,72.63 216.11,71.84 216.01,71.59 216.11,71.34 216.11,70.6 215.99,70.47 214.97,70.47 214.59,70.85 214.59,72.12 213.7,73.01 213.7,74.02 213.83,74.15 215.86,74.15
VDD33 on TOP (solid shape): 220.51,92.99 220.53,92.96 220.51,92.92 220.4,92.68 220.49,92.43 220.52,92.36 220.49,92.3 220.45,91.89 220.82,91.71 220.9,91.69 220.94,91.61 220.94,89.14 220.81,89.01 219.92,89.01 219.8,89.14 219.8,89.82 219.81,89.84 219.81,90.56 219.8,90.63 219.8,90.7 219.8,91.17 219.54,91.42 218.79,91.42 218.75,91.44 218.74,91.48 218.47,91.74 218.47,92.31 218.35,92.44 218.35,93.07 218.47,93.2 220.3,93.2
VDD33 on IN2 (solid shape): outline of 463 points within 212.05,72.55 222,92.19
VDDREG on TOP (solid shape): 218.63,80.83 218.83,80.83 218.83,81.85 219.13,81.85 219.13,80.15 220.3,78.98 220.3,77.83 220.68,77.45 220.68,75.93 217.64,72.88 217.64,70.85 217.26,70.47 216.62,70.47 216.49,70.6 216.49,71.24 216.51,71.26 216.52,71.27 216.72,71.59 216.52,71.91 216.51,71.91 216.49,71.94 216.49,72.52 216.5,72.54 216.52,72.56 216.72,72.85 216.57,73.17 216.53,73.25 216.56,73.33 219.54,76.31 219.54,77.45 219.29,77.71 219.29,78.6 218.35,79.54 218.35,81.85 218.63,81.85
VIN on TOP (solid shape): 12.4,126.86 12.4,124.06 13.45,123.02 13.45,121.29 13.17,121.01 10.63,121.01 9.74,121.9 9.74,126.97 9.99,127.23 12.03,127.23
VIN on TOP (solid shape): 67.37,86.29 67.37,82.25 66.61,81.49 66.61,79.33 66.48,79.2 61.33,79.2 61.1,79.43 61.04,79.51 60.96,79.57 60.92,79.61 60.92,86.5 61.25,86.83 66.84,86.83
VIN on TOP (solid shape): 41.62,73.63 42.52,73.63 43.4,72.75 44.53,72.75 45.42,71.85 45.42,70.98 44.92,70.47 42.88,70.47 42.03,71.32 40.72,71.32 40.48,71.08 40.48,67.03 42.49,65.02 42.49,59.89 42.33,59.74 37.96,59.74 37.88,59.82 37.88,60.9 37.46,61.33 37.46,62.41 37.08,62.78 37.08,64.99 36.12,65.95 36.12,66.66 36.12,66.67 36.12,69.37 35.81,69.67 34.63,69.67 34.46,69.83 34.46,71.14 34.46,71.14 34.46,71.88 34.53,71.94 35.24,71.94 35.47,72.17 36.97,72.17 38.48,73.68 41.57,73.68
VIN on TOP (solid shape): 53.04,108.95 53.04,106.66 52.78,106.4 52.63,106.4 52.55,106.44 52.54,106.52 52.16,107.36 51.25,107.22 51.07,106.9 51.07,106.52 51.05,106.44 50.97,106.4 50.67,106.4 50.28,106 50.28,102.94 50.38,102.84 50.38,102.47 50.25,102.35 48.22,102.35 48.07,102.5 48.07,103.11 47.84,103.34 47.84,105.32 47.94,105.57 47.84,105.82 47.84,108.24 48.8,109.2 52.79,109.2
VIN on TOP (solid shape): outline of 100 points within 133.54,149.25 142.2,154.52
VIN on TOP (solid shape): outline of 176 points within 178.93,64.5 209.51,73.47
VIN on BOTTOM (solid shape): 11.35,126.95 11.35,123.68 11.73,123.3 12.15,123.3 13.17,122.28 13.17,121.14 12.91,120.89 9.61,120.89 8.91,121.59 8.91,124.51 8.94,124.54 8.94,127.02 9.09,127.18 11.12,127.18
VIN on BOTTOM (solid shape): 212,66.07 212,60.99 211.62,60.61 209.71,60.61 209.66,60.66 209.46,60.66 209.3,60.82 209.3,63.76 208.72,64.35 207.48,64.35 207.25,64.12 205.83,64.12 205.57,64.37 205.57,65.82 205.75,66 205.75,67.19 205.98,67.42 210.65,67.42
VIN on BOTTOM (solid shape): 135.85,152.26 136.61,152.26 136.74,152.13 138.64,152.13 138.9,151.88 138.9,150.73 139.02,150.61 139.77,150.61 140.04,150.34 140.04,150.12 140.03,150.12 140.03,149.45 139.9,149.33 137,149.33 136.61,149.72 133.94,149.72 133.82,149.84 133.82,150.61 134.2,150.99 134.2,152.51 134.32,152.64 135.47,152.64
VIN on BOTTOM (solid shape): 67.32,86.9 67.32,85.2 67.24,85.12 67.24,79 67.06,78.83 64.63,78.83 64.45,79 64.45,80.65 63.13,81.98 62.24,81.98 61.81,82.41 61.55,82.41 61.36,82.6 61.36,84.85 61.57,85.06 65.46,85.06 65.64,85.24 65.64,86.85 65.92,87.13 67.09,87.13
VIN on BOTTOM (solid shape): 188.1,73.82 188.1,72.37 189.29,71.18 189.32,71.18 189.32,70.11 189.57,69.86 189.57,67.83 189.34,67.6 185.56,67.6 185.33,67.83 185.33,70.72 184.97,71.08 183.17,71.08 182.71,70.62 179.43,70.62 178.88,71.18 178.88,72.93 179.23,73.29 183.04,73.29 183.47,73.72 183.47,74.13 183.83,74.48 187.44,74.48
VIN on BOTTOM (solid shape): outline of 82 points within 37.17,64.5 45.31,93.56
VIN on BOTTOM (solid shape): outline of 107 points within 178.27,46.97 190.97,53.95
VIN on BOTTOM (solid shape): outline of 560 points within 147.12,85.12 180.68,144.51
VIN on IN1 (solid shape): outline of 2664 points within 9.43,64.63 50.5,124.44
VIN on SVCC (solid shape): outline of 459 points within 133.82,139.43 152.36,154.54
VIN on SVCC (solid shape): outline of 1087 points within 36.53,37.24 188.43,86.22
VIN on IN3 (solid shape): outline of 1116 points within 38.19,79.1 65.54,91.93
1.5GFX_SW on BOTTOM (solid shape): 11.79,133.69 11.8,133.67 11.9,133.46 12.11,133.36 12.12,133.36 12.91,132.57 12.91,130.58 14.1,129.4 16.89,129.4 17.78,128.51 17.78,127.58 18.9,126.45 18.9,124.92 18.9,124.9 18.89,124.89 18.71,124.71 14.82,124.71 14.33,124.23 11.91,124.23 11.86,124.28 11.86,126.97 11.24,127.59 9.74,127.59 8.62,128.71 8.62,133.64 8.64,133.66 8.64,134.1 9.11,134.57 10.92,134.57
1642_LGATE1 on TOP (solid shape): 52.5,78.69 52.66,78.69 53.08,78.27 53.08,78.13 53.3,77.91 53.3,76.67 53.29,76.67 53.03,76.67 53.02,76.68 53.02,77.66 52.72,77.96 52.56,77.96 52.56,77.96 52.19,77.96 51.53,78.62 51.53,78.77 51.85,79.09 52.1,79.09
1642_LGATE1 on BOTTOM (solid shape): 51.29,80.32 51.29,79.84 51.9,79.23 52.66,79.23 52.92,78.98 52.92,78.47 52.79,78.34 51.8,78.34 50.72,79.42 50.19,79.42 50.11,79.5 50.11,80.01 50.12,80.02 50.12,80.45 50.15,80.48 51.14,80.48
1642_LGATE2 on TOP (solid shape): 55.04,79.42 55.04,78.67 54.8,78.44 54.8,76.69 54.78,76.67 54.54,76.67 54.52,76.68 54.52,77.88 54.11,78.29 54.11,78.65 54.36,78.9 54.36,79.46 54.45,79.55 54.91,79.55
1642_LGATE2 on BOTTOM (solid shape): 55.56,79.97 55.03,79.44 55.03,78.6 54.57,78.14 54.29,78.14 54.09,78.34 54.09,78.55 54.47,78.93 54.47,79.71 54.8,80.04 54.8,81.04 55.56,81.04
1642_PHASE1 on TOP (solid shape): 45.47,93.05 45.47,92.54 45.94,92.07 48.46,92.07 50.4,90.13 50.4,90.11 50.95,89.56 50.95,85.12 50.35,84.52 50.35,82.94 49.67,82.25 45.58,82.25 45.3,82.53 45.3,87.13 44.87,87.56 44.13,87.56 44.03,87.66 44.03,92.01 44.31,92.29 44.31,92.95 44.54,93.18 45.35,93.18
1642_PHASE1 on BOTTOM (solid shape): 54.47,91.25 54.47,89.26 53.65,88.45 53.65,85.63 53.48,85.45 49.89,85.45 49.39,84.95 49.39,79.64 48.85,79.1 47.68,79.1 47.33,79.46 44.79,79.46 44.61,79.64 44.61,84.97 45.65,86.01 45.65,86.98 51.42,86.98 51.42,89.65 50.96,89.65 50.96,86.98 45.65,86.98 45.65,87.66 45.46,87.86 44.42,87.86 44.28,88 44.28,91.4 44.41,91.53 54.19,91.53
1642_PHASE2 on TOP (solid shape): 60.42,88.8 60.42,88.77 60.66,88.53 60.66,87.16 60.27,86.76 60.27,81 60.16,80.88 58.76,80.88 58.51,81.14 58.51,82.15 57.79,82.86 55.43,82.86 54.95,83.35 54.95,88.48 56.88,90.41 58.81,90.41
1642_PHASE2 on BOTTOM (solid shape): 65.21,89.29 65.21,85.58 65.15,85.52 65.13,85.52 64.94,85.33 60.56,85.33 60.36,85.12 60.36,83.27 61.18,82.45 61.18,82.19 60.97,81.98 54.75,81.98 54.29,82.43 54.29,85.45 54.54,85.71 54.54,86.83 62.9,86.83 62.9,89.5 62.44,89.5 62.44,86.83 54.54,86.83 54.54,88.35 56.85,90.66 63.84,90.66
1642_UGATE1 on TOP (solid shape): 49.94,76.51 50.01,76.54 50.09,76.5 50.18,76.43 50.29,76.39 50.31,76.39 50.74,75.95 51.32,75.95 52.29,75.95 52.31,75.94 52.31,75.68 52.3,75.67 51.32,75.67 49.87,75.67 49.87,75.68 49.74,75.8 49.74,76.31
1642_UGATE1 on BOTTOM (solid shape): 45.32,87.28 45.32,86.37 44.59,85.63 44.23,85.63 44.1,85.76 44.1,86.34 44.26,86.5 44.26,87.24 44.35,87.33 45.28,87.33
1642_UGATE2 on TOP (solid shape): 60.03,80.5 60.03,79.64 60.02,79.61 60,79.59 59.87,79.52 59.78,79.41 59.72,79.36 59.64,79.37 59.23,79.36 59.04,79 59.06,78.86 59.12,78.74 59.13,78.73 59.13,78.69 59.01,78.57 58.71,78.57 57.49,77.35 57.49,76.5 56.66,75.67 55.53,75.67 55.52,75.68 55.52,75.94 55.52,75.95 56.51,75.95 56.93,76.37 56.93,77.61 57.7,78.38 57.7,78.58 57.71,78.6 57.73,78.63 57.73,78.71 58.1,79.08 58.12,79.09 58.15,79.09 58.43,79.13 58.6,79.35 58.64,79.69 58.41,79.94 58.39,79.96 58.38,79.98 58.38,80.25 58.76,80.63 59.9,80.63
24707_LX on TOP (solid shape): 42.78,69.41 44.66,69.41 45.16,68.91 45.16,67.51 45.92,66.75 45.92,63.93 45.62,63.64 43.34,63.64 43.09,63.89 43.09,65.24 42.61,65.72 42.43,65.9 42.42,65.91 42.41,65.94 40.97,67.38 40.97,70.45 41,70.48 41.7,70.48
24707_LX on BOTTOM (solid shape): 45.42,69.83 45.42,66.59 46.09,65.93 48.37,65.93 48.62,65.67 48.62,63.74 48.55,63.67 41.33,63.67 40.95,64.05 40.95,69.46 41.46,69.97 45.28,69.97
51216_DRVH on TOP (solid shape): 196.58,54.92 195.79,54.92 195.56,54.7 195.56,54.44 195.44,54.31 195,54.31 194.88,54.44 194.88,54.8 195.03,54.95 195.44,54.95 195.59,55.1 196.58,55.1
51216_DRVL on TOP (solid shape): 196.6,56.32 196.6,56.12 195.77,56.12 195.26,56.63 195.26,56.91 195.54,57.18 195.74,57.18
51216_SW on TOP (solid shape): 195.61,55.51 196.58,55.51 196.6,55.48 196.6,55.31 195.59,55.31 195.39,55.1 193.76,55.1 193.68,55.18 193.68,55.81 193.73,55.86 195.26,55.86
51216_SW on BOTTOM (solid shape): 185.38,60.11 185.38,57.77 186.29,56.85 190.97,56.85 190.97,54.57 190.89,54.49 184.77,54.49 183.88,53.6 180.37,53.6 179.87,54.11 179.87,60.72 180.12,60.97 184.51,60.97
51216_VBST on TOP (solid shape): 196.58,54.67 195.41,53.5 193.79,53.5 193.71,53.58 193.71,54.39 193.76,54.44 194.55,54.44 194.9,54.09 195.61,54.09 195.82,54.29 195.82,54.7 196.58,54.7
51225_DH1 on BOTTOM (solid shape): 208.7,63.81 208.7,63.28 208.68,63.24 208.64,63.23 207.37,63.23 207.22,63.38 207.22,63.76 207.4,63.94 208.57,63.94
51225_DL1 on TOP (solid shape): 199.13,63.32 199.13,63.12 198.92,62.9 198.56,62.9 198.13,63.33 198.13,64.12 198.33,64.12
51225_DL1 on BOTTOM (solid shape): 202.98,62.85 202.98,62.34 202.95,62.32 201.61,62.32 201.51,62.42 201.51,62.95 201.56,63 202.83,63
51225_DL2 on BOTTOM (solid shape): 189.32,63.99 189.32,63.61 189.16,63.46 187.28,63.46 187.18,63.56 187.18,64.14 187.21,64.17 189.14,64.17
51225_SW1 on TOP (solid shape): 201.35,65.77 201.35,64.98 201.3,64.93 200.49,64.93 200.41,65.01 199.63,65.01 199.5,65.13 198.56,65.13 198.52,65.15 198.51,65.19 198.51,65.29 198.52,65.32 198.56,65.34 199.53,65.34 199.98,65.8 201.33,65.8
51225_SW1 on BOTTOM (solid shape): 206.23,63.03 208.72,63.03 208.77,62.98 208.77,60.61 209.14,60.25 210.37,60.25 210.46,60.2 210.46,60.1 210.78,59.57 211.09,60.1 211.09,60.2 211.18,60.25 211.22,60.25 211.24,60.26 211.46,60.26 212.05,59.67 212.05,55.94 211.59,55.48 205.57,55.48 205.1,55.95 205.1,57.43 203.56,58.96 203.56,63.36 203.72,63.51 205.75,63.51
51225_SW2 on TOP (solid shape): 195.39,65.34 196.3,65.34 196.33,65.31 196.33,65.19 196.31,65.15 196.27,65.13 195.13,65.13 195.08,65.08 193.63,65.08 193.53,65.19 193.53,65.85 193.56,65.87 194.85,65.87
51225_SW2 on TOP (solid shape): 184.87,69.68 184.87,67.4 185.25,67.01 186.04,67.01 186.65,66.4 186.65,63.26 186.42,63.03 180.63,63.03 179.92,63.74 179.92,66.56 180.12,66.76 181.8,66.76 182.28,67.24 182.25,67.27 182.25,69.76 182.41,69.91 184.64,69.91
51225_SW2 on BOTTOM (solid shape): 184.87,69.85 184.87,67.5 185.25,67.12 186.39,67.12 186.66,66.85 186.66,63.19 186.52,63.05 180.6,63.05 179.79,63.86 179.79,69.53 180.23,69.97 184.74,69.97
51225_VBST1 on TOP (solid shape): 199.61,64.87 199.78,64.87 199.88,64.86 199.98,64.87 200.31,64.87 200.48,64.7 201.23,64.7 201.33,64.6 201.33,63.74 201.28,63.69 200.41,63.69 200.39,63.71 200.39,64.2 199.98,64.6 199.5,64.6 199.35,64.75 198.51,64.75 198.51,64.92 198.52,64.93 199.55,64.93
51225_VBST2 on TOP (solid shape): 195.51,64.93 196.3,64.93 196.3,64.75 194.83,64.75 194.6,64.53 194.6,63.94 194.42,63.76 193.61,63.76 193.51,63.86 193.51,64.58 193.53,64.6 194.09,64.6 194.45,64.96 195.49,64.96
+DDR_VTT_RUN on TOP (solid shape): 201.99,57.44 201.99,54.24 201.76,54.01 198.97,54.01 198.79,54.19 198.79,54.7 199.68,54.7 199.91,54.47 200.44,54.47 200.64,54.67 200.64,55.1 200.44,55.31 198.81,55.31 198.79,55.33 198.79,55.51 199.81,55.51 200.08,55.79 200.24,55.79 200.72,56.27 200.72,57.62 200.82,57.72 201.71,57.72
+DDR_VTT_RUN on TOP (solid shape): 161.76,84.82 161.76,80.71 161.74,80.67 161.71,80.66 161.05,80.66 160.5,80.11 160.5,79.35 161.05,78.8 161.71,78.8 161.74,78.79 161.76,78.75 161.76,73.52 162.14,73.14 162.14,72.63 161.63,72.12 160.61,72.12 158.71,74.02 158.71,79.04 158.77,79.14 158.88,79.11 159.5,79.36 158.88,79.6 158.77,79.58 158.71,79.67 158.71,81.14 159.47,81.9 159.47,84.69 159.85,85.07 161.5,85.07
+DDR_VTT_RUN on TOP (solid shape): 62.7,65.64 62.8,65.57 62.92,65.54 62.95,65.52 62.95,65.13 62.81,64.99 62.79,64.99 62.67,64.96 62.57,64.89 61.7,64.01 61.7,63.88 61.68,63.86 61.68,63.36 61.71,63.33 61.71,63.31 61.77,63.19 61.89,63.13 61.91,63.13 62.19,62.85 62.19,59.51 62.18,59.48 62.16,59.46 61.96,59.14 62.16,58.82 62.18,58.8 62.19,58.77 62.19,56.24 61.81,55.86 60.16,55.86 60.03,55.99 60.03,56.5 60.16,56.63 60.66,56.63 60.92,56.88 60.92,57.39 60.66,57.64 60.03,57.64 59.9,57.77 59.9,58.01 59.97,58.08 60.15,58.42 60.09,58.83 60.11,58.86 60.16,58.91 60.79,58.91 60.92,59.04 60.92,62.59 60.54,62.98 60.54,63.99 61.43,64.88 61.43,65.52 61.55,65.64
+DDR_VTT_RUN on BOTTOM (solid shape): 71.84,52.94 71.84,52.05 71.71,51.93 70.32,51.93 69.81,52.43 69.81,52.94 69.94,53.07 71.71,53.07
+DDR_VTT_RUN on BOTTOM (solid shape): 201.99,57.54 201.99,56.32 201.71,56.04 200.77,56.04 200.69,56.12 200.69,56.58 200.47,56.8 200.47,57.64 200.57,57.74 201.79,57.74
+DDR_VTT_RUN on BOTTOM (solid shape): 160.87,84.85 160.87,82.71 160.66,82.51 160.13,82.51 159.95,82.69 159.34,82.69 159.22,82.81 159.22,84.85 159.19,84.87 159.19,84.95 159.44,85.2 160.51,85.2
+DDR_VTT_RUN on BOTTOM (solid shape): 64.35,56.41 64.35,54.59 64.22,54.47 61.6,54.47 61.58,54.47 61.56,54.48 60.79,54.48 60.76,54.47 60.74,54.47 60.66,54.47 60.03,55.1 60.03,56.24 60.16,56.37 60.92,56.37 61.05,56.5 64.25,56.5
+DDR_VTT_RUN on BOTTOM (solid shape): 161.76,77.07 161.76,74.08 162.04,73.8 162.04,72.02 161.88,71.87 159.83,71.87 159.47,72.22 159.47,74.57 159.48,74.61 159.52,74.62 159.52,76.67 159.48,76.68 159.47,76.72 159.47,76.87 160.05,77.45 161.38,77.45
+DDR_VTT_RUN on BOTTOM (solid shape): outline of 153 points within 61.05,61.7 64.35,66.02
+DDR_VTT_RUN on IN1 (solid shape): 162.26,72.88 162.26,70.85 162.01,70.6 160.11,70.6 159.85,70.85 159.85,72.12 160.99,73.26 161.88,73.26
+DDR_VTT_RUN on IN1 (solid shape): 201,57.9 202.09,57.9 202.37,57.62 202.37,56.47 202.27,56.37 200.48,56.37 200.45,56.38 200.43,56.4 200.17,56.6 199.86,56.5 199.79,56.48 199.72,56.51 199.22,57.01 199.22,58.15 199.48,58.4 200.49,58.4
+DDR_VTT_RUN on IN1 (solid shape): outline of 139 points within 60.67,55.86 64.01,65.01
+DDR_VTT_RUN on IN2 (solid shape): outline of 303 points within 126.83,50.4 142.58,55.1
+DDR_VTT_RUN on IN2 (solid shape): outline of 591 points within 149.69,51.29 162.39,73.26
+DDR_VTT_RUN on IN2 (solid shape): outline of 664 points within 60.79,49.13 91.02,60.44
+G_SEN_PW on TOP (solid shape): outline of 257 points within 215.22,50.4 221.57,59.8
+G_SEN_PW on BOTTOM (solid shape): 219.92,58.12 219.92,57.13 220.18,56.88 220.18,55.99 220.05,55.86 218.91,55.86 218.53,56.24 217.64,56.24 217.51,56.37 217.51,57.9 217.76,58.15 218.78,58.15 218.91,58.28 219.77,58.28
+SMDDR_VREF_DIMM on IN2 (solid shape): 133.19,59.67 133.44,59.57 133.68,59.67 134.07,59.67 134.58,59.17 134.58,57.64 134.32,57.39 133.64,57.39 133.61,57.4 133.59,57.44 133.59,57.95 133.46,58.08 133.45,58.1 133.45,58.13 132.85,58.47 133.19,57.87 133.21,57.87 133.24,57.86 133.28,57.82 133.28,57.44 133.26,57.4 133.23,57.39 132.29,57.39 131.97,57.71 131.96,57.75 131.97,57.78 132.06,58.05 131.93,58.3 131.92,58.32 131.91,58.34 131.91,58.41 131.92,58.42 131.99,58.64 131.91,58.85 131.91,59.46 131.92,59.49 131.94,59.51 132.03,59.57 132.09,59.65 132.11,59.67 132.14,59.67
