# Allegro board DA0Z8CMB8D0-D-gina-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3V: length 598
  TOP w0.254: Q20.2 149.88,96.41 150.14,96.68 150.79,96.68 150.92,96.54 150.92,96.42 151.16,96.17 151.59,96.17 151.82,96.4 v1(152.03,96.4)
  TOP w0.279: U20.5 160.69,106.46 160.74,106.41 C266.2 ; R257.2 149.89,92.95 149.88,92.96 Q20.5 ; U27.5 132.05,66.12 131.81,66.35 131.38,66.35 130.93,66.8 130.93,67.14
  TOP w0.305: U22.5 40.59,102.98 40.73,103.12 40.85,103.12 ; 38.58,104.62 U21.5 ; v1(92.11,123.35) U17.14 ; v1(59.84,75.62) 59.78,75.62 59.3,75.14 PR65.2
  TOP w0.381: PR33.2 14.36,116.66 v1(14.36,117.33) ; v1(85.11,107.12) 85.2,107.03 R196.2 ; C192.2 91.93,123.17 v1(92.11,123.35)
  TOP w0.457: R114.2 149.09,124.8 v1(149.69,124.8) ; Q3.2 v1(83.78,152.54) ; R104.1 149.14,126.93 149.67,126.93 v1(149.69,126.91) ; R110.2 v1(149.69,125.84) 150.08,125.84 R108.2 ; v1(84.24,150.45) 84.03,150.45 83.77,150.19 R60.2 ; v1(149.72,128.74) 149.59,128.86 149.09,128.86 R98.2 R94.2 ; v1(149.69,119.41) 149.12,119.41 R139.2
  TOP w0.508: v1(73.36,107.63) 73.7,107.29 R187.2 ; 162.77,116.82 162.77,116.01 v1(162.9,115.88) ; 162.77,116.82 R158.2 R159.2 R160.2 R157.2 ; 162.77,116.82 R156.2 R155.2 ; v1(149.56,132.5) 149.06,132 R92.2 ; v1(149.56,132.5) 149.11,132.95 R91.2 ; v1(149.56,132.5) 150.2,133.13 150.2,134.1 149.31,134.98 R88.1 ; R192.2 62.8,106.14 v1(62.8,105.57) ; R113.1 155.28,125.08 155.89,125.08 v1(156.08,125.27) ; R79.1 145.6,139.12 144.9,138.41 144.9,138.39 144.81,138.31 v1(144.81,138.16) ; Q17.2 78.72,105.01 v1(78.32,104.61) ; v1(160.46,58.35) 160.46,58.28 160.89,57.85 160.89,55.81 161.6,55.1 162.01,55.1 162.52,54.59 162.52,53.32 162.9,52.94 Q30.2 ; R33.1 125.46,156.45 v1(124.55,155.53) ; 38.58,104.62 37.8,104.62 C267.2 38.32,103.87 v1(40.98,103.87) 41.36,103.49 41.36,103.37 C275.2 40.85,103.12 ; R90.1 v1(83.02,133.59) ; C273.2 159.48,103.75 v1(159.6,103.87) ; v1(63.33,107.96) 63.31,107.96 63.08,107.73 63.08,107.56 R190.2 ; PR79.1 167.98,69.15 167.42,69.71 165.08,69.71 v2(164.7,69.33) ; R115.2 150.33,123.55 v1(150.71,123.17) ; R134.1 153.26,120.37 153.76,119.87 v1(153.76,119.49) ; v1(77.2,152.89) 76.82,153.27 Q1.2 76.03,153.53 v1(75.37,153.53) ; v1(149.69,121.4) R130.2 R137.2 149.14,120.3 v1(149.69,120.3) 149.89,120.5 R131.2 150.35,120.52 151.32,120.52 R132.2 ; 159.22,61.58 v1(159.85,61.58) ; v1(211.41,72.75) 211.41,74.66 211.79,75.04 212.43,75.04 213.06,75.68 R293.2 ; R59.2 v1(23.45,151.24) ; R332.2 136.11,63.04 v1(136.05,62.98) ; Q26.2 v1(208.37,72.76) 209,72.13 R306.1 ; v1(137.27,67.14) 130.93,67.14 C387.2 ; R241.2 152.62,96.11 152.33,96.4 v1(152.03,96.4) ; v1(162.7,70.81) 161.89,71.61 160.51,71.61 158.61,73.52 158.34,73.52 ; R117.2 161.45,125.9 159.74,127.62 157.06,127.62 156.41,128.26 R99.1 R97.2 155.91,130.02 155.91,131.56 154.26,133.21 v1(151.62,133.21) ; R40.2 v1(75.39,154.15) ; v1(94.29,48.77) 94.29,49.67 93.8,50.16 R389.1 ; PR72.2 v1(199.73,73.14) ; C266.2 160.88,105.65 v1(161.48,105.65) ; R55.1 v1(81.48,151.12) ; v1(151.72,118.1) 151.72,118.09 151.6,117.97 150.86,117.97 R154.1 ; v1(158.31,85.3) 158.43,85.18 C313.1 159.09,83.78 159.09,82.03 158.34,81.27 R288.2 C345.1 R297.1 158.34,73.52 ; R257.2 151.02,91.04 v1(151.85,91.04) ; R402.2 156.56,40.75 v1(156.8,40.75) 157.44,41.39 R399.2 ; PR114.2 v1(200.22,50.93) ; v1(48.47,74.41) 48.9,74.83 PR66.2 ; 158.34,73.52 v1(157.57,73.52) ; Q2.2 v1(80.1,154.42) ; R64.2 v1(10.79,147.26)
  TOP w0.762: v2(231.73,25.13) 233.64,23.22 R426.1
  IN1 w0.381: v1(59.84,75.62) 59.84,74.21 57.77,72.15 52.17,72.15 51.81,72.5 49.06,72.5 v1(48.45,73.11)
  IN1 w0.508: v1(21.04,128.76) 9.86,128.76 v1(8.85,127.75) ; v1(208.37,72.76) 208.37,72.75 v1(211.41,72.75)
  IN1 w0.762: 136.1,149.36 136.1,144.38 137.37,143.11 138.52,143.11 139.79,141.84 141.21,141.84
  IN1 w1.016: 68.36,91.12 68.36,86.93 66.28,84.85 66.28,80.91
  IN2 w0.305: v1(48.45,73.11) 48.73,73.39 48.73,74.15 v1(48.47,74.41)
  IN2 w0.508: 143.72,134.48 142.45,134.48 v1(141.82,135.11) ; 143.72,134.48 143.72,133.59 144.41,132.9 146.9,132.9 v1(147.02,133.03) ; 143.72,134.48 v1(143.72,135.11) ; 233.26,43.16 234.37,42.05 237.04,42.05 238.08,43.09 v1(238.08,44.18) 238.08,44.89 v1(238.11,44.92) ; 224.49,39.86 222.72,39.86 221.57,38.72 v1(219.03,38.72) ; v1(159.19,39.82) 158.25,40.75 v1(156.8,40.75) ; v1(10.79,147.26) 10.79,150.77 12.02,152 22.69,152 v1(23.45,151.24) ; v1(152.03,96.4) 152.03,92.97 151.85,92.8 v1(151.85,91.04) 151.85,90.15 153,89.01 155.03,89.01 158.31,85.73 v1(158.31,85.3)
  IN2 w0.762: 226.91,38.59 227.8,37.7 227.8,30.72 231.48,27.03 231.48,25.38 v2(231.73,25.13)
  IN2 w1.016: 57.62,65.77 57.62,63.23 56.6,62.21 56.6,59.55 57.49,58.66 57.49,55.18 55.54,53.24 55.54,51.54 56.55,50.53 60.71,50.53 61.77,49.46 62.37,49.46 63.8,48.03 65.63,48.03 66.48,47.18 67.6,47.18 68.28,47.86 ; v1(156.8,40.75) 156.42,40.75 154.39,42.78 147.25,42.78 144.97,40.5 135.98,40.5
  IN3 w0.508: v1(143.44,71.1) 142.71,71.1 142.19,70.58 141.52,70.58 138.51,67.57 137.7,67.57 v1(137.27,67.14) 137.27,64.2 v1(136.05,62.98) ; v1(10.79,147.26) 9.99,146.46 9.99,141.59 8.85,140.45 v1(8.85,127.75) 8.85,124.95 10.69,123.11 10.69,119.68 13.04,117.33 v1(14.36,117.33) ; v1(21.04,128.76) 23.43,126.37 23.43,122.95 24.22,122.16 24.85,122.16 26.31,120.7 26.31,120.06 29.42,116.95 31.71,116.95 32.6,116.06 32.6,114.66 37.93,109.33 44.03,109.33 44.54,109.84 45.93,109.84 v1(46.57,109.2) 57.49,109.2 57.9,108.8 v1(58.51,108.8) ; v1(151.72,118.1) v1(151.72,117.2)
  BOTTOM w0.203: PR136.2 142.79,150.22 v1(142.31,150.69)
  BOTTOM w0.254: PR167.2 59.28,76.17 v1(59.84,75.62) ; v1(158.31,85.3) 158.18,85.17 JDIM1.199
  BOTTOM w0.381: v1(143.72,135.11) 143.72,134.86 143.6,134.73 R515.1 ; R514.1 141.94,134.98 v1(141.82,135.11) ; PR217.2 v1(133.26,41.17) ; R669.2 67.57,100.25 v1(67.57,99.83)
  BOTTOM w0.457: R529.2 R531.2 153.63,128.89 153.88,128.63 153.88,126.98 R539.2 ; R577.2 154.51,120.07 154.42,119.97 154.42,119.53 R582.1 ; R534.2 150.22,128.74 v1(149.72,128.74) 149.17,128.74 R533.2 ; R551.2 151.1,123.81 151.1,123.56 v1(150.71,123.17) 151.1,122.78 151.1,122.65 151.1,122.65 R561.1 ; R580.1 149.14,119.41 v1(149.69,119.41) 149.95,119.41 150.12,119.24 R586.1 ; R545.1 150.29,124.8 v1(149.69,124.8) 149.09,124.8 R114.2 ; R569.1 149.56,121.52 v1(149.69,121.4) 149.82,121.52 R570.2 ; R549.1 156.08,124.47 v1(156.08,125.27) ; Q38.2 v1(85.81,152.54) ; R486.2 84.55,150.14 v1(84.24,150.45) ; R104.1 149.14,126.93 149.67,126.93 v1(149.69,126.91) ; R517.1 149.79,134.36 R520.2 150.34,133.98 150.77,133.55 150.77,132.66 150.2,132.09 R525.2 ; R587.1 152.48,118.09 151.73,118.09 v1(151.72,118.1) 151.72,118.09 151.67,118.14 151.17,118.14 R593.1 ; R576.1 150.19,120.38 149.77,120.38 v1(149.69,120.3) 149.61,120.38 149.19,120.38 R575.1 ; R528.2 150.32,130.28 150.78,130.74 150.78,131.61 150.44,131.95 R525.2 ; R110.2 v1(149.69,125.84) ; R525.2 150.17,131.95 149.62,132.5 v1(149.56,132.5) 149.18,132.11 R524.2 R523.2
  BOTTOM w0.508: R539.2 154.51,126.48 R538.2 154.52,125.47 R543.2 156.02,125.33 v1(156.08,125.27) ; 43.46,108.89 U46.4 ; 43.46,108.89 44.41,109.84 45.93,109.84 v1(46.57,109.2) 47.2,109.2 47.46,108.95 47.46,107.93 47.04,107.52 C662.1 46.53,107.52 46.11,107.1 U46.6 ; 43.46,108.89 42.32,108.89 41.87,108.44 41.87,107.81 40.98,106.92 v1(40.98,103.87) ; v2(164.7,69.33) 163.22,70.81 v1(162.7,70.81) ; v1(160.46,58.35) 160.59,58.48 160.59,60.97 159.98,61.58 v1(159.85,61.58) 159.98,61.71 160.87,61.71 163.15,63.99 163.15,66.25 v2(164.7,67.8) ; R596.1 151.22,117.2 v1(151.72,117.2) 152.35,117.2 R599.1 ; R94.2 R528.2 ; v1(219.03,38.72) 204.81,38.72 199.86,43.67 199.86,50.56 v1(200.22,50.93) ; R482.1 v1(113.12,151.62) ; R766.1 109.75,47.68 110.07,47.99 110.58,47.99 ; 185.77,81.52 R699.1 ; 185.77,81.52 184.49,81.52 184.11,81.9 v1(184.11,83.45) ; 185.77,81.52 R705.1 ; L29.1 v1(98.25,146.03) ; v1(92.11,123.35) 92.11,124.5 91.66,124.94 v1(91.66,127.9) ; R764.2 124.81,47.53 124.36,47.08 124.01,47.08 123.68,46.74 123.68,45.78 ; 123.68,45.78 123.71,45.75 123.71,43.42 123.07,42.78 122.74,42.78 ; 123.68,45.78 123,45.78 122.8,45.58 R771.2 ; R782.2 159.97,40.75 159.19,39.97 v1(159.19,39.82) ; R581.2 v1(153.76,119.49) R582.1 ; v1(231.35,43.06) 232.01,42.4 234.73,42.4 235.09,42.05 236.89,42.05 238.08,43.24 v1(238.08,44.18) ; v1(201,79.99) 201,74.41 v1(199.73,73.14) ; R577.2 154.51,121.16 R574.2 154.21,121.59 154.21,122.37 R560.1 ; v1(143.44,71.1) 143.44,71.59 144.48,72.63 145.12,72.63 145.63,72.12 148.5,72.12 148.88,72.5 150,72.5 150.4,72.91 156.96,72.91 v1(157.57,73.52) ; L25.1 v1(110.07,157.6) ; v1(23.45,151.24) 21.42,153.27 14.69,153.27 13.52,154.44 13.52,160.53 R447.1 13,160.88 12.22,161.66 R446.1
  vias: v1(57.8,108.76) v1(58.81,109.33) v1(59.14,108.8) v1(61.78,78.55) v1(62.39,78.55) v1(79.71,48.88) v1(80.34,48.84) v1(93.68,48.77) v1(111.29,48.65) v1(111.9,48.65) v1(117.18,155.81) v1(117.94,155.81) v1(118.7,155.81) v1(121.5,42.4) v1(122.26,42.4) v1(134.86,40.6) v1(225,37.7) v1(225,37.07) v1(227.03,44.69) v1(227.67,44.69) v2(69.3,94.6) v2(69.3,93.84) v2(164.68,68.56) v2(168.87,83.8) v2(168.87,83.04) v2(168.87,82.28) v2(218.65,64.07) v2(218.65,63.31)
+3V_DMIC: length 6.2
  TOP w0.508: R426.2 234.41,16.89 C516.1 C781.2 235.04,15.22 235.42,15.6 v1(235.42,16.49)
  BOTTOM w0.508: v1(235.42,16.49) 235.44,16.47 CN20.2
+3V_EC: length 4.6
  TOP w0.203: v1(138.39,62.62) 138.88,62.13 U32.11
  TOP w0.508: v1(138.39,62.62) 138.03,62.62 137.88,62.47 C407.1 137.25,62.88 137.6,63.23 137.59,63.24 R332.1
+3V_GFX: length 281.6
  TOP w0.279: R176.1 65.37,115.05 65.11,114.79 Q12.5 ; Q12.2 61.18,114.79 R175.1
  TOP w0.508: R171.2 v1(56.22,113.78) ; v1(28.3,96.78) 28.3,97.09 25.61,99.78 25.61,103.87 25.99,104.25 25.99,108.82 26.76,109.58 v1(26.76,111.87) ; v1(36.28,113.9) 37.04,113.9 Q14.2 36.92,114.54 v1(36.28,114.54) ; R361.2 v1(159.85,57.39) ; Q10.2 v1(52.51,116.7) ; R362.2 136.47,56.93 136.23,56.69 136.17,56.69 135.86,56.39 135.86,55.72 135.87,55.71 135.87,53.1 135.59,52.82 v1(135.34,52.82) ; R65.2 v1(22.83,146.3) ; v1(38.31,51.95) 39.48,50.78 55.19,50.78 v1(56.44,52.03) ; v1(14.82,143.24) 14.44,143.24 14.31,143.1 R70.2 ; v1(53.93,113.78) R169.2 R170.2 ; v1(38.54,108.42) 38.92,108.03 R185.2 ; R175.1 v1(60.79,113.78) ; R182.2 34.69,108.76 v1(34.64,108.7) ; R176.1 66.01,115.05 v1(66.63,115.68) ; R71.2 v1(17.74,142.99) ; R380.2 v1(159.85,52.82) ; v1(36.03,108.7) 36.03,109.32 R180.2
  IN2 w0.508: v1(38.31,51.95) 38.31,53.45 33.74,58.02 32.6,58.02 31.28,59.34 31.28,65.82 29.22,67.88 29.22,89.72 30.95,91.45 30.95,94.47 28.63,96.78 v1(28.3,96.78) ; v1(155.15,52.94) 154.9,52.94 152.87,50.91 149.69,50.91 148.68,49.89 137.7,49.89 136.18,51.42 135.34,51.42 ; 135.34,51.42 v1(135.34,52.82) ; 135.34,51.42 128.23,51.42 125.64,48.83 112.58,48.83 112.1,49.31 97.19,49.31 96.88,49.62 91.5,49.62 90.64,48.75 81.31,48.75 80.45,49.62 68.64,49.62 67.22,48.19 66.68,48.19 65.93,48.94 64.16,48.94 62.72,50.38 62.08,50.38 61.06,51.39 56.93,51.39 56.44,51.89 v1(56.44,52.03)
  IN3 w0.508: v1(28.15,119.36) 28.02,119.49 28.02,120.38 25.1,123.3 25.1,123.68 24.09,124.7 v1(24.09,125.08) 24.09,126.6 20.58,130.11 20.58,140.14 v1(17.74,142.99) ; v1(155.15,52.94) 155.91,53.7 158.96,53.7 v1(159.85,52.82) 159.85,53.07 161.12,54.34 161.12,55.61 159.85,56.88 v1(159.85,57.39)
  BOTTOM w0.508: R584.2 v1(68.7,119.47) ; v1(41.23,112.89) 41.75,112.37 R624.2 ; R583.1 v1(66.67,119.47) ; v1(45.93,113.78) R605.2 45.42,114.4 45.17,114.16 R618.1 ; v1(14.82,143.24) 15.07,143.49 17.23,143.49 v1(17.74,142.99) 21.05,146.3 v1(22.83,146.3) ; v1(49.36,113.78) R608.2 R609.2 R610.2 ; 36.66,108.82 38.13,108.82 v1(38.54,108.42) ; R606.2 v1(47.08,113.78) ; R566.2 22.3,121.91 22.06,122.16 22.06,123.81 22.32,124.07 R552.2 22.69,124.7 23.07,125.08 v1(24.09,125.08) ; R591.1 v1(70.86,118.46) ; R630.2 R629.2 v1(50.5,111.62) ; R627.1 v1(48.22,111.62)
  vias: v1(26.76,112.51) v1(32.6,112.12) v1(34.12,106.33) v1(34.12,105.65) v1(36.76,126.17) v1(36.76,125.33) v1(48.28,127.73) v1(48.3,127.01) v1(48.3,126.21) v1(48.35,125.33) v1(49.08,127.95) v1(49.62,122.16) v2(34.5,117.71) v2(35.26,117.71)
+3V_MAIN_EN: length 7.7
  BOTTOM w0.14: 51.65,116.16 TP138.1
  BOTTOM w0.152: U43.A3 54.07,121.29 54.07,119.27 51.62,116.82 TP138.1 ; R610.1 51.65,116.16
+3V_PCH_ME: length 28
  TOP w0.508: R76.1 155.18,140.56 155.18,141.44 153.76,142.86 v1(151.72,142.86) ; v1(151.64,138.77) 151.21,139.2 R77.1 149.94,139.43 R80.1 ; 155.66,127.75 155.66,128.51 154.9,129.27 U14.8 154.9,131.56 154.14,132.32 v1(151.62,132.32)
  IN2 w0.508: v1(151.72,142.86) 151.89,142.69 151.89,141.38 151.64,141.12 v1(151.64,138.77) 151.64,135.92 150.96,135.24 150.96,132.98 v1(151.62,132.32)
  BOTTOM w0.508: v1(151.64,138.77) 151.64,138.91 151.62,138.9 R494.1
+3V_RTC: length 115.8
  TOP w0.203: U32.3 139.34,65.33 138.54,64.53 138.26,64.53
  TOP w0.381: v1(139.71,115.1) 138.87,115.93 C249.2
  TOP w0.508: v1(129.09,65.39) 129.35,65.13 R722.1 129.73,64.55 128.85,63.68 R726.1 C716.1 ; 138.26,64.53 137.47,64.53 137.25,64.75 C397.1 137.45,65.33 v1(138.46,65.33)
  TOP w0.635: R726.1 129.37,62.84 D15.3
  IN1 w0.635: v1(138.46,65.33) 138.13,65.66 138.13,67.29 141.08,70.24 141.08,74.43 142.01,75.36 143.91,75.36 145.86,77.3 145.86,88.5 147.04,89.69 147.04,95.33 v1(147.28,95.57) 145.68,95.57 144.59,96.66 144.59,99.27 145.27,99.96 146.12,99.96 146.36,99.72 v1(146.36,99.7)
  IN2 w0.508: v1(139.71,115.1) 140.12,115.1 140.47,114.74 140.47,114.16 140.59,114.03 140.59,113.5 140.75,113.34 140.75,110.24 141.25,109.74 141.51,109.74 141.79,109.46 141.79,108.04 140.29,106.54 140.29,99.2 143.22,96.28 146.19,96.28 146.9,95.57 v1(147.28,95.57) ; v1(149.06,100.82) 148.24,100.01 146.67,100.01 v1(146.36,99.7)
  BOTTOM w0.305: U45.AG10 139.36,115.1 v1(139.71,115.1)
  BOTTOM w0.508: R676.1 145.02,99.52 146.18,99.52 v1(146.36,99.7) 146.52,99.54 R677.2 147.48,99.09 147.48,98.38 147.83,98.04 C682.1 C683.2 ; R665.1 149.31,101.33 149.06,101.08 v1(149.06,100.82)
  BOTTOM w0.635: v1(138.46,65.33) 137.53,65.33 137.21,65.01 137.21,61.29 135.09,59.17 133.05,59.17 132.55,59.67 132.55,61.93 v1(129.09,65.39)
+3V_RTC_0: length 73.1
  TOP w0.508: v1(97.11,72.35) 97.27,72.5 97.27,73.26 96.83,73.69 93.66,73.69 92.39,74.96 86.27,74.96 85.48,75.76 Q42.1
  TOP w0.635: v1(126.32,66.91) 126.75,66.48 126.75,63.31 127.52,62.54 R336.1
  IN1 w0.635: v1(126.32,66.91) 126.83,67.42 126.83,70.6 125.82,71.61 97.85,71.61 v1(97.11,72.35) 96.38,71.61 93.24,71.61 92.53,70.9 91.35,70.9 v1(90.76,71.48)
  BOTTOM w0.635: v1(90.76,71.48) 90.51,71.74 90.51,73.77 v3(88.63,75.65) CN9.1
+3V_RTC_1: length 2.1
  TOP w0.508: R336.2 128.39,62.15 128.38,62.14 v1(128.38,61.71) 128.36,61.68 D15.1
+3V_RTC_2: length 3.9
  TOP w0.508: R349.1 132.67,60.94 131.99,61.63 v1(131.38,61.63) 130.82,61.63 130.39,61.2 D15.2
+3V_S5: length 700.3
  TOP w0.14: v1(143.6,103.74) 143.46,103.61 R209.1
  TOP w0.254: R274.2 86.83,90.29 83.52,86.98 81.99,86.98 80.77,85.76 80.77,84.62 81.15,84.24 83.56,84.24 88.3,88.99 88.3,91.37 v3(89.37,92.44) 88.9,92.91 88.9,103.45 v1(87.72,104.63) 87.72,107.73 86.32,109.13 86.32,112.53 v1(86.95,113.17)
  TOP w0.279: v1(204.86,90.61) 204.86,90.03 205.16,89.72 205.7,89.72 205.95,89.98 Q22.2 Q22.5 ; Q21.2 Q21.5 ; R240.1 146.25,97.28 145.94,96.97 Q19.2 Q19.5 145.94,92.89 146.08,92.75 R260.1
  TOP w0.381: v1(151.22,119.9) 151.1,119.78 R141.1 ; R204.1 153.48,103.89 v1(153.48,103.36) ; R208.1 142.03,103.82 142.75,103.82 R209.1 ; v1(157.77,118.65) 157.69,118.65 157.18,119.16 157.18,119.64 156.65,120.18 156.19,120.18 156.07,120.05 155.49,120.05 R138.2 155.29,120 155.16,119.87 R146.1 ; R228.2 149.95,101.45 149.61,101.79 149.61,102.81 R214.1 ; v1(146.9,103.64) R221.2 147.03,102.47 147.67,102.47 R226.2 ; R213.2 151.65,104.5 v1(151.49,104.66)
  TOP w0.508: v1(158.45,105.06) 158.45,104.63 158.59,104.5 R206.1 ; 147.41,75.05 R300.2 ; 147.41,75.05 v1(147.41,74.2) ; 147.41,75.05 R299.2 ; 164.8,71.61 163.64,70.44 163.64,64.63 ; C1.2 v1(33.49,169.02) ; v1(153.12,144.13) 153.5,144.13 154,144.63 154,149.75 153.64,150.11 PR8.2 ; R202.1 146.9,104.01 v1(146.9,103.64) ; v1(152.23,100.69) 151.84,100.31 R231.1 ; R244.1 R255.1 152.62,92.56 152.72,92.46 v1(152.72,91.96) ; 163.64,64.63 163.64,57.16 v1(163.66,57.13) ; 163.64,64.63 168.87,64.63 170.28,66.04 PR84.1 ; v1(198.71,94.19) 198.71,93.2 199.09,92.82 200.11,92.82 ; v1(145.17,101.08) 145.17,101.3 144.74,101.74 R219.2 R220.2 ; v1(144.6,144.23) 144.6,144.49 143.72,145.38 PR18.2 ; v2(10.11,153.02) 10.37,153.28 R44.2 ; v1(136.36,77.71) 136.91,78.27 136.91,79.03 137.52,79.64 137.52,84.56 137.98,85.02 137.98,86.14 135.47,88.66 135.47,95.61 138.36,98.51 138.36,102.78 138.26,102.88 R211.2 R210.2 ; R214.1 R203.2 149.44,104.38 149.79,104.02 v1(149.87,104.02) ; C6.2 v1(61.55,169.02) ; R168.1 154.62,115.37 154.31,115.07 154.31,115.05 154.26,115 154.26,112.06 v1(154.82,111.5) ; v1(100.67,136) 100.67,137.78 100.29,138.16 100.29,140.83 ; R260.1 146.08,91.42 146.36,91.14 R273.1 146.36,89.9 146.52,89.75 Q23.1 147.02,89.01 147.52,88.51 R277.2 148.68,88.51 149.02,88.86 C307.1 149.56,89.39 150.01,89.84 152.69,89.84 v1(152.87,90.01) ; v1(91.04,149.59) 91.04,150.95 C58.2 ; v2(123,153.43) 123.91,154.34 C47.2
  TOP w0.762: v1(91.04,149.59) 92.44,148.19 94.7,148.19 96.73,146.16 96.73,141.59 97.49,140.83 109.31,140.83 116.16,147.68 116.16,150.73 118.86,153.43 v2(123,153.43)
  TOP w1.27: R324.1 211.84,69.78 208.16,69.78 v1(203.5,74.44) 199.73,78.22 189.95,78.22 187.41,80.76 180.68,80.76 175.09,75.17 169.25,75.17 166.96,72.88
  IN1 w0.508: v1(152.21,74.2) 152.21,75.07 151.22,76.06 151.22,77.96 151.85,78.6 151.85,79.36 151.47,79.74 151.47,83.26 153.12,84.91 153.12,87.55 152.55,88.12 152.55,89.69 v1(152.87,90.01) ; v2(152.64,140.57) 152.64,142.5 153.09,142.96 153.09,144.1 v1(153.12,144.13)
  IN1 w0.762: v1(157.77,118.65) 158.96,117.46 v1(158.96,113.73) v1(158.96,112.99) ; v2(152.64,140.57) 149.18,140.57 147.02,142.73 145.6,142.73 144.6,143.73 v1(144.6,144.23) 144.6,145.7 145.25,146.34 145.25,147.58 145.6,147.94 145.6,151.9 144.97,152.54 v1(144.66,152.54) ; v2(15.67,160.37) 16.67,159.37 21.85,159.37 27.26,164.78 27.26,166.02 28.33,167.09 31.56,167.09 v1(33.49,169.02) 34.38,169.91 60.66,169.91 v1(61.55,169.02) 72.55,158.02 84.11,158.02 85.18,156.96 85.18,156.19 91.04,150.33 v1(91.04,149.59)
  IN2 w0.254: v1(86.95,113.17) 86.95,113.78 88.22,115.05 90.64,115.05 94.19,118.6 94.19,122.92 95.34,124.06 95.34,127.24 96.38,128.28 96.38,130.69 96.86,131.17 97.75,131.17 99.4,132.83 99.4,134.73 v1(100.67,136)
  IN2 w0.381: v1(151.22,119.9) 151.22,120.1 151.75,120.63 152.99,120.63 153.55,120.08 154.62,120.08 154.67,120.13 156.19,120.13 156.37,120.3 157.11,120.3 157.16,120.25
  IN2 w0.508: v1(149.69,113.57) 149.69,113.44 147.56,111.31 147.56,109.94 146.77,109.15 146.77,108.62 147.11,108.28 147.11,107.21 147.66,106.66 ; 152.61,101.84 153.88,100.57 v1(154.9,100.57) ; v1(136.36,77.71) 136.23,77.58 136.23,76.69 136.99,75.93 145.68,75.93 v1(147.41,74.2) ; v2(48.06,74.98) 48.39,75.31 48.39,77.37 50.39,79.37 54.87,79.37 56.3,80.81 61.63,80.81 63.09,79.35 74.49,79.35 75.26,80.11 v2(79.07,80.11) ; v1(152.87,90.01) 152.72,90.15 v1(152.72,91.96) 152.72,100.2 v1(152.23,100.69) ; v1(163.66,57.13) 163.66,55.23 161.82,53.39 161.82,50.72 161.35,50.25 161.35,49.29 161.88,48.75 169.76,48.75 171.41,47.1 v1(173.64,47.1) ; v2(10.11,153.02) 10.88,153.79 10.88,158.23 13.03,160.37 v2(15.67,160.37)
  IN2 w0.762: v2(152.64,140.57) 152.38,140.32 152.38,130.46 158.81,124.04 158.81,122.36 157.16,120.71 157.16,119.01 157.51,118.65 v1(157.77,118.65) ; v1(144.66,152.54) 144.36,152.54 143.57,151.75 134.09,151.75 133.69,152.15 132.65,152.15 132.11,151.62 130.21,151.62 129.29,152.54 125.64,152.54 124.28,153.9 123.47,153.9 v2(123,153.43)
  IN3 w0.508: v2(79.07,80.11) 80.72,80.11 88.13,87.53 88.13,104.21 v1(87.72,104.63) ; v1(147.41,74.2) 148,74.8 151.61,74.8 v1(152.21,74.2) ; v1(145.17,101.08) 145.17,101.91 143.6,103.49 v1(143.6,103.74)
  IN3 w0.762: v2(9.79,164.58) 9.79,164.12 10.47,163.43 12.61,163.43 v2(15.67,160.37)
  BOTTOM w0.254: C623.2 100.8,135.49 100.65,135.35 U42.5 ; v1(159.01,110.7) 159.01,110.08 RP2.10
  BOTTOM w0.305: RP2.5 161.73,107.43 v1(161.86,107.55) ; C677.2 155.52,99.43 155.77,99.19 U47.5
  BOTTOM w0.457: v1(149.69,113.57) 149.61,113.65 R619.1 ; v1(154.82,111.5) 154.78,111.54 R635.2 R622.1 ; R643.2 v1(154.39,109.46) R636.1 R637.1 ; R651.1 152.07,104.66 v1(151.49,104.66) ; R641.1 156.17,107.81 155.41,107.04 v1(155.41,106.92) R646.1
  BOTTOM w0.508: R650.2 150.74,104.66 v1(151.49,104.66) ; v2(48.06,74.98) 47.4,74.32 47.4,73.02 47.94,72.48 48.68,72.48 48.77,72.57 PR178.2 ; v2(152.64,140.57) 153.09,140.12 R494.2 ; C623.2 101.42,135.63 101.05,136 v1(100.67,136) ; v1(203.5,74.44) 204.08,74.44 204.73,75.09 204.73,77.15 204.48,77.4 204.48,82.28 206.56,84.36 206.56,85.91 204.99,87.49 202.65,87.49 202.14,87.99 202.14,89.06 202.65,89.57 204.35,89.57 204.86,90.08 v1(204.86,90.61) 202.29,90.61 v1(198.71,94.19) ; PR133.2 144,152.87 144.33,152.54 v1(144.66,152.54) ; R648.1 151.85,106.66 152.71,107.53 v1(153.42,107.53) ; C677.2 v1(154.9,100.57) ; R767.1 v1(173.64,47.1)
  vias: v1(154.03,107.48) v1(155.2,109.46) v1(159.98,96.35) v1(160.38,95.79) v1(160.64,96.35) v1(160.99,95.79) v2(166.96,76.06) v2(166.96,75.29) v2(166.96,74.53)
+3V_TPM_VDD: length 34.3
  IN2 w0.508: v1(173.31,42.02) 172.58,41.28 v1(170.39,41.28) 169.1,39.99 163.53,39.99 162.37,41.16 v1(161.63,41.16)
  BOTTOM w0.406: v1(170.39,41.28) 170.27,41.41 U56.10 ; U56.24 162.26,44.66 162.14,44.54 161.65,44.54 161.63,44.56 ; 162.26,41.41 U56.19
  BOTTOM w0.508: 173.95,44.05 R775.2 ; 173.95,44.05 173.95,46.21 174.58,46.85 174.58,47.35 173.82,48.12 R765.1 ; 173.95,44.05 173.95,42.4 173.57,42.02 v1(173.31,42.02) R780.2 ; C776.1 C778.1 R782.1 161.22,40.75 v1(161.63,41.16) 162.01,41.16 162.26,41.41 ; C776.1 161.63,44.56 ; C776.1 C772.2
+3V_WLAN:
  vias: v1(216.21,68.06)
+3VCC_S5: length 94.3
  TOP w0.381: C238.1 137.18,116.9 137.18,115.16 v1(137.27,115.07) 137.27,114.95 137.96,114.26 v1(137.97,114.26)
  TOP w0.508: v1(143.9,92.92) 144.08,93.1 144.08,93.61 142.84,94.85 C292.2 ; v1(150.33,85.33) 149.54,86.12 145.73,86.12 144.48,87.36 Q23.3 145.37,88.88 145.37,90.03 144.89,90.51 R273.2 ; C238.1 136.75,118.15 v1(136.89,118.3)
  IN2 w0.508: 134.58,116.19 133.41,115.02 132.01,115.02 131.09,114.1 131.09,109.69 133.71,107.07 133.71,106.6 134.07,106.24 134.59,106.24 136.99,103.84 136.99,97.11 141.79,92.31 143.29,92.31 v1(143.9,92.92) 144.26,93.28 144.92,93.28 146.39,91.8 146.39,89.26 v1(150.33,85.33) 147.79,82.79 147.79,76.26 150.38,73.67 150.38,72.88 149.82,72.32 149.82,71.63 150.5,70.94 v1(150.5,69.33)
  BOTTOM w0.254: 138.01,118.47 138.03,118.5 U45.AA9 U45.AC9 ; v1(137.97,114.26) 138.31,114.6 U45.AH11
  BOTTOM w0.381: U45.AE21 133.54,116.55 U45.AE20 133.77,116.68 134.1,116.68 v1(134.25,116.82)
  BOTTOM w0.508: R723.2 155.66,66.25 153.61,68.3 151.53,68.3 v1(150.5,69.33) ; v1(136.89,118.3) 137.07,118.47 138.01,118.47
+3VCPVDD: length 7.1
  TOP w0.14: v1(240.62,43.26) 240.64,43.24 241.21,43.24 241.64,43.67 v1(242.15,43.67)
  TOP w0.203: 238.59,42.53 238.38,42.32 U34.36
  TOP w0.508: v1(240.62,43.26) 240.53,43.26 240.23,43.55 C491.1 240.12,43.8 239.23,42.91 238.97,42.91 238.59,42.53
  BOTTOM w0.508: v1(240.62,43.26) 240.45,43.26 240.22,43.49 240.22,44.43 R774.1
+3VDVDD: length 5.9
  TOP w0.203: 230.84,42.66 231.18,42.32 U34.1
  TOP w0.508: 230.84,42.66 229.46,42.66 C495.1 228.4,42.65 C494.1 R398.1 226.04,42.43 v1(226.02,42.4)
+3VDVDDIO: length 8.2
  TOP w0.14: R408.2 226.63,36.69 226.15,36.69 v1(225.89,36.43)
  TOP w0.203: U34.9 230.87,39.12 230.22,39.76 229.73,39.76 229.19,39.23
  TOP w0.508: 229.19,39.23 228.57,38.6 C502.1 228.42,38.59 C499.1 R408.2
+3VPCU: length 329.7
  TOP w0.254: v1(48.14,78.42) 48.14,77.58 47.34,76.78 PR59.2 ; RP1.5 62.7,50.02 62.44,49.77 62.44,47.94 61.98,47.48 RP1.10 60.28,46.17 60.28,45.48 v1(60.38,45.37)
  TOP w0.305: 47.5,78.8 47.55,78.75 47.81,78.75 v1(48.14,78.42) ; 227.81,64.36 U26.5
  TOP w0.381: R301.2 149.56,73.77 149.19,73.39 v1(149.18,73.39) 149.18,72.75 149.44,72.5 149.44,71.49 R313.2 ; PR55.2 47.5,78.8 47.5,79.49 47.84,79.82 47.84,80.3 47.74,80.39 ; v1(149.17,98.82) 149.06,98.93 R237.2 R238.2 ; v1(34.45,59.45) PR101.2
  TOP w0.508: R331.2 231.61,63.36 227.2,63.36 v1(226.94,63.61) 226.94,64.09 C400.1 227.16,64.25 227.27,64.36 227.81,64.36 ; R212.2 138.97,102.55 138.97,98.26 136.08,95.36 136.08,88.91 138.59,86.39 138.59,84.77 138.13,84.31 138.13,81.14 138.9,80.37 139.91,80.37 140.93,79.36 140.93,76.98 140.49,76.54 140.49,74.09 140.55,74.03 140.55,73.64 139.94,73.03 v1(139.76,73.03) ; R310.2 v1(142.83,72.25) ; D16.1 133.23,57.18 132.83,56.78 132.83,54.24 132.56,53.97 v1(130.74,53.97) ; D16.1 134.91,58.33 134.15,59.09 R349.2 ; D16.1 135.99,58.27 R353.2 ; v1(194.73,67.29) 194.73,67.57 194.89,67.74 PR80.1 194.4,68.18 193.14,66.93 PR85.1 ; R234.2 R235.2 145.75,99.42 146.11,99.07 v1(146.11,98.79) ; PC35.1 47.74,80.39 47.68,80.45 46.11,80.45 PR49.2 ; v1(54.75,59.93) 55.39,60.57 PR97.2 55.39,61.05 55.53,61.19 55.53,62.06 55.45,62.15 PR94.2 ; 153.63,72.88 153.49,72.88 R315.2 ; R45.2 12.41,153.77
  TOP w0.635: LED1.1 10.25,165.23 10.58,164.91 v2(10.58,164.58)
  TOP w0.762: 11.26,151.37 10.12,150.22 10.12,147.81 9.86,147.56 9.86,145.04 9.32,144.5 9.32,143.01 8.91,142.6 8.91,134.79 9.23,134.48 9.23,130.41 7.4,128.58 7.4,123.63 5.55,121.77 v1(5.55,118.35) 5.55,114.92 7.93,112.53 12.61,112.53 13.04,112.96 20.35,112.96 21.29,113.9 22.44,113.9 v2(22.69,114.16)
  IN1 w0.381: v2(174.33,63.86) 174.15,64.04 174.15,67.78 177.17,70.8 181.75,70.8 182.91,71.97 191.78,71.97 193.23,70.52 193.23,68.79 v1(194.73,67.29)
  IN1 w0.508: v1(52,68.06) 52.51,68.56 v1(54.57,68.56) ; 50.38,53.2 53.32,53.2 55.46,55.33 55.46,59.22 v1(54.75,59.93)
  IN2 w0.508: v1(148.29,66.53) 148.29,67.93 149.36,69 149.36,70.85 149.06,71.15 149.06,73.26 v1(149.18,73.39) ; v1(146.11,98.79) 146.11,98.56 146.52,98.15 147.15,98.15 147.53,98.54 147.53,99.04 147.89,99.4 148.59,99.4 v1(149.17,98.82) 150.78,97.21 150.78,90.16 153.19,87.76 153.68,87.76 156.1,85.35 156.1,79.61 155.79,79.3 155.79,76.31 154.9,75.42 v1(154.9,74.22) ; 215.73,61.45 215.99,61.2 217.76,61.2 219.76,63.19 219.76,65.35 220.43,66.02 224.53,66.02 v1(226.94,63.61)
  IN2 w0.762: v2(25.54,164.47) 25.54,163.48 23.33,161.27 v2(21.68,161.27) 19.9,159.5 17.84,159.5 17.31,160.03 ; v2(12.71,155.56) 12.71,156.37 14.72,158.38 15.66,158.38 17.31,160.03 ; 17.31,160.03 16.09,161.25 13.9,161.25 v2(10.58,164.58)
  IN3 w0.508: 52,68.08 52.66,68.74 52.66,72.09 51.61,73.15 51.61,75.71 50.44,76.88 50.44,77.52 49.54,78.42 v1(48.14,78.42) ; 52,68.08 51.14,68.08 50.45,67.4 50.45,66.05 50.89,65.62 50.89,61.71 52.66,59.93 v1(54.75,59.93) ; 52,68.08 v1(52,68.06)
  BOTTOM w0.203: PR193.2 54.72,68.42 v1(54.57,68.56)
  BOTTOM w0.254: CN6.12 5.63,118.43 v1(5.55,118.35)
  BOTTOM w0.457: R686.2 146.06,98.74 v1(146.11,98.79)
  BOTTOM w0.508: R716.2 149.03,67.04 R717.2 148.29,66.76 v1(148.29,66.53) ; v2(21.68,161.27) 21.68,161.52 R439.2 R440.2 ; v1(130.74,53.97) 130.74,51.14 126.96,47.35 126.96,46.34 ; v1(142.83,72.25) 142.97,72.25 144.1,73.38 ; 144.1,73.38 149.17,73.38 v1(149.18,73.39) ; 144.1,73.38 143.48,73.38 142.96,73.9 142.4,73.9 141.64,73.14 140.27,73.14 140.17,73.03 v1(139.76,73.03)
  vias: v1(12.79,154.54) v1(100.29,43.16) v1(100.92,43.16) v1(101.56,43.16) v1(102.19,43.16) v1(102.8,43.16) v1(153.73,74.21) v1(153.73,73.6) v1(160.82,64.02) v1(160.82,63.38) v1(160.82,62.75) v2(23.2,114.79) v2(23.2,113.52) v2(34.27,49.59) v2(34.96,50.33) v2(34.98,49.62) v2(41.08,45.27) v2(41.56,45.88) v2(41.97,45.27) v2(124.55,44.38) v2(124.55,43.62) v2(125.43,44.38) v2(125.43,43.62) v2(126.45,44.38) v2(126.45,43.62) v2(130.77,44.18) v2(167.98,67.55) v2(172.55,63.86) v2(173.31,63.86) v2(175.09,63.86) v2(215.6,64.4) v2(215.63,63.66) v2(215.63,62.93) v3(128.71,46.34)
+3VPCU_EC: length 84.2
  TOP w0.203: U32.114 147.44,69.73 C372.1 ; U32.26 139.28,56.13 138.9,55.75 v2(138.14,55.75) ; U32.50 148.64,51.07 v1(148.8,50.91) ; 145.37,70.47 145.37,69.42 144.64,68.69 U32.121 ; U32.92 156.7,64.53 156.98,64.25 v2(157.43,64.25)
  TOP w0.508: v2(157.43,64.25) 158.06,64.88 C399.1 ; v2(138.14,55.75) 137.97,55.75 137.58,55.36 137.51,55.36 C429.1 ; L20.1 159.83,53.96 160.61,53.17 v1(160.61,52.82) ; C371.1 145.37,70.47 v1(144.74,69.83) ; C372.1 148.29,69.94 148.17,69.81 v1(148.17,69.58)
  TOP w0.762: C399.1 C402.1 158.45,63.35 158.35,63.26 R337.2 ; v2(142.71,73.14) v1(141.69,73.14) 141.59,73.14 140.67,72.22 L18.2
  IN2 w0.762: 142.07,67.29 140.67,65.9 140.67,64.88 137.52,61.73 137.52,59.95 137.25,59.67 137.25,56.24 137.74,55.75 v2(138.14,55.75)
  IN3 w0.508: v2(157.43,64.25) 158.45,64.25 160.99,61.71 160.99,60.18 162.14,59.04 162.14,54.34 v1(160.61,52.82)
  BOTTOM w0.508: v1(148.8,50.91) 148.8,52.51
  BOTTOM w0.762: v2(138.14,55.75) 139.11,55.75 140.91,53.96 140.98,53.96 141.59,53.35 141.59,52.79 142.82,51.55 C767.1 148.23,52.51 153.2,52.51 156.18,55.5 156.18,61.36 156.82,62 156.82,63.63 v2(157.43,64.25)
+3VPCU_ECPLL: length 4.5
  TOP w0.203: v1(142.07,69.58) 142.24,69.41 U32.127
  TOP w0.508: v1(142.07,69.58) 141.69,69.96 141.69,70.71 C369.1 L18.1
+5V: length 140.7
  TOP w0.508: R394.1 70.58,47.24 71.59,48.24 73.62,48.24 74.25,47.61 Q32.1 ; v2(89.87,149.92) D2.2 v2(88.27,149.92) ; PR120.1 215.99,45.58 v2(216.47,45.09) ; C3.2 v1(35.77,169.02) ; C4.2 v1(59.27,169.02) ; R230.1 56.75,100.65 56.75,99.93 v1(56.42,99.6)
  IN1 w0.508: v2(102.07,161.27) 103.84,161.27 104.16,160.96 105.69,160.96 106.26,160.38 107.4,160.38 107.91,160.89 109.66,160.89 v1(112.33,158.23)
  IN1 w0.762: 88.27,149.95 88.3,149.97 89.82,149.97 v2(89.87,149.92) ; 88.27,149.95 88.25,149.97 86.83,149.97 84.79,152 84.79,153.22 84.03,153.98 v2(84.03,154.72) 84.03,155 83.09,155.94 72.86,155.94 60.92,167.88 60.41,167.88 v1(59.27,169.02) v1(35.77,169.02) 32.95,166.2 28.79,166.2 28.18,165.59 28.18,164.47 18.65,154.95 14.64,154.95 10.88,158.71 v2(10.88,162.29) ; 88.27,149.95 v2(88.27,149.92)
  IN3 w0.508: v2(68.67,97.9) 68.67,98.15 67.73,99.09 56.93,99.09 v1(56.42,99.6)
  BOTTOM w0.508: Q37.3 83.91,155.15 84.03,155.03 v2(84.03,154.72) ; v1(180.68,83.04) 180.37,83.36 R697.1 ; 113.37,158.23 v1(112.33,158.23) ; v2(89.87,149.92) D2.2
  vias: v1(35.65,43.93) v1(35.65,43.29) v1(36.06,73.64) v1(36.06,73.01) v1(36.28,43.93) v1(36.28,43.29) v1(36.7,73.64) v1(36.7,73.01) v1(92.41,48.77) v1(93.05,48.77) v1(102.02,163.05) v2(59.85,44.97) v2(60.29,44.41) v2(60.9,44.92) v2(61.39,44.41) v2(96.1,153.78) v2(96.86,153.78) v2(102.07,160.51) v2(166.33,51.42) v2(166.58,47.1) v2(166.96,47.86) v2(167.09,51.42) v2(167.34,47.1) v2(167.85,51.42) v2(167.85,47.86) v2(168.11,47.1) v2(190.2,82.86) v2(190.2,82.13) v2(190.2,81.39) v2(216.11,44.36) v2(216.11,43.54) v2(216.87,44.36) v2(216.87,43.54) v2(217.23,45.07) v2(217.64,44.36) v2(217.64,43.54) v2(238.34,54.85) v2(238.34,54.09) v2(239.23,54.85) v2(239.23,54.09)
+5V_FAN1:
  vias: v1(188.1,83.65)
+5V_FAN2:
  vias: v1(12.53,166.1) v1(12.53,165.41) v1(14.56,156.19) v1(15.15,155.69)
+5V_HDD:
  vias: v2(34.27,75.55) v2(34.27,74.63) v2(34.86,76.01) v2(34.86,75.12) v3(34.76,73.52)
+5V_KB:
  vias: v1(75.09,50.78)
+5V_KB_R: length 5.1
  TOP w0.508: v1(69.99,48.12) 70.19,48.12 71.21,49.13 71.21,50.83 71,51.04 v1(71,51.62) 71.06,51.68 R382.2
+5V_S5: length 342.9
  TOP w0.254: PC18.2 18.44,120.95 17.87,120.38 PU2.7
  TOP w0.381: v1(90.76,92.82) 91.65,91.93 91.65,89.01 91.01,88.37 R280.1
  TOP w0.508: PC18.2 19.13,121.53 19.64,121.01 v1(19.64,119.87) ; R794.1 R797.1 79.53,72.78 68.67,72.78 67.06,74.38 67.06,77.07 v1(66.66,77.47) 65.89,78.24 63.94,78.24 63.36,77.66 61.38,77.66 60.92,77.2 v1(60.21,77.2) ; v2(216.37,49.01) 215.22,49.01 215.1,49.13 PR117.1
  IN1 w0.508: v1(146.14,146.8) 146.14,146.31 147.28,145.17 147.28,144.56 147.68,144.15 149.26,144.15 149.44,144.34 152.06,144.34 152.56,144.84 v1(153.12,144.84)
  IN2 w0.381: v2(32.47,45.32) 32.47,47.1 32.17,47.41 32.17,49.62 36.05,53.5 v1(36.05,54.72) ; v1(66.66,77.47) 75.54,77.47 76.36,78.29 82.58,78.29 87.31,83.02 87.31,90.84 89.29,92.82 v1(90.76,92.82)
  IN2 w0.508: v1(153.12,144.84) 154.47,144.84 154.52,144.89 ; v1(51.27,76.95) 55.41,76.95 55.99,77.53 59.88,77.53 v1(60.21,77.2) ; v1(8.59,121.01) 9.99,119.62 19.39,119.62 v1(19.64,119.87) ; v1(148.62,154.67) 148.62,154.44 149.08,153.98 150.96,153.98 151.33,153.62
  IN2 w0.762: v2(192.46,92.62) 191.68,91.83 183.32,91.83 180.93,94.22 179.92,94.22 166.73,107.4 166.73,114.36 163.71,117.38 163.71,122.87 155.28,131.3 155.28,139.05 154.52,139.81 154.52,150.43 151.33,153.62
  IN3 w0.381: v1(36.05,54.72) 36.43,54.34 55.2,54.34 55.58,54.72 55.58,60.31 54.95,60.94 52.79,60.94 52.03,61.71 52.03,66.81 54.16,68.94 54.16,69.58 53.88,69.86 53.88,72.42 52.51,73.8 52.51,75.7 v1(51.27,76.95)
  IN3 w0.508: v1(146.14,146.8) 146.14,146.49 145.07,145.42 141.06,145.42 140.6,144.97 v1(140.04,144.97)
  IN3 w0.762: 217.48,51.57 214.77,51.57 213.7,52.64 213.7,53.88 212.81,54.77 212.81,63.86 208.87,67.8 206.41,67.8 203.29,70.93 v2(203.29,72.3)
  BOTTOM w0.178: PU7.2 140.73,145.46 140.67,145.4 PC96.1
  BOTTOM w0.254: v1(51.27,76.95) 51.41,77.09 PR164.2
  BOTTOM w0.508: v1(140.04,144.97) 140.09,144.92 140.64,144.92 PC96.1 ; PR132.2 148.4,154.44 v1(148.62,154.67)
  BOTTOM w0.762: v2(203.29,72.3) 202.52,73.06 202.52,81.26 201.38,82.41 201.38,84.96 199.63,86.72 199.63,87.89 194.9,92.62 v2(192.46,92.62)
  BOTTOM w2.032: 64.37,43.77 89.26,43.77
  vias: v1(7.32,121.65) v1(7.32,121.01) v1(7.96,121.01) v1(37.22,43.93) v1(37.68,44.43) v1(37.85,43.77) v1(38.26,44.23) v1(38.69,43.8) v2(98.61,42.88) v2(98.61,42.17) v2(99.32,42.88) v2(99.32,42.17) v2(162.01,49.64) v2(162.77,49.64) v2(163.66,49.64) v2(164.42,49.64) v2(216.37,49.77) v2(217.13,49.77) v2(217.13,49.01) v2(217.89,49.77) v2(217.89,49.01) v2(231.78,77.07) v2(232.55,78.57) v2(232.55,77.81) v2(232.55,77.07) v2(239.48,107.55) v2(240.12,107.96) v2(240.12,107.17) v2(240.75,108.29) v2(240.75,107.55)
+5VA: length 4.1
  TOP w0.203: 238.97,37.7 238.97,37.83 238.49,38.32 U34.26
  TOP w0.508: 238.97,37.7 238.97,36.95 239.35,36.57 239.6,36.57 240.24,35.92 C507.1
  vias: v1(240.75,34.81) v1(241.16,35.29) v1(243.67,42.91) v1(243.8,41.13) v1(243.8,40.5)
+5VMCU: length 11.4
  BOTTOM w0.102: L27.2 98.38,153.77 98.38,153.6
  BOTTOM w0.203: U40.45 100.19,153.26 99.66,153.78 99.02,153.78
  BOTTOM w0.381: L27.2 99.02,153.78
  BOTTOM w0.508: 98.38,153.6 97.61,152.83 R475.1 R481.1 96.9,152.33 v1(96.35,152.33) 95.72,151.7 95.72,150.22 96.61,149.34 R489.1
+5VPCU: length 117.7
  TOP w0.14: PC72.2 194.14,56.76 v1(194.14,57.64)
  TOP w0.208: PU5.14 197.82,63.11 197.96,62.96 197.96,62.48 v1(198.15,62.29) ; PU6.12 195.72,55.81 195.28,56.24 195.03,56.24 v1(194.9,56.37) 194.52,56.75 PC72.2
  TOP w0.254: PU4.7 192.62,74.91 192.01,75.52
  TOP w0.305: U25.5 224.52,70.24 225.13,70.85 225.63,70.85 R318.2
  TOP w0.381: v1(203.41,58.02) 203.64,58.25 PD6.2
  TOP w0.508: 192.01,75.52 191.27,76.26 PC41.2 v1(190.85,77.06) ; v1(222.65,69.08) 222.85,69.28 C378.1 222.85,70.22 223.99,71.37 225.37,71.37 R318.2
  IN1 w0.508: v1(212.94,53.58) 212.76,53.76 212.76,63.66 208.62,67.8 204.81,67.8 204.27,68.34 202.79,68.34 201.96,69.17 196.71,69.17 v1(196.23,68.69)
  IN2 w0.381: v1(206.59,52.31) 204.56,54.34 204.56,56.88 v1(203.41,58.02) 200.36,61.07 199.86,61.07 198.64,62.29 v1(198.15,62.29)
  IN2 w0.508: v1(194.9,56.37) 195.16,56.12 195.67,56.12 196.17,55.61 196.17,54.85 197.57,53.45 202.4,53.45 205.19,50.66 v2(206.59,50.66)
  IN3 w0.508: v1(190.85,77.06) 192.8,77.06 193.23,76.64 193.23,72.53 193.89,71.87 201.25,71.87 206.08,67.04 208.37,67.04 212.05,63.36 v2(212.05,52.82)
  BOTTOM w0.381: v1(196.23,68.69) 196.87,69.33 PR186.2
  BOTTOM w0.508: v1(222.65,69.08) 222.65,66.85
  vias: v2(211.29,53.2) v2(211.29,52.43) v2(211.29,51.67) v2(212.05,51.8) v2(222.08,65.26) v2(222.08,64.37) v2(222.84,65.26) v2(222.84,64.37)
+5VPVDD1: length 7.4
  TOP w0.203: U34.41 235.38,45.2
  TOP w0.508: v1(232.14,46.64) 232.5,47 R393.1 C482.1 233.99,47.51 234.79,46.71 C487.1 235.38,45.62 235.38,45.2
+5VPVDD2: length 6.7
  TOP w0.203: U34.46 233.38,43.78 232.72,44.43 232.32,44.43 232.11,44.64
  TOP w0.508: v1(229.14,46.72) 229.37,46.49 R395.1 C484.1 231.23,45.33 C489.1 231.43,45.32 232.11,44.64
+15V: length 364.2
  TOP w0.254: PR122.1 200.26,46.75 200.11,46.75 198.61,48.24 v1(197.7,48.24) 193.13,48.24 189.29,52.08 186.67,52.08 185.51,50.91 185.51,50.4 183.86,48.76 PR118.1 183.23,48.5 180.55,48.5 180.3,48.24 180.3,46.08 180.05,45.84 174.69,45.84 173.29,44.43 171.15,44.43 169.88,43.16 169.88,39.48 v1(170.52,38.85) ; PR24.1 v1(21.29,141.85) ; PR31.1 23.57,116.31 21.93,114.66 v1(20.79,114.66) ; PR107.1 v1(209.54,54.56)
  IN1 w0.254: v1(209.54,54.56) 206.4,51.42 205.06,51.42 201.89,48.24 v1(197.7,48.24)
  IN2 w0.254: 54.7,53.58 54.7,57.46 51.52,60.64 51.52,66.2 54.64,69.33 55.46,69.33 56.13,70 56.13,74.24 v1(57.31,75.42) ; 54.7,53.58 53.81,54.47 38.44,54.47 32.04,60.87 32.04,68.61 30.72,69.94 30.72,73.5 29.92,74.3 29.92,87.76 31.54,89.39 31.54,90.95 32.08,91.48 32.08,96.36 30.56,97.88 25.74,97.88 24.85,98.77 24.85,110.63 23.07,112.4 22.54,112.4 20.79,114.16 v1(20.79,114.66) 20.79,117.71 21.55,118.47 21.55,129.52 19.52,131.56 19.52,136.76 18.37,137.91 18.37,139.81 20.41,141.85 v1(21.29,141.85) ; 54.7,53.58 54.7,51.25 56.15,49.79 60.4,49.79 62.58,47.61 63.08,47.61 63.46,47.23 65.39,47.23 66.37,46.24 68.15,46.24 69.1,45.29 90.01,45.29 90.84,46.12 98.57,46.12 99.96,47.51 v1(104.26,47.51) ; v1(111.72,41.39) 112.1,41.77 128.74,41.77 129.85,40.65 133.16,40.65 134.04,39.76 145.27,39.76 146.34,40.83 149.82,40.83 152.74,37.91 169.58,37.91 v1(170.52,38.85)
  IN3 w0.254: v1(57.31,75.42) 57.31,76.77 58.02,77.48 59.8,77.48 60.08,77.76 60.86,77.76 61.17,78.07 62.6,78.07 63.6,79.07 66.77,79.07 67.52,79.82 67.52,81.75 68.67,82.89 v1(68.67,82.91)
  BOTTOM w0.254: v1(104.26,47.51) 104.26,47.77 105.11,48.62 107.15,48.62 107.65,48.12 107.65,45.4 108.6,44.45 108.6,43.61 108.72,43.49 109.18,43.04 110.07,43.04 v1(111.72,41.39) ; PR163.1 72.86,79.9 72.86,81.09 71.51,82.43 69.15,82.43 v1(68.67,82.91)
+15V_ALWP: length 4.8
  TOP w0.381: PR107.2 210.7,57.24 v1(210.14,57.79) 209.3,58.63 PC70.2 209.25,59.17 PD7.1
+A3VPCU: length 5
  TOP w0.203: 157.18,56.63 157.18,56.88 156.74,57.33 U32.74
  TOP w0.508: 157.18,56.63 157.18,56.5 v1(157.69,55.99) 157.69,55.74 158.33,55.1 C430.1 L20.2
+V1.05DX_MODPHY:
  vias: v1(137.91,122.77) v1(137.93,123.38) v1(138.57,123.4) v1(139.4,133.84)
+V1.05M_VCCASW: length 0.8
  TOP w0.381: v1(138.95,116.57) 138.9,116.61 C239.1
  vias: v1(140.6,115.66) v1(156.42,118.98) v1(157.44,117.1) v1(157.72,117.84) v1(158.07,117.08)
+V1.05S_AIDLE: length 6.8
  TOP w0.508: v1(140.5,122.3) 140.36,122.16 137.36,122.16 C194.1 137.12,121.14 R133.1
  BOTTOM w0.305: U45.P9 139.8,122.3 v1(140.5,122.3) 140.5,122.53 U45.N8
+V1.05S_APLLOPI: length 38.7
  TOP w0.508: C236.1 132.37,118.19 v1(132.76,118.19)
  IN1 w0.203: 139.68,117.18 139.68,116.67 140.24,116.11 140.79,116.11 140.79,116.11 142.12,116.11 142.15,116.14 142.76,116.14 143.01,115.88 144.28,115.88 144.61,116.21
  IN1 w0.229: 139.68,117.18 140.19,117.18 140.29,117.08 144.03,117.08 144.61,116.5 144.61,116.21
  IN1 w0.508: 144.61,116.21 145.6,116.21 146.52,115.3 146.88,115.3 147.39,114.79 148.17,114.79 148.36,114.6 150.24,114.6 150.38,114.46 150.83,114.46 151.49,115.12 152.3,115.12 152.81,114.61 153.06,114.61 154.53,113.14 154.9,113.14 v1(156.14,111.9) ; v1(132.76,118.19) 132.89,118.31 134.8,118.31 135.27,117.85 135.3,117.85 135.3,117.84 136.23,117.84 136.89,117.18 139.68,117.18
  BOTTOM w0.254: U45.W21 132.99,119.4 132.65,119.06 132.65,118.3 v1(132.76,118.19) 133.14,118.56 U45.AA21
  BOTTOM w0.508: C661.2 155.79,113.86 156.1,113.55 156.1,113.46 v1(156.14,113.42) v1(156.14,111.9)
+V1.05S_ASATA3PLL: length 17
  TOP w0.508: v1(140.45,135.11) 140.45,135.39 v1(140.99,135.94) 141.44,136.38 141.82,136.38 142.71,137.28 C104.2 C100.2 L11.2
  BOTTOM w0.203: 138.93,130.42 138.83,130.32 138.83,129.9 138.4,129.48 138.17,129.48 U45.B11
  BOTTOM w0.254: 138.93,130.42 139.4,130.9 139.4,131.68 139.79,132.06 139.79,132.82 140.42,133.46 140.42,133.98 C636.1
  BOTTOM w0.508: C636.1 R513.1 ; R513.1 139.91,134.87 140.15,135.11 v1(140.45,135.11) ; R513.1 R512.2
+V1.05S_AUSB3PLL: length 30.4
  TOP w0.508: L12.2 136.74,139.93 136.74,139.94 C99.2 135.72,139.84 135.72,138.41 135.34,138.03 134.38,138.03 C103.2 133.95,136.78 132.93,135.75 132.93,133.97 134.07,132.83 134.07,131.94 ; 134.07,131.94 v1(134.07,131.17) ; 134.07,131.94 128.79,131.94 v1(128.15,131.3)
  BOTTOM w0.254: v1(128.15,131.3) 128.15,131.55 126.32,133.38 126.32,134.22 126.59,134.49 R509.1 R510.2 ; U45.B18 133.95,129.79 133.77,129.97 133.77,130.75 134.07,131.05 v1(134.07,131.17) 134.07,131.65 135.65,133.23 135.92,133.23 136.4,133.71 C635.1
+V1.05S_AXCK_DCB: length 30.7
  TOP w0.508: v1(134.06,125.15) 133.25,125.15 133.14,125.26 132.89,125.26 C165.1
  IN2 w0.508: v1(134.06,125.15) 133.1,125.15 132.6,125.65 132.6,126.37 131.45,127.52 131.45,128.89 132.6,130.03 132.6,131.48 134.96,133.84 136.74,133.84 137.46,134.56 v1(137.46,135.11)
  IN3 w0.508: v1(145.51,138.16) 145.51,138.33 145.04,138.79 142.71,138.79 142.25,139.25 141.64,139.25 140.36,137.97 v1(140.04,137.97)
  BOTTOM w0.254: U45.K19 134.08,124.43 134.08,125.11 134.11,125.15 ; 134.11,125.15 v1(134.06,125.15) ; 134.11,125.15 134.33,125.15 134.6,124.88 U45.J18
  BOTTOM w0.508: L30.2 v1(145.51,138.16) ; v1(140.04,137.97) 140.29,137.72 C619.2 C618.2 138.65,136.62 137.46,135.43 v1(137.46,135.11)
+V1.05S_AXCK_LCPLL: length 39.6
  TOP w0.508: v1(143.72,135.75) 144.74,136.76 144.97,136.76 146.39,138.18 146.39,139.76 146.16,139.99 144.94,139.99 144.5,140.43 C96.2 144.5,143.09 C87.2 143.22,143.11 L10.2
  IN2 w0.508: v1(143.72,135.75) 143.72,136.25 143.34,136.64 136.1,136.64 135.47,136 135.47,135.49 135.9,135.06 v1(136.13,135.06)
  IN3 w0.508: v1(136.13,135.06) 135.42,134.35 133.31,134.35 132.29,133.33 128.23,133.33 126.93,134.63 v1(126.93,135.21)
  BOTTOM w0.508: v1(133.42,131.1) 133.42,131.67 135.46,133.71 C634.1 135.73,133.71 136.15,134.13 136.15,135.04 v1(136.13,135.06) ; v1(126.93,135.21) 126.96,135.24 R500.1
+V1.05S_CORE_PCH: length 14.7
  TOP w0.381: C231.1 139.03,118.31 139.51,117.83 139.51,117.13 140.06,116.57 140.39,116.57 v1(140.41,116.59)
  TOP w0.508: C254.1 130.01,115.05 130.01,115.28 130.41,115.69 v1(130.41,115.74)
  IN1 w0.508: v1(131.28,121.5) 130.51,120.74 130.51,118.21 130.18,117.88 130.18,117.16 130.54,116.8 130.54,115.89 130.55,115.88 v1(130.41,115.74)
  BOTTOM w0.229: v1(130.41,115.74) 130.6,115.55 131.35,115.55 131.54,115.74 U45.AF22
  BOTTOM w0.254: v1(135.93,125.83) 136.18,125.83 U45.H15 ; v1(140.41,116.59) 140.24,116.42 U45.AE8
  BOTTOM w0.305: v1(137.9,125.09) 138,125.09 U45.H11
  BOTTOM w0.381: v1(137.9,125.09) 138.14,124.85 U45.J11
  vias: v1(134.15,122.44)
+V1.5S_VCCATS: length 11
  TOP w0.381: R84.2 135.37,136.64 135.47,136.53 135.47,134.6 v1(135.09,134.22) 134.71,133.84 134.71,131.12 136.23,129.6 136.23,127.82
  BOTTOM w0.254: U45.J15 136.16,125.21 v1(135.98,125.21)
+V1.05S_VCCUSBCORE: length 23.4
  TOP w0.508: C253.1 134.08,115.05 134.54,115.05 134.65,114.94 134.68,114.94 v1(134.7,114.92) 134.7,114.01 135.34,113.37 v1(135.34,107.68) 135.34,105.01 134.96,104.63 134.96,98.53 135.33,98.15 135.85,98.15 136.22,98.52 136.22,100.19 136.86,100.83 R232.2
  BOTTOM w0.381: U45.AG16 U45.AG17 134.77,114.94 134.73,114.94 v1(134.7,114.92)
+V3.3DX_1.5DX_1.8DX_AUDIO: length 12.4
  TOP w0.508: C251.2 135.42,115.04 136.14,114.31 v1(136.14,114.14) 136.9,113.38 136.9,110.69 137.25,110.35 137.25,108.06 136.99,107.81 v1(136.99,106.87) 136.99,104.38 R210.1
  BOTTOM w0.254: v1(136.14,114.14) 136.16,114.14 136.17,114.15 136.21,114.15 136.49,114.43 136.53,114.43 136.7,114.6 U45.AH14
+V3.3M_PSPI: length 21.6
  TOP w0.381: 151.47,116.34 152.46,116.34 153.15,115.66 R168.2 153.15,114.89 v1(153.5,114.54)
  TOP w0.508: 151.47,116.34 151.34,116.47 R154.2 150.83,116.67 149.97,117.54 149.28,117.54 149.07,117.32 C233.2 147.74,117.32 v1(147.66,117.41)
  IN1 w0.203: 139.91,118.98 140.38,119.45 v1(140.54,119.45) 141.02,118.97 142.67,118.97 142.91,118.73 142.91,118.4 142.55,118.04 140.19,118.04 139.91,118.32 139.91,118.98
  IN1 w0.381: 142.91,118.73 144.22,118.73 144.61,118.34 144.61,117.97 144.99,117.59 146.85,117.59 147.02,117.41 v1(147.66,117.41)
  BOTTOM w0.254: U45.Y8 140.24,119.15 v1(140.54,119.45)
+V3.3S_VCCPCORE: length 25.9
  TOP w0.508: R117.1 C176.2 158.2,123.29 157.31,124.18 156.01,124.18 v1(155.23,123.4)
  IN2 w0.229: v1(140.41,120.4) 140.48,120.4 140.96,120.88 142.6,120.88 142.78,121.07 142.78,121.17 143.09,121.48 144.28,121.48 144.61,121.14
  IN2 w0.508: v1(155.23,123.4) 155.2,123.37 155.2,123.15 154.39,122.33 154.39,121.9 153.88,121.4 150.71,121.4 149.95,122.16 149.18,122.16 148.66,121.63 146.93,121.63 145.98,120.68 145.07,120.68 144.61,121.14
  BOTTOM w0.254: v1(140.41,120.4) 140.24,120.23 U45.V8 140.24,119.88 139.81,119.45 U45.W9
+V3.3S_VCCPTS: length 25.5
  TOP w0.381: v1(136.46,121.82) 136.25,121.82 135.93,122.14 C205.1 ; R79.2 144.2,139.2 v1(144.2,138.11) 144.2,137.75 v1(143.85,137.4)
  IN2 w0.381: v1(136.46,121.82) 137.35,122.71 137.35,123.63 137.71,123.99 138.77,123.99 139.4,124.62 ; v1(144.2,138.11) 144.2,137.55 147.66,134.1 147.66,130.67 146.52,129.52 145.12,129.52 143.6,128
  BOTTOM w0.305: U45.K16 136.08,124.43 136.93,124.43 U45.K14 136.98,123.68 136.86,123.56 136.86,123.3
  BOTTOM w0.381: v1(136.46,121.82) 136.86,122.23 136.86,123.3
+V3.3S_VCCSDIO: length 17.6
  TOP w0.508: R113.2 154.03,124.6 154.03,124.45 154.06,124.42 v1(154.06,124.22) ; C212.1 140.3,121.52 v1(140.49,121.33)
  IN2 w0.229: 143.85,121.83 140.73,121.83 140.49,121.59 v1(140.49,121.33)
  IN2 w0.254: 147.53,122.54 147.17,122.54 146.47,121.83 143.85,121.83
  IN2 w0.508: 150.96,122.54 151.93,122.54 152.52,123.14 152.52,124.35 152.99,124.82 153.73,124.82 154.06,124.49 v1(154.06,124.22) ; 148.55,122.92 148.17,122.54 147.53,122.54
  BOTTOM w0.254: U45.U8 140.24,121.08 v1(140.49,121.33) 139.82,121.33 U45.T9
+VCCIN: length 38.7
  TOP w0.508: 111.59,127.62 111.59,129.52 110.7,130.41 103.72,130.41 v1(103.34,130.79)
  IN2 w0.254: v1(150.33,154.64) 150.33,154.8 149.97,155.15 144.76,155.15 143.98,154.37 141.94,154.37 141.21,153.63 140.37,153.63 139.63,154.37 128.84,154.37 v1(128.58,154.62)
  BOTTOM w0.254: v1(150.33,154.64) 150.57,154.64 151.43,155.51 PR127.2 ; U45.F59 108.8,126.66 v1(108.47,126.99) ; U45.K57 v1(110.32,124.6) ; U45.M57 v1(110.45,123.3)
  BOTTOM w0.508: v1(103.34,130.79) 103.34,131.3 102.83,131.81 R522.1
  vias: v1(110.38,125.96) v1(110.58,122.28) v1(110.63,121.04) v1(110.63,120.02) v1(110.78,125.46) v1(110.75,118.75) v1(110.78,116.27) v1(110.88,127.55) v1(111.43,126.01) v1(112.56,126.01) v1(113.38,127.55) v1(113.94,126.01) v1(114.26,121.52) v1(114.26,120.76) v1(115.02,121.52) v1(115.07,126.01) v1(115.89,127.55) v1(116.45,126.01) v1(116.62,121.37) v1(117.57,126.01) v1(118.4,127.55) v1(118.7,121.45) v1(118.95,126.01) v1(120.08,126.01) v1(120.76,126.25) v1(120.74,121.45) v1(120.91,127.55) v1(121.46,126.01) v1(122.59,126.01) v1(122.77,121.45) v1(123.41,127.55) v1(123.97,126.01) v1(124.77,121.47) v1(125.1,126.01) v1(125.82,126.35) v1(125.82,125.71) v1(125.92,127.55) v1(126.48,126.01) v1(126.88,121.4) v1(127.01,125.71) v1(127.58,125.99) v1(128.23,127.52) v1(128.23,126.35) v1(128.15,125.74) v1(130.77,127.52) v1(131,126.35) v2(126.53,145.48) v2(126.58,146.8) v2(126.55,144.54) v2(126.96,148.57) v2(126.96,147.43) v2(126.96,146.16) v2(127.21,145.02) v2(127.54,149.11) v2(127.54,148.02) v2(127.54,146.97) v2(127.57,145.78) v2(127.59,144.38) v2(128.36,149.08) v2(128.36,148.12) v2(128.48,143.62) v2(129.12,148.12) v2(129.24,149.08) v2(129.24,143.62) v2(129.88,148.12) v2(130.01,148.83) v2(130.01,143.62) v2(130.77,143.62) v2(130.92,149.08) v2(130.92,148.32) v2(130.92,147.56) v2(131.4,144.38) v2(131.53,143.62) v2(133.03,143.24) v2(133.21,144.51) v2(133.66,143.95) v2(133.77,143.24) v2(134.43,143.65) v2(134.91,143.11) v2(135.47,143.62) v3(123.91,140.7)
+VCCIO_OUT: length 39.8
  IN2 w0.508: v1(103.29,138.22) 103.02,138.22 101.56,136.76 101.56,134.22 100.92,133.59 100.92,132.65 97.98,129.7 97.98,124.98 v1(98.64,124.32) 98.36,124.32 97.9,123.86 97.9,122.51 v1(98.41,122.01)
  BOTTOM w0.254: U45.A59 108.92,130.31 108.41,130.82 108.23,130.82 107.83,131.22 105.71,131.22 105.32,131.61 105.32,133.16 105.98,133.82 105.98,135.29 106.89,136.2 C621.2
  BOTTOM w0.381: R568.1 99.45,121.59 99.45,121.82 99.72,122.09 100.58,122.09 101.67,123.17 R555.1
  BOTTOM w0.508: R568.1 98.89,121.52 v1(98.41,122.01) ; v1(98.64,124.32) 99.02,124.7 R546.2
  BOTTOM w0.635: C621.2 105.93,137.22 R495.2 103.34,138.28 v1(103.29,138.22)
+VCCIOA_OUT: length 2.1
  TOP w0.14: v1(133.24,127.16) 132.79,127.62 v1(132.67,127.62)
  TOP w0.254: R107.2 133.22,127.16 v1(133.24,127.16)
  BOTTOM w0.254: U45.E20 133.53,127.46 v1(133.24,127.16)
+VCCPDSW: length 25.2
  TOP w0.381: v1(139.75,114.47) 139.48,114.47 C255.1
  TOP w0.508: v1(138.62,105.57) 138.13,105.09 R211.1 R212.1 ; v1(134.96,116.7) 134.96,116.57 134.48,116.09 133.52,116.09 C240.2
  IN1 w0.254: 139.84,115.73 140.29,115.27 140.29,114.79 139.97,114.47 v1(139.75,114.47) 139.58,114.47 138.57,115.48 138.57,115.73 139.84,115.73
  IN1 w0.508: v1(134.96,116.7) 134.96,116.19 135.42,115.73 138.57,115.73
  IN2 w0.508: v1(139.75,114.47) 139.67,114.47 139.3,114.1 139.3,113.17 138.9,112.76 138.9,110.35 137.88,109.33 137.88,106.28 138.59,105.57 v1(138.62,105.57)
  BOTTOM w0.254: U45.AH10 139.18,114.6 139.3,114.48 139.74,114.48 v1(139.75,114.47)
+VCCRTCEXT: length 4.6
  TOP w0.254: C225.2 139.03,119.36 139.66,118.73 139.66,118.27 139.96,117.97 139.96,117.33 140.22,117.08 140.78,117.08 141.06,116.79 v1(141.06,116.59)
  BOTTOM w0.254: U45.AE7 140.89,116.42 v1(141.06,116.59)
AGND_CPU: length 42
  TOP w0.191: PU1.41 147.83,151.47 PU1.29
  TOP w0.254: PC6.2 143.17,151.31 v1(143.17,150.95) 143.17,150.55 PR7.2
  TOP w0.381: PC7.2 PC9.2 153.27,147.53 152.54,146.8 v1(151.88,146.8) ; v1(146.21,144.79) 146.21,145.06 PR16.2 PR15.2
  TOP w0.508: PC11.2 PC10.2 ; PC10.2 148.99,145.39 v1(148.95,145.42) ; PC10.2 149.56,145.02 149.19,144.65 PR20.2 ; PC3.2 PC2.2 146.57,154.92 v1(146.26,154.62)
  IN1 w0.508: PU1.38 149.13,149.17 149.13,145.6 v1(148.95,145.42)
  IN2 w0.508: PU1.35 146.68,149.92 144.58,149.92 143.55,150.95 v1(143.17,150.95) ; v1(146.26,154.62) 146.82,154.06 146.82,151.47 PU1.34
  IN3 w0.508: v1(148.95,145.42) 146.64,145.42 146.21,144.99 v1(146.21,144.79)
  BOTTOM w0.254: PC91.2 143.17,151.28 v1(143.17,150.95)
  BOTTOM w0.381: PR143.2 147.12,145.41 PR145.2 148.94,145.41 v1(148.95,145.42) 148.97,145.41 PR146.1 150.64,145.41 PR149.2 ; PR138.2 150.12,148.09 150.17,148.04 150.35,148.04 151.6,146.8 v1(151.88,146.8) ; PU1.36 146.95,149.27 146.47,148.78 PR137.1 146.09,148.78 145.64,148.34 145.64,147.8 145.12,147.28 143.62,147.28 143.11,147.78 PR141.1
  BOTTOM w0.508: PU1.38 149.03,148.78 149.7,148.11 PR138.2
  vias: v3(147.02,152.26)
