# Allegro board DA0Z8CMB8D0-D-gina-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ35: length 59.7
  TOP w0.102: v1(118.57,66.13) U31.F7
  IN3 w0.102: v1(118.57,66.13) 118.57,66.82 117.99,67.4 117.33,67.4 116.77,67.95 114.3,67.95 114.05,68.2 112.97,68.2 112.86,68.31
  IN3 w0.14: 112.86,68.31 112.57,68.6 112.57,70.45 111.49,71.54 111.49,74.36 108.73,77.11 108.73,79.03 108.86,79.16 109.53,79.16 109.66,79.28 109.66,80.55 109.53,80.68 108.78,80.68 108.65,80.81 108.65,96.48 108.96,96.79 108.96,97.04 108.84,97.16 108.19,97.16 108.06,97.29 108.06,99.07 107.93,99.2 107.73,99.2 107.6,99.07 107.6,98.13 107.48,98 107.27,98 107.15,98.13 107.15,99.07 107.02,99.2 106.28,99.2 105.3,100.17 105.3,102.05 107.84,104.59 v1(108.51,104.59)
  BOTTOM w0.076: v1(108.51,104.59) 109.3,104.59 110.51,105.8 110.51,105.93 110.88,106.3 110.88,107.18 111.03,107.32 111.03,107.57 110.74,107.86 U45.AW56
  BOTTOM w0.102: v1(118.57,66.13) 118.97,66.52 U53.E3
M_A_DQ36: length 59.4
  TOP w0.102: v1(115.37,64.53) U31.H3
  IN3 w0.102: 112.25,65.49 113.83,65.49 114.42,64.9 114.99,64.9 v1(115.37,64.53)
  IN3 w0.14: v1(108.05,106.75) 106.52,106.75 106.12,106.35 104.79,106.35 102.17,103.73 102.17,103.26 102.45,102.98 102.45,102.47 102.07,102.09 102.07,101.58 102.5,101.15 102.5,100.11 102.29,99.91 102.29,99.04 103.61,97.73 103.61,85.63 103.74,85.51 104.71,85.51 104.83,85.38 104.83,85.18 104.71,85.05 103.74,85.05 103.61,84.92 103.61,80.22 104.76,79.07 104.76,75.68 105.9,74.53 105.9,73.12 109.55,69.48 109.55,68.19 112.25,65.49
  BOTTOM w0.076: U45.AV58 109.39,108.56 108.41,107.58 108.41,107.29 108.05,106.94 v1(108.05,106.75)
  BOTTOM w0.102: U31.H3 v1(115.37,64.53)
M_A_DQ37: length 61.5
  TOP w0.102: v1(118.07,65.19) 118.89,64.36 118.89,64.2 U31.H7
  IN3 w0.102: v1(118.07,65.19) 117.94,65.31 117.94,66.84 117.79,66.99 117.16,66.99 116.6,67.55 114.13,67.55 113.88,67.8 112.61,67.8
  IN3 w0.14: 112.61,67.8 111.86,68.55 111.86,70.12 109.71,72.27 109.71,73.19 109.58,73.31 109.1,73.31 108.97,73.44 108.97,73.64 109.1,73.77 109.58,73.77 109.71,73.9 109.71,75.12 108.02,76.81 108.02,77.36 107.46,77.91 107.46,79.33 107.94,79.81 107.94,96.31 104.59,99.65 104.59,103.22 v1(104.76,103.39)
  BOTTOM w0.076: 107.15,104.12 107.18,104.15 107.5,104.15 109.75,106.41 110.16,106.41 110.39,106.64 110.39,107.15 110.28,107.26 110.28,107.55 110.3,107.6 110.31,107.6 110.35,107.71 110.35,107.84 110.28,107.99 110.28,108.2 110.3,108.25 110.35,108.34 110.35,108.35 110.35,108.54 110.34,108.56 110.34,108.94 110.35,108.95 110.35,109.19 110.15,109.4 U45.AU58
  BOTTOM w0.102: v1(118.07,65.19) 118.89,64.36 118.89,64.2 U31.H7
  BOTTOM w0.216: 107.15,104.12 106.41,103.39 v1(104.76,103.39)
M_A_DQ38: length 60.9
  TOP w0.102: v1(114.56,64.49) 114.97,64.91 U31.G2
  IN3 w0.14: v1(109.76,105.84) 109.76,106.4 108.86,107.31 106.58,107.31 105.98,106.71 104.65,106.71 101.81,103.87 101.81,103.87 101.61,103.67 101.61,99.19 103.26,97.55 103.26,80.04 104.33,78.97 104.33,73.97 106.31,71.99 106.53,71.99 109.19,69.33 109.19,68.04 112.74,64.49 v1(114.56,64.49)
  BOTTOM w0.076: U45.AV56 110.63,108.4 110.5,108.27 110.47,108.21 110.45,108.16 110.45,108.03 110.45,108.01 110.49,107.93 110.52,107.87 110.52,107.64 110.49,107.62 110.45,107.51 110.45,107.32 110.55,107.22 110.55,106.57 109.82,105.84 v1(109.76,105.84)
  BOTTOM w0.102: v1(114.56,64.49) 114.92,64.13 U53.H8
M_A_DQ39: length 61.6
  TOP w0.102: v1(119.39,66.11) U31.F8
  IN3 w0.102: v1(119.39,66.11) 119.39,66.3 118.09,67.6 117.42,67.6 116.86,68.16 114.39,68.16 113.88,68.67 113.88,69.72 113.52,70.08 113.52,70.44 113.24,70.72
  IN3 w0.14: v1(108.05,104.1) 108.05,102.74 106.38,101.08 106.38,99.68 106.51,99.55 108.29,99.55 108.42,99.42 108.42,97.65 108.54,97.52 108.75,97.52 108.87,97.65 108.87,99.42 109,99.55 109.19,99.55 109.32,99.42 109.32,96.64 109.01,96.33 109.01,81.16 109.13,81.04 109.89,81.04 110.02,80.91 110.02,76.72 111.85,74.89 111.85,73.85 111.97,73.72 112.32,73.72 112.45,73.59 112.45,73.39 112.32,73.26 111.97,73.26 111.85,73.14 111.85,72.93 111.97,72.81 112.32,72.81 112.45,72.68 112.45,71.52 113.24,70.72
  BOTTOM w0.076: v1(108.05,104.1) 109.05,104.1 110.68,105.73 110.68,105.87 111.05,106.23 111.05,107.11 111.19,107.26 111.19,108.05 110.92,108.33 110.92,108.62 110.92,108.63 110.92,108.87 110.63,109.16 U45.AU56
  BOTTOM w0.102: v1(119.39,66.11) U31.F8
M_A_DQ40: length 67.2
  TOP w0.102: v1(82.57,66.15) 82.96,65.75 U29.F2
  IN1 w0.102: v1(82.57,66.15) 82.16,66.56 81.11,66.56
  IN1 w0.178: v1(105.75,101.83) 105.75,101.76 105.63,101.63 104.85,101.63 104.73,101.51 104.73,101.34 104.91,101.15 104.91,101 104.78,100.87 104.01,100.87 92.34,89.2 91.89,89.2 85.8,83.11 85.8,81.26 84.81,80.27 84.31,80.27 82.37,78.33 82.37,78.15 82.51,78.01 82.69,78.01 84.37,79.68 84.55,79.68 84.7,79.53 84.7,79.35 82.3,76.95 82.3,75.16 78.32,71.17 78.32,68.69 80.45,66.56 81.11,66.56
  BOTTOM w0.076: v1(105.75,101.83) 107.48,101.83 111.54,105.89 111.54,106.9 111.69,107.05 111.69,107.32 U45.AY54
  BOTTOM w0.102: U29.F2 82.96,65.75 v1(82.57,66.15)
M_A_DQ41: length 68.3
  TOP w0.102: U29.E3 v1(84.16,66.13)
  IN1 w0.102: v1(84.16,66.13) 83.77,65.74 82.38,65.74 82.33,65.69 81.64,65.69
  IN1 w0.178: 81.64,65.69 80.7,65.69 80.58,65.82 80.3,65.82 80.16,65.68 79.98,65.68 79.86,65.8 79.86,65.97 80.07,66.18 80.07,66.33 79.91,66.49 79.73,66.49 79.45,66.21 79.27,66.21 79.15,66.34 79.15,66.52 79.42,66.79 79.42,66.97 79.3,67.1 79.12,67.1 78.85,66.83 78.67,66.83 78.55,66.96 78.55,67.14 78.81,67.41 78.81,67.58 78.69,67.71 78.51,67.71 78.23,67.43 78.05,67.43 77.92,67.56 77.92,67.74 78.2,68.02 78.2,68.2 77.92,68.48 77.92,71.33 81.91,75.32 81.91,78.43 84.15,80.67 84.65,80.67 85.4,81.42 85.4,83.28 91.72,89.6 92.18,89.6 104.62,102.04 105.32,102.04 106.04,102.75 v1(106.67,102.75)
  BOTTOM w0.076: U45.AW54 111.82,107.86 111.53,107.57 111.53,107.12 111.38,106.97 111.38,105.96 108.16,102.75 v1(106.67,102.75)
  BOTTOM w0.102: U51.F7 83.76,65.74 v1(84.16,66.13)
M_A_DQ42: length 67.9
  TOP w0.102: v1(86.57,66.13) U29.F7
  IN1 w0.102: 81.53,70.98 81.4,70.85 81.26,70.85 80.96,70.55 80.96,69.52 81.96,68.53 81.96,68.31 82.31,67.95 85.06,67.95 86.57,66.45 v1(86.57,66.13)
  IN1 w0.178: 81.53,70.98 84.59,74.04 84.59,74.57 88.11,78.09 88.11,78.27 87.96,78.43 87.78,78.43 87.09,77.75 86.91,77.75 86.73,77.94 86.73,78.12 88.32,79.71 88.43,79.71 88.55,79.84 88.55,80.07 88.43,80.2 88.25,80.2 88.12,80.32 88.12,80.58 88.25,80.71 88.44,80.71 88.57,80.83 88.57,81.09 88.44,81.21 88.25,81.21 88.12,81.34 88.12,81.64 88.25,81.77 88.44,81.77 88.57,81.9 88.57,82.65 92.83,86.92 93.29,86.92 104.92,98.54 105.85,98.54 106.5,99.19 107.28,99.19 108.25,100.16 108.25,100.53 108.33,100.61 108.66,100.61 108.78,100.73 108.78,100.89 108.7,100.97 108.7,101.15 108.82,101.28 109,101.28 109.1,101.18 109.28,101.18 109.67,101.57 109.67,101.75 109.52,101.9 109.34,101.9 109.14,101.7 108.89,101.7 v1(108.72,101.86)
  BOTTOM w0.076: v1(108.72,101.86) 109.84,101.86 113.22,105.24 113.22,106.03 113.29,106.11 113.29,107.32 U45.AY52
  BOTTOM w0.102: v1(86.57,66.13) 86.96,66.52 U51.E3
M_A_DQ43: length 68.8
  TOP w0.102: v1(87.35,64.54) U29.H8
  IN1 w0.102: 80.35,69.22 80.35,68.91 81.26,68 81.98,68 82.23,67.75 84.98,67.75 86.14,66.59 86.14,65.75 v1(87.35,64.54)
  IN1 w0.178: 80.35,69.22 80.35,70.35 84.2,74.2 84.2,74.73 86.69,77.23 86.69,77.41 86.52,77.58 86.34,77.58 85.49,76.73 85.31,76.73 85.14,76.91 85.14,77.09 87.72,79.66 87.72,82.35 92.67,87.31 93.13,87.31 104.75,98.94 105.69,98.94 106.33,99.58 107.12,99.58 107.8,100.27 v1(107.8,100.94)
  BOTTOM w0.076: v1(107.8,100.94) 109.35,100.94 113.46,105.05 113.46,107.51 113.41,107.61 113.41,107.62 113.39,107.67 113.39,107.88 U45.AW52
  BOTTOM w0.102: U51.G2 87.74,64.93 v1(87.35,64.54)
M_A_DQ44: length 68.6
  TOP w0.102: U29.H3 83.4,64.5 83.4,64.5 v1(83.37,64.53)
  IN1 w0.102: v1(83.37,64.53) 82.99,64.91 82.23,64.91 81.8,65.34 81.37,65.34 81.24,65.21 80.93,65.21
  IN1 w0.178: 80.93,65.21 79.69,65.21 77.53,67.37 77.53,71.5 81.52,75.48 81.52,78.59 83.98,81.06 84.49,81.06 85.01,81.58 85.01,83.44 91.56,89.99 92.02,89.99 104.51,102.48 105.09,102.48 107.03,104.42 107.21,104.42 107.35,104.28 107.35,104.1 106.79,103.54 106.79,103.31 106.89,103.21 v1(107.13,103.21)
  BOTTOM w0.076: U45.AV54 111.64,108.46 111.64,108.33 111.36,108.05 111.36,107.19 111.21,107.04 111.21,106.03 108.39,103.21 v1(107.13,103.21)
  BOTTOM w0.102: U29.H3 83.4,64.5 83.4,64.5 v1(83.37,64.53)
M_A_DQ45: length 70
  TOP w0.102: v1(82.56,64.5) 82.96,64.91 U29.G2
  IN1 w0.178: v1(82.56,64.5) 82.53,64.47 79.87,64.47 77.14,67.21 77.14,71.66 81.12,75.65 81.12,78.76 84.62,82.25 84.62,83.6 91.4,90.38 91.85,90.38 101.57,100.1 101.57,100.81 101.86,101.09 102.56,101.09 104.38,102.91 104.94,102.91 106.85,104.81 107.71,104.81 108.49,105.6 109.31,105.6 109.53,105.37 v1(111.51,104.65)
  BOTTOM w0.076: v1(111.51,104.65) 112.69,105.83 112.69,106.24 112.84,106.38 112.84,107.09 112.71,107.22 112.71,107.55 112.74,107.6 112.74,107.6 112.78,107.71 112.78,107.84 112.71,107.99 112.71,108.2 112.74,108.25 112.78,108.34 112.78,108.35 112.78,109.19 112.58,109.4 U45.AU54
  BOTTOM w0.102: v1(82.56,64.5) 82.93,64.13 U51.H8
M_A_DQ46: length 69.6
  TOP w0.102: v1(87.38,66.11) U29.F8
  IN1 w0.102: v1(87.38,66.11) 87.2,66.11 85.15,68.16 82.4,68.16 82.16,68.4 82.16,68.68 81.87,68.97 81.87,70.76 82,70.89
  IN1 w0.178: 82,70.89 84.98,73.87 84.98,74.41 88.53,77.95 88.53,79.21 88.96,79.64 88.96,82.48 93,86.52 93.45,86.52 105.08,98.15 106.02,98.15 106.62,98.75 107.4,98.75 112.44,103.79 112.44,103.96 112.24,104.16 112.06,104.16 110.22,102.32 v1(109.18,102.32)
  BOTTOM w0.076: v1(109.18,102.32) 109.87,102.32 112.96,105.42 112.96,106.18 113.13,106.35 113.13,107.03 112.88,107.28 112.88,107.51 112.95,107.67 112.95,107.87 112.93,107.93 112.88,108.02 112.88,108.03 112.88,108.16 112.9,108.21 112.93,108.27 113.06,108.4 U45.AV52
  BOTTOM w0.102: U29.F8 v1(87.38,66.11)
M_A_DQ47: length 70.6
  TOP w0.102: v1(86.45,64.78) 86.96,64.26 U29.H7
  IN1 w0.102: v1(86.45,64.78) 86.45,65.13 85.94,65.64 85.94,66.51 84.9,67.55 82.14,67.55 81.89,67.8 81.17,67.8 79.84,69.13 79.84,69.3
  IN1 w0.178: 79.84,69.3 79.84,70.47 83.8,74.43 83.8,74.92 85.09,76.21 85.09,76.37 84.92,76.54 84.74,76.54 84.19,75.98 84.01,75.98 83.83,76.16 83.83,76.34 86.22,78.72 86.22,79.54 86.52,79.84 86.93,79.84 87.05,79.71 87.21,79.71 87.31,79.81 87.31,82.5 92.51,87.7 92.96,87.7 104.59,99.33 105.53,99.33 106.68,100.48 v1(107.34,100.48)
  BOTTOM w0.076: U45.AU52 113.55,109.01 113.55,107.71 113.6,107.6 113.63,107.55 113.63,104.79 109.32,100.48 v1(107.34,100.48)
  BOTTOM w0.102: v1(86.45,64.78) 86.96,64.26 U29.H7
M_A_DQ48: length 67.6
  TOP w0.102: v1(87.38,70.15) U29.A7
  IN1 w0.076: v1(120.3,113.48) 120.3,113.05 121.29,112.06 121.29,110.11 121.4,110.01
  IN1 w0.178: 121.4,110.01 122.23,109.17 122.23,102.92 121.07,101.75 121.07,101.36 119.76,100.06 118.69,100.06 118.32,99.69 115.82,99.69 114.61,98.48 113.42,98.48 108.64,93.7 106.92,93.7 96.59,83.36 96.59,81.45 95.97,80.83 95.97,78.22 92.57,74.81 92.57,74.15 92.67,74.05 93.71,74.05 93.84,73.92 93.84,73.58 93.71,73.45 91.33,73.45 88.55,70.67 87.87,70.67 87.38,70.19 v1(87.38,70.15)
  BOTTOM w0.102: U45.AK40 120.63,113.81 v1(120.3,113.48) ; U29.A7 v1(87.38,70.15)
M_A_DQ49: length 67.8
  TOP w0.102: v1(88.17,68.54) U29.C8
  IN1 w0.076: 121.37,109.61 121.07,109.92 121.07,112.04 119.57,113.53 v1(119.41,113.53)
  IN1 w0.102: 88.02,71.1 87.74,71.1 86.98,70.34 86.98,69.98 87.22,69.74 87.54,69.74 87.77,69.51 87.77,68.94 v1(88.17,68.54)
  IN1 w0.178: 88.02,71.1 88.3,71.1 93.05,75.85 93.05,79.94 94.12,81.01 95.56,81.01 96.19,81.64 96.19,83.53 106.76,94.1 108.48,94.1 113.48,99.09 113.62,99.09 114.61,100.09 118.16,100.09 118.53,100.45 119.6,100.45 120.56,101.41 120.56,101.8 121.74,102.98 121.74,109.24 121.37,109.61
  BOTTOM w0.102: v1(88.17,68.54) U29.C8 ; v1(119.41,113.53) 119.69,113.81 U45.AK42
M_A_DQ50: length 64.6
  TOP w0.102: U29.A3 v1(83.37,69.34)
  IN1 w0.076: v1(118.44,112.31) 118.44,111.49 118.04,111.1 118.04,109.79 117.66,109.4 117.66,109.08
  IN1 w0.178: v1(83.37,69.34) 83.37,69.45 83.75,69.83 84.44,69.83 84.69,70.09 85.02,70.09 85.12,70.19 85.12,70.49 85.02,70.6 84.67,70.6 84.57,70.7 84.57,70.88 86.75,73.06 86.75,73.19 89.39,75.83 89.39,75.99 89.33,76.06 89.33,76.23 89.49,76.39 89.63,76.39 89.7,76.32 89.86,76.32 89.98,76.44 89.98,76.6 89.92,76.66 89.92,76.84 90.06,76.98 90.24,76.98 90.31,76.92 90.46,76.92 90.76,77.23 90.76,81.78 90.94,81.96 90.94,81.97 93.73,84.76 94.19,84.76 105.81,96.38 107.53,96.38 113.53,102.38 113.98,102.38 114.11,102.51 114.11,102.93 114.23,103.06 114.56,103.06 114.69,102.93 114.69,102.52 114.82,102.4 115.12,102.4 115.25,102.52 115.25,102.96 115.73,103.44 116.04,103.44 117.66,105.06 117.66,109.08
  BOTTOM w0.102: v1(118.44,112.31) 118.73,112.31 U45.AM43 ; U51.B8 v1(83.37,69.34)
M_A_DQ51: length 65
  TOP w0.102: U29.C2 82.57,68.53 v1(82.57,68.56)
  IN1 w0.076: 115.91,109.71 116.04,109.84 116.67,109.84 116.92,110.09 116.92,111.32 117.46,111.85 v1(117.46,112.27)
  IN1 w0.102: 82.79,70.85 82.65,70.71 82.37,70.71 82.13,70.47 82.13,69 v1(82.57,68.56)
  IN1 w0.178: 82.79,70.85 85.57,73.63 85.57,74.16 89.54,78.14 89.54,82.24 93.24,85.94 93.7,85.94 105.32,97.56 106.26,97.56 106.86,98.17 107.64,98.17 113.05,103.57 113.05,104.75 112.38,105.42 111.67,105.42 111.54,105.55 111.54,105.98 111.67,106.11 113.06,106.11 114.64,107.68 115.35,107.68 115.55,107.88 115.55,109.36 115.91,109.71
  BOTTOM w0.102: v1(82.57,68.56) 82.96,68.17 U29.C2 ; U45.AM45 117.71,112.27 v1(117.46,112.27)
M_A_DQ52: length 66.2
  TOP w0.102: v1(83.37,68.57) 83.37,67.88 83.45,67.8 83.69,67.8 83.76,67.88 U29.C3
  IN1 w0.076: 116.8,109.54 116.88,109.54 117.09,109.75 117.09,111.23 117.85,111.99 117.85,113.18 v1(117.5,113.54)
  IN1 w0.102: v1(83.37,68.57) 82.95,68.99 82.95,70.38 83.17,70.6
  IN1 w0.178: 83.17,70.6 85.96,73.39 85.96,74 89.94,77.98 89.94,82.08 93.4,85.54 93.86,85.54 105.49,97.17 106.42,97.17 107.02,97.77 107.81,97.77 113.45,103.41 113.45,104.86 113.57,104.99 113.83,104.99 113.95,104.86 113.95,104.68 114.08,104.56 114.72,104.56 114.87,104.71 114.87,105.75 115.02,105.9 115.27,105.9 116.08,106.7 116.08,109.27 116.34,109.54 116.8,109.54
  BOTTOM w0.102: U45.AK45 117.76,113.81 v1(117.5,113.54) ; v1(83.37,68.57) 83.37,67.73 U51.D7
M_A_DQ53: length 65.7
  TOP w0.102: U29.A2 82.99,69.73 v1(83.38,70.12)
  IN1 w0.076: 117.27,109.13 117.27,109.37 117.88,109.98 117.88,111.18 118.02,111.33 118.02,113.45 118.18,113.61 v1(118.44,113.61)
  IN1 w0.178: v1(83.38,70.12) 83.47,70.21 84.01,70.21 84.13,70.34 84.13,70.47 83.93,70.67 83.93,70.8 86.36,73.23 86.36,73.78 86.47,73.9 86.55,73.9 86.62,73.82 86.8,73.82 86.93,73.95 86.93,74.13 86.88,74.18 86.88,74.36 87.01,74.48 87.19,74.48 87.26,74.41 87.42,74.41 87.54,74.53 87.54,74.69 87.45,74.77 87.45,74.94 87.57,75.05 87.73,75.05 87.81,74.97 87.98,74.97 88.09,75.09 88.09,75.25 88.01,75.33 88.01,75.49 88.13,75.61 88.29,75.61 88.37,75.53 88.53,75.53 88.65,75.64 88.65,75.81 88.57,75.89 88.57,76.05 90.02,77.51 90.26,77.51 90.37,77.62 90.37,81.95 93.57,85.15 94.02,85.15 105.65,96.78 106.74,96.78 106.87,96.9 106.87,97.02 106.99,97.14 107.15,97.14 107.27,97.02 107.27,96.99 107.37,96.88 107.48,96.88 107.62,97.02 107.62,97.25 107.7,97.34 107.93,97.34 113.84,103.25 113.84,103.76 114.21,104.12 114.36,104.12 114.49,104 114.49,103.69 114.77,103.41 115.15,103.41 115.58,103.84 115.88,103.84 117.27,105.23 117.27,109.13
  BOTTOM w0.102: U51.A7 v1(83.38,70.12) ; U45.AK43 118.73,113.61 v1(118.44,113.61)
M_A_DQ54: length 66.1
  TOP w0.102: v1(87.37,69.33) U29.B8
  IN1 w0.076: 120.79,109.56 120.79,109.99 120.82,110.03 120.82,111.81 120.45,112.18 v1(120.3,112.18)
  IN1 w0.102: 87.84,71.48 87.77,71.48 86.7,70.42 86.7,69.96 87.33,69.33 v1(87.37,69.33)
  IN1 w0.178: 120.79,109.56 120.79,103.68 120.38,103.27 120.38,103.11 120.75,102.74 120.75,102.56 120.53,102.35 120.35,102.35 120.11,102.59 119.93,102.59 119.72,102.37 119.72,102.19 119.77,102.14 119.77,101.69 119.67,101.59 119.57,101.59 119.39,101.76 119.28,101.76 118,100.48 114.3,100.48 108.32,94.49 106.6,94.49 95.18,83.07 95.18,82.74 95.51,82.41 95.51,82.23 95.21,81.93 95.03,81.93 94.75,82.21 94.32,82.21 94.11,82 93.66,82 93.22,81.55 93.22,81.24 93.41,81.04 93.41,80.86 93.24,80.69 93.06,80.69 93,80.76 92.8,80.76 92.66,80.62 92.66,76.02 88.12,71.48 87.84,71.48
  BOTTOM w0.102: U51.A2 87.76,69.72 v1(87.37,69.33) ; v1(120.3,112.18) 120.63,112.51 U45.AM40
M_A_DQ55: length 65.6
  TOP w0.102: U29.D7 87.36,67.72 v1(87.36,67.73)
  IN1 w0.076: 120.18,109.08 120.18,109.51 119.89,109.8 119.89,111.73 v1(119.39,112.23)
  IN1 w0.102: v1(87.36,67.73) 86.93,68.16 86.93,69.44 86.45,69.93 86.45,70.14
  IN1 w0.178: 120.18,109.08 120.18,103.74 120.11,103.68 119.93,103.68 119.75,103.87 119.57,103.87 119.34,103.64 119.34,103.46 119.5,103.3 119.5,102.99 119.33,102.82 119.33,102.54 119.07,102.28 117.23,102.28 117.1,102.16 117.1,101 116.98,100.87 114.14,100.87 108.15,94.88 106.43,94.88 93.94,82.39 93.5,82.39 92.26,81.16 92.26,76.36 86.45,70.55 86.45,70.14
  BOTTOM w0.102: U45.AM42 119.66,112.51 v1(119.39,112.23) ; U51.C3 v1(87.36,67.73)
M_A_DQ56: length 54.8
  TOP w0.102: v1(119.39,70.15) U31.A7
  IN3 w0.14: v1(116.53,112.88) 117.03,112.39 117.03,112.05 117.94,111.13 117.94,110.16 117,109.22 117,106.23 117.13,106.11 117.71,106.11 117.84,105.98 117.84,105.77 117.71,105.65 117.13,105.65 117,105.52 117,105.32 117.13,105.19 117.71,105.19 117.84,105.06 117.84,104.86 117.71,104.73 117.13,104.73 117,104.61 117,104.4 113.7,101.1 113.7,100.87 113.83,100.75 114.19,100.75 114.32,100.62 114.32,100.42 114.19,100.29 113.8,100.29 113.67,100.16 113.67,99.96 113.8,99.83 114.19,99.83 114.32,99.7 114.32,99.5 114.19,99.37 113.8,99.37 113.67,99.25 113.67,91.45 114.25,90.88 114.25,88.59 114.96,87.88 114.96,87.37 114.25,86.66 114.25,85.87 113.95,85.58 113.95,84.3 115.52,82.74 115.52,79.27 116.48,78.3 116.48,73.41 119.39,70.5 v1(119.39,70.15)
  BOTTOM w0.102: v1(116.53,112.88) 116.91,112.51 U45.AM46 ; U31.A7 v1(119.39,70.15)
M_A_DQ57: length 54.1
  TOP w0.102: v1(119.37,69.33) U31.B8
  IN3 w0.076: v1(116.53,113.53) 116.11,113.12 116.11,112 116.51,111.61 116.83,111.61 116.97,111.47 116.97,111.17
  IN3 w0.14: v1(119.37,69.33) 118.96,69.33 118.83,69.45 118.83,70.56 116.13,73.26 116.13,78.14 115.16,79.1 115.16,82.59 112.98,84.78 112.98,84.87 113.1,85 113.47,85 113.6,85.12 113.6,85.33 113.47,85.45 113.1,85.45 112.98,85.58 112.98,85.79 113.1,85.91 113.76,85.91 113.89,86.04 113.89,87.28 114.02,87.41 114.46,87.41 114.59,87.54 114.59,87.74 114.46,87.87 114.02,87.87 113.89,87.99 113.89,90.74 113.32,91.31 113.32,101.22 115.81,103.71 115.81,107.69 116.09,107.97 116.09,109.26 116.97,110.14 116.97,111.17
  BOTTOM w0.102: v1(119.37,69.33) 119.77,69.72 U53.A2 ; v1(116.53,113.53) 116.8,113.81 U45.AK46
M_A_DQ58: length 52
  TOP w0.102: U31.A3 v1(115.38,69.34)
  IN3 w0.089: v1(114.55,112.18) 114.55,111.78 114.13,111.36 114.13,110.09 113.88,109.84
  IN3 w0.14: v1(115.38,69.34) 115.83,69.79 115.83,70.63 114.06,72.4 114.06,74.97 112.71,76.33 112.71,78.13 111.95,78.89 111.95,79.33 111.74,79.54 111.74,82.89 110.93,83.7 110.93,87.27 111.27,87.61 111.27,87.79 111.17,87.89 111.03,87.89 110.93,87.99 110.93,88.25 111.03,88.35 111.17,88.35 111.27,88.45 111.27,88.71 111.17,88.81 111.06,88.81 110.96,88.91 110.96,89.16 111.06,89.26 111.17,89.26 111.27,89.37 111.27,89.62 111.17,89.72 111.03,89.72 110.93,89.82 110.93,90.08 111.03,90.18 111.17,90.18 111.27,90.28 111.27,90.53 111.17,90.64 111.03,90.64 110.93,90.74 110.93,90.99 111.03,91.09 111.17,91.09 111.27,91.2 111.27,91.45 111.17,91.55 111.03,91.55 110.93,91.65 110.93,91.91 111.03,92.01 111.17,92.01 111.27,92.11 111.27,92.36 111.17,92.47 111.03,92.47 110.93,92.57 110.93,92.82 111.03,92.92 111.17,92.92 111.27,93.02 111.27,93.28 111.17,93.38 111.03,93.38 110.93,93.48 110.93,93.74 111.03,93.84 111.17,93.84 111.27,93.94 111.27,94.19 111.17,94.29 111.03,94.29 110.93,94.4 110.93,94.65 111.03,94.75 111.17,94.75 111.27,94.85 111.27,102.09 113.04,103.86 113.04,105.33 112.82,105.55 112.82,106.66 113.17,107.01 113.17,109.13 113.88,109.84
  BOTTOM w0.102: U53.B8 v1(115.38,69.34) ; v1(114.55,112.18) 114.88,112.51 U45.AM49
M_A_DQ59: length 51.2
  TOP w0.102: v1(115.38,70.13) 115.36,70.1 115.34,70.1 U31.A2
  IN3 w0.076: 113.95,111.9 114.12,112.08 114.12,113.14 v1(114.6,113.61)
  IN3 w0.14: 113.95,111.9 113.06,111.02 113.06,109.53 111.99,108.45 111.99,105.87 112.68,105.18 112.68,104.01 110.91,102.24 110.91,98.79 110.81,98.69 110.7,98.69 110.6,98.59 110.6,98.33 110.7,98.23 110.81,98.23 110.91,98.13 110.91,97.88 110.81,97.77 110.68,97.77 110.58,97.67 110.58,97.42 110.68,97.32 110.81,97.32 110.91,97.22 110.91,96.96 110.81,96.86 110.68,96.86 110.58,96.76 110.58,96.5 110.68,96.4 110.81,96.4 110.91,96.3 110.91,96.05 110.81,95.95 110.68,95.95 110.58,95.84 110.58,95.59 110.68,95.49 110.81,95.49 110.91,95.39 110.91,95.13 110.81,95.03 110.68,95.03 110.58,94.93 110.58,83.55 111.38,82.74 111.38,79.39 111.59,79.19 111.59,76.94 113.71,74.82 113.71,72.25 115.38,70.57 v1(115.38,70.13)
  BOTTOM w0.102: U45.AK49 114.8,113.81 v1(114.6,113.61) ; U53.A7 115.77,69.75 115.4,70.13 v1(115.38,70.13)
M_A_DQ60: length 53.7
  TOP w0.102: U31.D7 v1(118.57,67.73)
  IN3 w0.076: 115.78,109.86 115.96,110.05 115.96,111.05 115.53,111.49 v1(115.53,112.11)
  IN3 w0.14: 115.78,109.86 115.38,109.46 115.38,108.27 114.51,107.4 114.51,105.77 114.77,105.52 114.77,104.63 114.51,104.38 114.51,103.42 112.61,101.51 112.61,90.83 112.87,90.56 113.05,90.56 113.18,90.43 113.18,90.23 113.05,90.1 112.87,90.1 112.75,89.98 112.75,89.77 112.87,89.65 113.05,89.65 113.18,89.52 113.18,89.32 113.05,89.19 112.87,89.19 112.75,89.06 112.75,88.86 112.87,88.73 113.05,88.73 113.18,88.6 113.18,88.4 113.05,88.27 112.87,88.27 112.75,88.15 112.75,87.91 113.18,87.47 113.18,86.75 113.05,86.62 112.39,86.62 112.26,86.5 112.26,84.3 113.83,82.74 113.83,79.56 114.05,79.33 114.05,76.98 114.3,76.74 115.04,76.74 115.42,76.37 115.42,72.97 117.94,70.44 117.94,68.69 118.57,68.06 v1(118.57,67.73)
  BOTTOM w0.102: v1(115.53,112.11) 115.93,112.51 U45.AM48 ; U53.C3 118.97,68.12 v1(118.57,67.73)
M_A_DQ61: length 52.9
  TOP w0.102: v1(119.36,67.72) U31.C8
  IN3 w0.076: 115.78,109.46 116.14,109.81 116.14,111.21 115.93,111.41 115.93,113.15 v1(115.55,113.53)
  IN3 w0.14: v1(119.36,67.72) 118.7,68.38 118.7,68.61 118.36,68.96 118.36,70.53 115.77,73.11 115.77,77.99 114.81,78.96 114.81,82.44 112.62,84.63 112.62,86.14 112.75,86.27 113.41,86.27 113.53,86.39 113.53,90.59 112.96,91.16 112.96,101.37 115.46,103.86 115.46,107.84 115.74,108.12 115.74,109.41 115.78,109.46
  BOTTOM w0.102: U45.AK48 115.83,113.81 v1(115.55,113.53) ; U31.C8 v1(119.36,67.72)
M_A_DQ62: length 52.2
  TOP w0.102: U31.C3 115.77,67.86 115.71,67.8 115.5,67.8 115.37,67.93 v1(115.37,68.57)
  IN3 w0.102: v1(115.37,68.57) 114.94,69 114.94,69.5 114.71,69.74 114.51,69.74 114.13,70.12 114.13,70.87 114.14,70.88
  IN3 w0.14: 114.14,70.88 114.14,71.31 113.35,72.1 113.35,74.68 111.24,76.79 111.24,79.04 111.03,79.25 111.03,82.59 110.22,83.4 110.22,98.87 110.32,98.97 110.45,98.97 110.56,99.07 110.56,99.32 110.45,99.42 110.32,99.42 110.22,99.53 110.22,99.78 110.32,99.88 110.45,99.88 110.56,99.98 110.56,100.24 110.45,100.34 110.32,100.34 110.22,100.44 110.22,100.69 110.32,100.8 110.45,100.8 110.56,100.9 110.56,102.38 112.33,104.15 112.33,105.03 111.63,105.73 111.63,108.6 112.71,109.68 112.71,111.27 v1(113.65,112.21)
  BOTTOM w0.102: U53.D7 115.37,67.73 v1(115.37,68.57) ; v1(113.65,112.21) 113.95,112.51 U45.AM51
M_A_DQ63: length 50.8
  TOP w0.102: U31.C2 114.97,68.17 v1(114.57,68.56)
  IN3 w0.102: 113.47,71.36 113.88,70.95 113.88,70.01 114.13,69.76 114.13,69 v1(114.57,68.56)
  IN3 w0.14: 113.47,71.36 112.99,71.83 112.99,74.53 110.88,76.64 110.88,78.89 110.67,79.1 110.67,82.44 109.86,83.25 109.86,102.19 111.95,104.28 111.95,104.91 111.28,105.58 111.28,108.75 112.35,109.82 112.35,112.31 113.3,113.26 113.45,113.26 v1(113.67,113.48)
  BOTTOM w0.102: U45.AK51 113.76,113.48 v1(113.67,113.48) ; v1(114.57,68.56) 114.97,68.17 U31.C2
M_A_DQS0: length 74.2
  TOP w0.102: U30.F3 102.56,65.52 102.64,65.44 102.86,65.44 103.04,65.26 103.15,65.26 103.26,65.38 103.26,65.75 103.44,65.92 103.65,65.92 v1(103.88,66.16)
  IN3 w0.102: 98.26,68.35 98.31,68.29 98.37,68.29 99.27,67.39 100.4,67.39 100.65,67.14 103.4,67.14 104.1,66.45 104.1,66.2 104.06,66.16 v1(103.88,66.16)
  IN3 w0.152: 98.26,68.35 98,68.6 98,68.64 96.38,70.27 96.38,70.7 94.09,72.99 94.09,73.7 91.16,76.63 91.16,83.87 93.11,85.82 93.11,88.38 93.17,88.44 93.36,88.63 93.61,88.88 94.73,89.99 94.73,108.17 95.18,108.63 95.59,109.04 95.59,111.24 98.89,114.54 99.73,114.54 100.14,114.12 100.14,114 100.24,113.91 v1(100.42,113.73)
  BOTTOM w0.076: U45.AJ62 107.21,114.16 107.21,114.28 107.15,114.34 106.99,114.34 106.91,114.26 106.82,114.26 106.75,114.33 106.65,114.38 106.59,114.41 106.46,114.41 106.33,114.36 106.28,114.34 105.79,114.34 105.75,114.3 100.22,114.3 100.11,114.19 100.11,113.73 100.25,113.6 100.29,113.6 v1(100.42,113.73)
  BOTTOM w0.102: U52.F3 105.5,65.47 105.17,65.47 104.72,65.92 104.12,65.92 v1(103.88,66.16)
M_A_DQS1: length 79.4
  TOP w0.102: U28.F3 70.49,65.67 70.49,65.56 70.67,65.39 70.86,65.39 71.04,65.2 71.12,65.2 71.18,65.27 71.18,65.75 71.36,65.92 71.62,65.92 v1(71.8,66.11)
  IN1 w0.102: v1(71.8,66.11) 71.76,66.07 71.76,65.97 71.84,65.9 72.19,65.9 72.3,66.01 72.3,66.19 71.37,67.12 68.68,67.12 68.45,67.34 67.69,67.34 66.81,68.23 66.81,70.05 67.55,70.78 67.55,70.85
  IN1 w0.203: 67.55,70.85 67.55,73.46 68.26,74.17 68.26,75.85 69.1,76.69 69.1,78.37 73.11,82.38 73.11,82.64 81.56,91.08 81.56,91.78 81.56,92.53 83.55,94.52 83.55,95.03 84.18,95.67 84.69,95.67 86.6,97.58 87.35,97.58 87.35,97.57 88.13,97.57 89.34,98.79 89.34,100.01 92.41,103.08 93.79,103.08 98.8,108.09 98.8,109.94 99.46,110.6 103.16,110.6 103.44,110.88 103.44,111.14 v1(103.32,111.26)
  BOTTOM w0.076: v1(103.32,111.26) 103.49,111.67 103.89,112.07 106.25,112.07 106.27,112.08 106.42,112.15 106.62,112.15 106.72,112.1 106.78,112.07 107.24,112.07 U45.AN61
  BOTTOM w0.102: v1(71.8,66.11) 72.04,65.87 72.81,65.87 73.18,65.51 73.54,65.51 U50.F3
M_A_DQS2: length 62.5
  TOP w0.102: v1(104.36,68.21) 104.56,68.41 104.77,68.41 105.05,68.69 105.18,68.69 105.46,68.41 105.67,68.41 105.76,68.32 U30.C7
  IN3 w0.152: v1(104.36,68.21) 104.6,68.45 104.9,68.45 105.14,68.69 105.14,69.16 104.59,69.71 104.33,69.71 103.82,70.22 103.82,70.66 101.79,72.69 101.79,75.9 101.53,76.16 99.96,76.16 99.81,76.31 99.81,78.84 99.38,79.26 99.38,83.76 99.5,83.88 100.82,83.88 101.08,84.13 101.08,88.25 100.82,88.5 99.65,88.5 99.53,88.63 99.53,98.21 99.05,98.68 99.05,105.15 100.49,106.59 100.49,108.78 100.61,108.9 104.88,108.9 105.5,109.52 105.5,109.69 107.55,111.74 108.75,111.74 v1(108.97,111.53)
  BOTTOM w0.102: U45.AN58 109.29,111.86 v1(108.97,111.53) ; v1(104.36,68.21) 104.16,68.41 102.84,68.41 U52.C7
M_A_DQS3: length 69.8
  TOP w0.102: U28.C7 73.76,68.35 73.67,68.44 73.48,68.44 73.2,68.72 73.09,68.72 72.79,68.41 72.61,68.41 v1(72.41,68.21)
  IN1 w0.076: v1(110.87,111.53) 111.15,111.53 111.26,111.42 111.26,109.87 109.55,108.16 107.38,108.16 107.06,108.48 106.71,108.48 106.61,108.58
  IN1 w0.203: v1(72.41,68.21) 72.25,68.36 72.04,68.36 71.66,68.74 71.66,71.33 71.99,71.66 72.68,71.66 74.94,73.92 74.94,74.51 76.29,75.85 76.55,75.85 76.95,76.25 76.95,79.16 81.59,83.8 81.59,84.35 82.79,85.55 82.79,85.98 86.67,89.86 86.67,91.26 88.54,93.13 89.97,93.13 90.42,93.58 91.28,93.58 98.91,101.21 98.91,101.91 100.75,103.76 101.45,103.76 106.28,108.58 106.61,108.58 106.61,108.58
  BOTTOM w0.102: U45.AN55 111.22,111.86 110.9,111.53 v1(110.87,111.53) ; v1(72.41,68.21) 72.2,68.41 70.84,68.41 U50.C7
M_A_DQS4: length 61.3
  TOP w0.102: v1(117.32,66.29) 117.08,66.05 116.93,66.05 116.31,65.44 116.06,65.44 U31.F3
  IN3 w0.102: v1(117.32,66.29) 117.32,66.24 117.08,66 116.96,66 116.87,66.08 116.87,66.99 116.52,67.34 114,67.34 113.8,67.55 112.23,67.55 112.2,67.57
  IN3 w0.152: 112.2,67.57 111.29,68.49 111.29,69.86 107.9,73.24 107.9,74.76 106.91,75.75 106.91,75.92 107.22,76.23 107.22,76.64 106.91,76.95 106.91,96.55 104.04,99.42 104.04,103.49 105.41,104.86 105.83,104.86 106.16,104.53 106.16,104.36 106.02,104.22 105.8,104.22 v1(105.67,104.35)
  BOTTOM w0.076: U45.AW57 110.06,108.5 109.94,108.62 109.85,108.62 109.82,108.59 109.77,108.49 109.77,108.36 109.84,108.2 109.84,107.99 109.82,107.94 109.78,107.86 109.77,107.84 109.77,107.71 109.8,107.65 109.84,107.55 109.84,107.26 109.6,107.01 109.6,106.5 107.54,104.44 106.67,104.44 106.56,104.33 105.69,104.33 v1(105.67,104.35)
  BOTTOM w0.102: U53.F3 118.97,65.53 118.87,65.44 118.68,65.44 118.07,66.05 117.55,66.05 v1(117.32,66.29)
M_A_DQS5: length 70.4
  TOP w0.102: v1(85.06,66.21) 84.82,65.97 84.67,65.97 84.44,65.75 84.44,65.3 84.38,65.24 84.24,65.24 84.04,65.44 83.82,65.44 83.76,65.5 U29.F3
  IN1 w0.102: 80.45,67.52 80.46,67.51 80.54,67.51 80.68,67.37 81.75,67.37 81.98,67.14 84.71,67.14 85.52,66.33 85.52,66.15 85.42,66.05 85.22,66.05 v1(85.06,66.21)
  IN1 w0.203: v1(110.64,103.75) 110.39,103.75 110.27,103.87 110.27,104.12 109.99,104.4 109.31,104.4 105.13,100.23 104.22,100.23 92.59,88.6 92.13,88.6 86.39,82.86 86.39,81.01 85.3,79.92 85.3,79.1 82.9,76.7 82.9,74.88 78.95,70.94 78.95,69.02 80.45,67.52
  BOTTOM w0.076: 111.74,105.5 111.75,105.51 111.75,105.53 112.02,105.8 112.02,107 112.27,107.25 112.27,107.53 arc(112.27,107.55) 112.27,107.56 112.25,107.6 112.21,107.68 arc(112.2,107.71) 112.2,107.73 112.2,107.84 112.21,107.85 112.23,107.9 112.27,107.99 112.27,108.41 112.33,108.47 112.45,108.47 U45.AW53
  BOTTOM w0.102: U51.F3 86.7,65.47 86.37,65.47 85.86,65.97 85.3,65.97 v1(85.06,66.21) ; 111.74,105.5 110.16,103.92 110.16,103.67 110.39,103.44 110.6,103.44 110.65,103.49 110.65,103.74 v1(110.64,103.75)
M_A_DQS6: length 67.3
  TOP w0.102: v1(85.44,68.46) 85.66,68.68 86.12,68.68 86.37,68.43 86.87,68.43 86.96,68.34 U29.C7
  IN1 w0.076: 119.07,109.08 119.07,109.09 118.99,109.16 118.99,112.8 119.15,112.96 119.15,112.96 119.16,112.96 119.31,112.96 v1(119.39,112.88)
  IN1 w0.203: v1(85.44,68.46) 85.62,68.64 86.14,68.64 86.45,68.95 86.45,69.37 85.94,69.88 85.94,70.85 87.72,72.63 87.72,72.78 91.66,76.73 91.66,81.4 93.25,82.99 93.7,82.99 106.19,95.48 107.91,95.48 113.91,101.48 116.16,101.48 116.47,101.79 116.47,102.58 117.51,103.62 117.84,103.62 117.89,103.57 118.37,103.57 118.8,104 118.8,104.43 118.75,104.48 118.75,104.73 119.07,105.04 119.07,109.08
  BOTTOM w0.102: U45.AL42 119.66,113.16 v1(119.39,112.88) ; v1(85.44,68.46) 85.22,68.68 84.66,68.68 84.4,68.41 84.05,68.41 U51.C7
M_A_DQS7: length 53.4
  TOP w0.102: U31.C7 118.68,68.41 117.59,68.41 v1(117.39,68.21)
  IN3 w0.089: 114.45,109.63 114.5,109.63 114.95,110.08 114.95,112.59 114.57,112.96 v1(114.57,112.99)
  IN3 w0.152: 114.45,109.63 113.72,108.91 113.72,106.78 113.37,106.43 113.37,105.78 113.62,105.53 113.62,103.66 111.82,101.86 111.82,87.38 111.48,87.04 111.48,83.98 113.01,82.45 113.01,78.6 113.26,78.36 113.26,76.56 114.61,75.2 114.61,72.63 116.59,70.65 116.59,68.67 116.85,68.41 117.19,68.41 v1(117.39,68.21)
  BOTTOM w0.102: v1(117.39,68.21) 117.19,68.41 116.05,68.41 U53.C7 ; U45.AL49 114.75,113.16 v1(114.57,112.99)
M_A_DQS#0: length 74.3
  TOP w0.102: v1(103.88,65.54) 103.71,65.72 103.52,65.72 103.47,65.66 103.47,65.29 103.23,65.06 102.96,65.06 102.78,65.24 102.68,65.24 102.56,65.12 U30.G3
  IN3 w0.102: 98.41,68.52 98.42,68.51 98.44,68.51 99.35,67.59 100.49,67.59 100.74,67.34 103.49,67.34 104.3,66.53 104.3,65.96 v1(103.88,65.54)
  IN3 w0.152: v1(99.71,113.8) 99.9,113.99 99.9,114.04 99.63,114.31 98.99,114.31 95.82,111.14 95.82,108.95 95.28,108.4 94.95,108.08 94.95,89.9 94.15,89.09 93.53,88.47 93.34,88.28 93.34,85.72 91.39,83.77 91.39,76.73 94.32,73.8 94.32,73.08 96.61,70.79 96.61,70.36 98.41,68.56 98.41,68.52
  BOTTOM w0.076: U45.AJ61 107.44,114.5 106.78,114.5 106.72,114.53 106.68,114.55 106.62,114.58 106.42,114.58 106.27,114.51 106.25,114.5 105.71,114.5 105.69,114.52 105.68,114.51 103.67,114.51 103.66,114.5 100.19,114.5 99.95,114.26 99.95,114.04 v1(99.71,113.8)
  BOTTOM w0.102: U52.G3 105.42,65.27 105.09,65.27 104.63,65.72 104.06,65.72 v1(103.88,65.54)
M_A_DQS#1: length 79.5
  TOP w0.102: v1(71.8,65.49) 71.8,65.58 71.66,65.72 71.44,65.72 71.39,65.66 71.39,65.18 71.2,65 70.96,65 70.77,65.19 70.59,65.19 70.49,65.08 70.49,64.99 U28.G3
  IN1 w0.102: 67.85,70.8 67.01,69.96 67.01,68.31 67.78,67.55 68.54,67.55 68.77,67.32 71.46,67.32 72.5,66.28 72.5,65.92 72.27,65.69 72,65.69 v1(71.8,65.49)
  IN1 w0.203: 67.85,70.8 67.85,73.33 68.56,74.04 68.56,75.73 69.4,76.56 69.4,78.24 73.41,82.26 73.41,82.51 81.86,90.95 81.86,91.91 81.86,92.4 83.85,94.4 83.85,94.91 84.31,95.36 84.82,95.36 86.73,97.27 87.22,97.27 88.25,97.27 89.65,98.66 89.65,99.89 92.53,102.77 93.91,102.77 99.1,107.97 99.1,109.82 99.58,110.3 103.29,110.3 103.74,110.75 103.74,111.08 103.92,111.26 v1(104.04,111.26)
  BOTTOM w0.076: U45.AN62 107.22,111.74 107.22,111.86 107.17,111.91 106.74,111.91 106.7,111.93 106.65,111.95 106.59,111.98 106.46,111.98 106.33,111.93 106.28,111.91 103.96,111.91 103.65,111.6 103.65,111.51 103.72,111.44 103.72,111.26 103.85,111.13 103.97,111.13 104.04,111.21 v1(104.04,111.26)
  BOTTOM w0.102: v1(71.8,65.49) 71.98,65.67 72.73,65.67 73.09,65.31 73.38,65.31 U50.G3
M_A_DQS#2: length 62.7
  TOP w0.102: v1(104.36,68.85) 104.59,68.61 104.68,68.61 104.96,68.89 105.27,68.89 105.55,68.61 105.65,68.61 105.76,68.73 U30.B7
  IN3 w0.152: v1(108.97,112.16) 108.78,111.97 107.46,111.97 105.27,109.78 105.27,109.61 104.78,109.13 100.52,109.13 100.26,108.87 100.26,106.69 98.82,105.25 98.82,98.59 99.3,98.11 99.3,88.54 99.56,88.27 100.73,88.27 100.85,88.15 100.85,84.23 100.73,84.11 99.41,84.11 99.15,83.86 99.15,79.16 99.58,78.74 99.58,76.22 99.86,75.93 101.44,75.93 101.56,75.81 101.56,72.6 103.56,70.59 103.56,70.11 104.23,69.45 104.48,69.45 104.89,69.05 104.89,68.8 104.79,68.71 104.5,68.71 v1(104.36,68.85)
  BOTTOM w0.102: U45.AM58 109.46,112.47 109.46,112.28 109.33,112.16 v1(108.97,112.16) ; v1(104.36,68.85) 104.13,68.61 102.87,68.61 U52.B7
M_A_DQS#3: length 70
  TOP w0.102: U28.B7 73.76,68.7 73.69,68.64 73.57,68.64 73.29,68.92 73.01,68.92 72.7,68.61 72.64,68.61 v1(72.41,68.85)
  IN1 w0.076: 106.51,108.24 106.59,108.31 106.99,108.31 107.31,108 109.62,108 111.43,109.8 111.43,111.49 111.24,111.68 111.24,111.82 v1(110.87,112.18)
  IN1 w0.203: v1(72.41,68.85) 72.41,68.75 72.32,68.67 72.17,68.67 71.97,68.87 71.97,71.21 72.12,71.36 72.81,71.36 75.24,73.8 75.24,74.38 76.41,75.55 76.68,75.55 77.25,76.12 77.25,79.03 81.89,83.67 81.89,84.22 83.1,85.42 83.1,85.86 86.98,89.74 86.98,91.13 88.67,92.83 90.1,92.83 90.55,93.28 91.41,93.28 99.21,101.08 99.21,101.79 100.88,103.45 101.58,103.45 106.37,108.24 106.51,108.24
  BOTTOM w0.102: U50.B7 70.87,68.61 72.17,68.61 v1(72.41,68.85) ; v1(110.87,112.18) 111.24,112.18 111.36,112.31 111.36,112.41 U45.AM55
M_A_DQS#4: length 61.4
  TOP w0.102: v1(117.32,65.67) 117.14,65.85 117.01,65.85 116.4,65.24 116.08,65.24 U31.G3
  IN3 w0.102: v1(117.32,65.67) 117.19,65.8 116.87,65.8 116.67,66 116.67,66.9 116.43,67.14 113.92,67.14 113.72,67.34 112.11,67.34 112.1,67.35 112.06,67.35 112.05,67.37
  IN3 w0.152: v1(106.31,105.01) 106,105.01 105.92,105.09 105.32,105.09 103.81,103.58 103.81,99.33 106.68,96.46 106.68,76.86 106.99,76.55 106.99,76.33 106.68,76.02 106.68,75.66 107.67,74.67 107.67,73.15 111.03,69.79 111.03,68.38 112.05,67.37
  BOTTOM w0.076: U45.AV57 110.06,108.84 110.01,108.79 109.78,108.79 109.68,108.69 109.6,108.52 109.6,108.32 109.63,108.26 109.68,108.16 109.68,108.03 109.6,107.87 109.6,107.67 109.63,107.62 109.68,107.51 109.68,107.32 109.43,107.08 109.43,106.57 107.48,104.61 106.6,104.61 106.49,104.5 106.24,104.5 106.13,104.61 106.13,104.83 v1(106.31,105.01)
  BOTTOM w0.102: U53.G3 118.97,65.15 118.88,65.24 118.6,65.24 117.99,65.85 117.49,65.85 v1(117.32,65.67)
M_A_DQS#5: length 70.5
  TOP w0.102: v1(85.06,65.59) 84.88,65.77 84.75,65.77 84.65,65.66 84.65,65.22 84.46,65.03 84.16,65.03 83.96,65.24 83.83,65.24 83.76,65.17 U29.G3
  IN1 w0.102: 80.66,67.74 80.67,67.73 80.67,67.71 80.65,67.69 80.76,67.57 81.83,67.57 82.06,67.34 84.79,67.34 85.72,66.42 85.72,66.06 85.51,65.85 85.27,65.85 85.23,65.8 85.12,65.8 85.05,65.73 85.05,65.61 v1(85.06,65.59)
  IN1 w0.203: v1(110.05,103.19) 110.19,103.33 110.19,103.51 109.97,103.74 109.97,104 109.86,104.1 109.43,104.1 105.26,99.93 104.34,99.93 92.72,88.3 92.26,88.3 86.7,82.74 86.7,80.88 85.61,79.79 85.61,78.98 83.21,76.58 83.21,74.76 79.26,70.81 79.26,69.14 80.66,67.74
  BOTTOM w0.076: 111.57,105.6 111.59,105.6 111.86,105.87 111.86,107.07 112.11,107.32 112.11,107.51 112.07,107.59 112.04,107.67 112.04,107.87 112.08,107.97 112.11,108.03 112.11,108.48 112.49,108.86 U45.AV53
  BOTTOM w0.102: U51.G3 86.63,65.26 86.28,65.26 85.78,65.77 85.24,65.77 v1(85.06,65.59) ; 111.57,105.6 109.97,103.99 109.97,103.59 110.19,103.36 110.19,103.33 v1(110.05,103.19)
M_A_DQS#6: length 67.4
  TOP w0.102: v1(85.44,69.1) 85.66,68.88 86.2,68.88 86.46,68.63 86.87,68.63 86.96,68.73 U29.B7
  IN1 w0.076: v1(118.44,112.96) 118.62,113.14 118.9,113.14 118.96,113.08 118.96,113 118.83,112.87 118.83,109.18 118.76,109.11 118.76,109.08
  IN1 w0.203: v1(85.44,69.1) 85.59,68.94 86.01,68.94 86.14,69.07 86.14,69.25 85.63,69.76 85.63,70.98 87.41,72.75 87.41,72.91 91.36,76.86 91.36,81.53 93.13,83.3 93.57,83.3 106.06,95.79 107.78,95.79 113.78,101.79 116.04,101.79 116.16,101.91 116.16,102.7 117.38,103.92 117.97,103.92 118.02,103.87 118.25,103.87 118.5,104.12 118.5,104.3 118.45,104.35 118.45,104.86 118.76,105.17 118.76,109.08
  BOTTOM w0.102: v1(85.44,69.1) 85.22,68.88 84.58,68.88 84.31,68.61 84.08,68.61 U51.B7 ; U45.AL43 118.93,112.96 118.8,112.84 118.56,112.84 v1(118.44,112.96)
M_A_DQS#7: length 53.6
  TOP w0.102: v1(117.39,68.85) 117.62,68.61 118.65,68.61 U31.B7
  IN3 w0.089: 114.6,109.46 114.6,109.48 115.13,110.01 115.13,112.69 114.99,112.82 114.99,113.01 115.09,113.11 115.32,113.11 v1(115.53,112.91)
  IN3 w0.152: v1(117.39,68.85) 117.21,68.67 116.95,68.67 116.85,68.77 116.85,70.72 114.84,72.72 114.84,75.29 113.49,76.65 113.49,78.45 113.24,78.7 113.24,82.54 111.71,84.07 111.71,86.95 112.05,87.28 112.05,101.76 113.85,103.57 113.85,105.62 113.6,105.87 113.6,106.33 113.95,106.69 113.95,108.81 114.6,109.46
  BOTTOM w0.102: U45.AL48 115.78,113.16 v1(115.53,112.91) ; U53.B7 116.08,68.61 117.16,68.61 v1(117.39,68.85)
M_A_ODT0: length 90.6
  TOP w0.102: U29.K1 82.16,62.9 82.24,62.98 82.38,62.98 82.53,62.82 82.74,62.82 82.89,62.98 83.09,62.98 83.17,62.9 83.17,62.8 83.24,62.72 83.47,62.72 83.55,62.8 83.55,62.9 83.63,62.98 84.01,62.98 84.11,62.87 84.11,62.77 84.24,62.65 85.15,62.65 v1(85.35,62.85) ; v1(72.71,62.62) 72.6,62.72 70.9,62.72 70.76,62.86 70.42,62.86 70.21,62.64 70.21,62.51 69.89,62.2 69.29,62.2 U28.K1 68.22,62.53 67.96,62.79 66.59,62.79 66.35,63.03 66.35,63.08 65.95,63.48 R333.2 ; v1(104.25,62.77) 104.07,62.95 102.24,62.95 102.17,62.87 102.17,62.37 101.93,62.13 101.1,62.13 100.96,62.26 U30.K1 ; v1(116.62,62.76) 116.62,62.54 116.49,62.42 116.21,62.42 116.11,62.52 116.11,62.82 116.29,63 116.29,63.15 116.24,63.2 116.12,63.2 115.89,62.98 115.63,62.98 115.55,62.9 115.55,62.8 115.45,62.7 115.27,62.7 115.21,62.76 115.21,62.9 115.13,62.98 114.87,62.98 114.42,62.53 U31.K1
  IN3 w0.14: v1(116.62,62.76) 116.32,63.07 116.32,63.26 116.16,63.41 116.01,63.41 115.88,63.28 115.88,62.79 115.66,62.57 113.39,62.57 112.66,63.31 107.45,63.31 107.32,63.18 107.32,62.37 107.22,62.26 106.81,62.26 106.69,62.38 106.69,62.54 106.56,62.67 105.44,62.67 105.32,62.54 105.32,62.39 105.19,62.26 104.85,62.26 104.34,62.77 v1(104.25,62.77) 102.78,62.77 102.47,62.47 100.16,62.47 99.73,62.9 97.14,62.9 96.45,62.21 94.07,62.21 93.89,62.39 91.17,62.39 91.04,62.52 91.04,63.03 90.92,63.15 89.54,63.15 89.05,62.66 85.54,62.66 v1(85.35,62.85) 85.15,62.85 84.94,62.65 84.24,62.65 83.77,62.18 79.33,62.18 79.21,62.05 79.21,61.69 79.08,61.57 78.77,61.57 78.65,61.69 78.65,62.05 78.52,62.18 78.22,62.18 78.09,62.05 78.09,61.69 77.96,61.57 77.66,61.57 77.53,61.69 77.53,61.87 77.4,61.99 76.49,61.99 76.36,62.12 76.36,62.39 76.23,62.52 75.93,62.52 75.8,62.39 75.8,62.12 75.68,61.99 75.37,61.99 75.24,62.12 75.24,62.44 75.07,62.62 v1(72.71,62.62)
  BOTTOM w0.102: U51.K1 88.81,62.53 88.96,62.68 88.96,62.82 88.81,62.98 85.48,62.98 v1(85.35,62.85) ; U53.K1 120.19,62.9 117.72,62.9 117.38,62.57 116.81,62.57 v1(116.62,62.76) ; U52.K1 107.36,62.82 107.28,62.9 105.44,62.9 105.37,62.82 105.37,62.44 105.22,62.29 104.38,62.29 104.25,62.42 v1(104.25,62.77) ; v1(72.71,62.62) 72.6,62.72 72.37,62.72 72.25,62.85 72.25,63 72.37,63.13 73.08,63.13 73.24,62.98 75.28,62.98 75.36,62.9 U50.K1
M_A_RAS#: length 148.7
  TOP w0.102: R339.2 63.28,62.91 65.79,62.91 v1(65.95,62.76) ; U30.J3 102.66,63.23 104.49,63.23 v1(104.94,62.77) ; v1(71.87,63.14) 71.77,63.05 71.18,63.05 71.1,63.13 71.1,63.84 71.03,63.92 70.82,63.92 70.72,63.81 70.72,63.4 70.65,63.33 U28.J3 ; v1(84.77,63.08) 84.54,62.85 84.39,62.85 84.31,62.93 84.31,63.86 84.24,63.94 84.06,63.94 83.96,63.84 83.96,63.4 83.88,63.33 U29.J3 ; U31.J3 115.58,63.33 115.5,63.4 115.5,63.66 115.58,63.74 116.09,63.74 116.6,63.23 116.95,63.23 v1(117.2,62.98)
  IN1 w0.178: v1(65.95,62.76) 65.97,62.73 66.98,62.73 67.17,62.93 68.43,62.93 69.06,62.3 71.03,62.3 v1(71.87,63.14) 72.11,62.9 72.35,62.9 72.59,63.14 73.52,63.14 73.64,63.02 73.64,62.68 73.77,62.56 76.17,62.56 76.46,62.26 77.12,62.26 77.25,62.39 77.25,63.1 77.38,63.23 78.83,63.23 78.95,63.1 78.95,62.87 79.08,62.75 80.88,62.75 81.39,62.24 83.68,62.24 84.29,62.85 84.54,62.85 v1(84.77,63.08) 84.99,63.3 87.33,63.3 87.48,63.15 89.26,63.15 89.39,63.28 90.33,63.28 91.22,62.39 97.16,62.39 97.62,62.85 99.91,62.85 100.3,62.46 102.56,62.46 103.32,63.22 104.5,63.22 v1(104.94,62.77) 105.45,62.77 105.63,62.58 107.59,62.58 107.83,62.34 108.37,62.34 108.49,62.47 108.49,62.79 108.62,62.91 111.97,62.91 112.1,62.79 112.1,62.47 112.23,62.34 112.45,62.34 112.58,62.47 112.58,62.79 112.71,62.91 112.94,62.91 113.06,62.79 113.06,62.47 113.19,62.34 113.34,62.34 113.55,62.54 113.75,62.54 113.95,62.34 114.11,62.34 114.35,62.58 115.34,62.58 115.48,62.72 115.99,62.72 116.11,62.85 116.11,63.08 116.04,63.15 116.04,63.28 116.16,63.41 116.36,63.41 116.56,63.21 116.97,63.21 v1(117.2,62.98)
  IN1 w0.203: v1(117.2,62.98) 118.42,62.98 119.27,63.83 121.9,63.83 123,64.92 129.67,64.92 131.28,66.53 v1(134.43,66.53)
  IN3 w0.076: 125.46,99.35 125.46,99.65 124.88,100.24 124.88,106.65 v1(124.43,107.1)
  IN3 w0.152: 125.46,99.35 125.46,90.71 127.59,88.58 127.59,86.97 128.97,85.59 128.97,84.89 130.2,83.65 130.63,83.65 131.58,82.7 131.96,82.7 132.21,82.45 132.21,79.8 131.63,79.22 131.63,77.02 132.32,76.34 133.28,76.34 134.48,75.14 134.48,72.27 134.5,72.25 134.5,66.61 v1(134.43,66.53)
  BOTTOM w0.102: U50.J3 73.76,63.64 73.68,63.71 73.44,63.71 73.36,63.64 73.36,63.41 73.29,63.33 72.05,63.33 v1(71.87,63.14) ; U45.AY34 124.78,107.45 v1(124.43,107.1) ; v1(104.94,62.77) 104.66,63.05 104.66,63.16 104.83,63.33 104.94,63.33 105.01,63.26 105.29,63.26 105.37,63.33 105.37,63.74 105.44,63.81 105.65,63.81 105.72,63.74 105.72,63.36 U52.J3 ; v1(84.77,63.08) 84.77,63.08 85.02,63.33 86.16,63.33 86.45,63.61 86.81,63.61 86.96,63.46 U51.J3 ; U53.J3 118.97,63.66 118.89,63.74 118.6,63.74 118.53,63.66 118.53,63.4 118.45,63.33 117.56,63.33 v1(117.2,62.98)
M_A_WE#: length 153.9
  TOP w0.102: U30.L3 102.82,61.73 102.97,61.58 103.37,61.58 104,60.95 104.53,60.95 v1(104.75,60.74) ; U31.L3 115.82,61.78 116.49,61.78 116.65,61.63 116.65,61.21 116.8,61.06 117.39,61.06 v1(117.68,60.77) ; v1(85.98,60.92) 85.78,61.11 84.69,61.11 84.41,61.39 84.41,61.48 84.16,61.73 U29.L3 ; 64.42,60.46 64.55,60.33 v1(65.62,60.33) ; v1(72.77,60.87) 72.54,61.1 71.97,61.1 71.94,61.07 71.19,61.07 70.56,61.7 U28.L3
  TOP w0.241: R350.2 62.7,59.82 63.34,60.46 64.42,60.46
  IN1 w0.178: v1(117.68,60.77) 117.46,60.99 116.41,60.99 116.12,60.7 115.07,59.65 112.3,59.65 111.13,60.82 109.62,60.82 108.09,59.29 106.64,59.29 106.51,59.42 106.51,60.69 106.38,60.82 104.82,60.82 v1(104.75,60.74) 104.5,60.99 103.97,60.99 103.72,60.74 101.86,60.74 100.8,59.67 95.08,59.67 94.73,60.03 92.31,60.03 91.55,59.27 87.87,59.27 86.22,60.92 v1(85.98,60.92) 85.75,60.92 85.57,61.09 85.2,61.09 85.18,61.07 84.74,61.07 83.09,59.42 81.95,59.42 81.85,59.32 80.76,59.32 80.02,60.05 74.79,60.05 74.43,60.41 74.43,61.07 74.3,61.19 73.57,61.19 73.24,60.87 v1(72.77,60.87) 72.54,60.87 72.36,61.04 71.99,61.04 71.97,61.02 69.23,61.02 69.17,60.96 67.76,60.96 67.6,60.8 67.36,60.8 66.89,60.33 v1(65.62,60.33)
  IN1 w0.203: v1(134.58,62.29) 133.87,61.58 126.77,61.58 126.44,61.25 125.26,61.25 124.09,60.08 123.1,60.08 122.64,59.62 121.55,59.62 121.21,59.28 119.68,59.28 118.26,60.7 117.75,60.7 v1(117.68,60.77)
  IN3 w0.076: 125.82,99.55 125.82,99.63 125.08,100.36 125.08,107.12 v1(124.4,107.8)
  IN3 w0.152: v1(134.58,62.29) 134.35,62.52 134.35,65.24 134.93,65.82 134.93,72.43 134.91,72.45 134.91,73.57 134.83,73.65 134.83,75.42 133.56,76.69 133.05,76.69 132.57,77.18 132.57,82.59 132.11,83.06 131.73,83.06 130.77,84.01 129.94,84.84 129.94,85.62 129.69,85.88 129.19,85.88 127.95,87.12 127.95,88.73 125.82,90.86 125.82,99.55
  BOTTOM w0.102: v1(72.77,60.87) 72.6,61.03 72.6,61.63 72.78,61.81 72.96,61.81 73.03,61.73 73.03,61.48 73.11,61.41 73.26,61.41 73.34,61.48 73.34,61.65 73.41,61.73 U50.L3 ; v1(117.68,60.77) 117.68,61.65 117.76,61.73 117.99,61.73 118.07,61.65 118.07,61.53 118.17,61.43 118.35,61.43 118.45,61.53 118.45,61.65 118.53,61.73 U53.L3 ; U51.L3 86.91,61.78 86.7,61.78 86.55,61.63 86.55,61.38 86.47,61.3 86.27,61.3 86.19,61.38 86.19,61.6 86.11,61.68 85.89,61.68 85.81,61.6 85.81,61.08 v1(85.98,60.92) ; v1(104.75,60.74) 104.66,60.83 104.66,61.63 104.76,61.73 105.01,61.73 105.09,61.65 105.09,61.45 105.16,61.38 105.34,61.38 105.42,61.45 105.42,61.65 105.5,61.73 U52.L3 ; U45.AW34 124.7,108.1 v1(124.4,107.8)
M_A_ZQ1: length 10.3
  TOP w0.102: 76.11,61.66 75.9,61.66 75.47,62.09 74.92,62.09 U28.L8
  TOP w0.14: R374.2 76.62,56.58 77.17,57.13 77.17,61.15 76.67,61.66 76.11,61.66
M_A_ZQ2: length 5.3
  TOP w0.102: U29.L8 88.17,61.32 89.5,61.32 90.21,62.04 90.84,62.04
  TOP w0.14: R342.2 92.06,62.21 91.88,62.04 90.84,62.04
M_A_ZQ3: length 9.4
  TOP w0.102: R378.2 107.59,54.5 107.93,54.85 107.93,55.33 108.92,56.32 108.92,60.04 107.64,61.32 106.96,61.32 U30.L8
M_A_ZQ4: length 5.3
  TOP w0.102: U31.L8 120.16,62.12 120.68,62.12 120.72,62.09 121.67,62.09 121.97,61.79
  TOP w0.14: R343.2 122.11,61.66 121.97,61.79
M_A_ZQ5: length 11.8
  BOTTOM w0.102: U50.L8 69.76,61.65 69.43,61.32 68.16,61.32 67.65,60.82 67.28,60.82 66.13,59.67 65.4,59.67 64.89,59.17 63.21,59.17 R745.2 62.7,59.87 62.47,60.11 61.94,60.11 61.93,60.1
  BOTTOM w0.14: 61.93,60.1 61.62,60.1 61.12,59.6 61.12,58.81 60.71,58.39 v3(60.7,58.39)
M_A_ZQ6: length 8.9
  BOTTOM w0.102: 80.86,60.56 80.88,60.59 81.13,60.59 81.83,61.29 82.53,61.29 U51.L8
  BOTTOM w0.14: 80.86,60.56 80.67,60.38 R756.2
M_A_ZQ7: length 10.4
  BOTTOM w0.102: U52.L8 101.46,61.73 101.06,62.13 100.42,62.13
  BOTTOM w0.14: 100.42,62.13 99.99,62.13 99.65,62.47 98.99,62.47 98.43,61.91 98.43,57.44 97.75,56.75 R752.2
M_A_ZQ8: length 9.3
  BOTTOM w0.102: 113.62,61.32 114.56,61.32 U53.L8
  BOTTOM w0.14: 113.62,61.32 113.34,61.32 112.71,60.69 112.71,60.28 112.48,60.05 112.48,58.28 112.61,58.15 R757.2
M_B_A0: length 40.6
  IN2 w0.076: 119.08,100.06 119.08,100.36 118.98,100.47 118.98,101.03 119.59,101.63 119.59,102.98 120.05,103.44 120.05,109.64 119.95,109.74 119.95,110.53 v1(120.3,110.88)
  IN2 w0.178: v1(128.33,78.77) 127.9,79.2 127.9,81.47 127.59,81.77 127.59,84.39 127.28,84.71 127.28,85.83 126.6,86.51 126.6,88.75 126.32,89.04 126.32,90.54 119.08,97.77 119.08,100.06
  BOTTOM w0.102: U45.AP40 120.63,111.21 v1(120.3,110.88)
  BOTTOM w0.216: JDIM1.98 127.88,76.63 127.68,76.84 127.68,78.11 v1(128.33,78.77)
M_B_A1: length 42.1
  IN2 w0.076: v1(120.34,110.21) 120.32,110.18 120.32,103.33 119.9,102.9 119.9,100.54 119.49,100.14 119.49,99.83
  IN2 w0.152: 119.49,99.83 119.49,98.05
  IN2 w0.178: v1(128.36,82.28) 128.12,82.52 128.12,84.52 127.74,84.9 127.74,85.89 127.86,86.01 128.15,86.01 128.28,86.14 128.28,86.34 128.15,86.47 127.31,86.47 127.19,86.6 127.19,86.88 127.31,87 127.69,87 127.82,87.13 127.82,87.39 127.69,87.51 127.21,87.51 127.09,87.64 127.09,87.94 127.21,88.07 128.16,88.07 128.29,88.2 128.29,88.45 128.16,88.58 127.19,88.58 127.06,88.71 127.06,89.09 127.19,89.21 127.44,89.21 127.57,89.34 127.57,89.62 127.44,89.75 126.92,89.75 126.77,89.9 126.77,90.9 125.96,91.71 125.96,92.22 125.75,92.43 125.57,92.43 125.43,92.3 125.2,92.3 125.04,92.47 125.04,92.7 125.13,92.79 125.13,93.02 124.97,93.18 124.74,93.18 124.7,93.15 124.38,93.15 124.25,93.28 124.25,93.49 124.34,93.58 124.34,93.81 124.18,93.98 123.95,93.98 123.85,93.88 123.62,93.88 123.46,94.05 123.46,94.28 123.55,94.37 123.55,94.62 123.42,94.75 123.18,94.75 123.06,94.64 122.88,94.63 122.65,94.87 122.65,95.05 122.7,95.1 122.7,95.25 122.36,95.59 121.95,95.59 119.49,98.05
  BOTTOM w0.102: v1(120.34,110.21) 120.69,110.56 U45.AR40
  BOTTOM w0.216: JDIM1.97 127.58,82.73 128.09,82.22 128.29,82.22 v1(128.36,82.28)
M_B_A2: length 45.1
  IN2 w0.076: v1(119.39,110.93) 119.78,110.54 119.78,110.03 119.24,109.48 119.24,104.28 119.41,104.1 119.41,101.79 118.63,101 118.63,99.81
  IN2 w0.178: 118.63,99.81 118.63,97.55 125.86,90.31 125.86,88.85 126.09,88.62 126.09,86.37 126.82,85.64 126.82,84.52 127.09,84.26 127.09,81.52 127.44,81.16 127.44,79 127.82,78.62 127.82,77.04 127.67,76.9 127.46,76.9 127.31,77.04 127.31,78.32 126.92,78.72 v1(126.68,78.72)
  BOTTOM w0.102: U45.AP42 119.66,111.21 v1(119.39,110.93)
  BOTTOM w0.216: JDIM1.96 127.28,78.12 v1(126.68,78.72)
M_B_A3: length 43.9
  IN2 w0.076: 118.2,100.6 118.35,100.75 118.35,100.97 119.24,101.86 119.24,103.97 118.91,104.3 118.91,109.8 v1(119.39,110.28)
  IN2 w0.178: 118.2,100.6 117.74,100.14 117.74,99.58 117.89,99.42 118.04,99.42 118.2,99.27 118.2,99.05 118.04,98.89 117.89,98.89 117.74,98.74 117.74,98.15 118.02,97.88 118.02,97.51 118.22,97.31 118.22,97.14 118.04,96.96 118.04,96.76 118.41,96.38 118.65,96.38 118.76,96.5 118.99,96.5 119.15,96.33 119.15,96.1 119.04,95.99 119.04,95.76 119.18,95.62 119.46,95.62 119.7,95.38 119.7,94.96 119.99,94.67 119.99,94.38 120.1,94.27 120.2,94.27 120.66,94.73 120.8,94.73 121.04,94.49 121.04,94.34 120.82,94.13 120.82,93.85 121.04,93.63 121.22,93.63 121.45,93.86 121.62,93.86 121.88,93.61 121.88,93.43 121.65,93.2 121.65,93.01 121.81,92.85 122.64,92.85 122.81,92.68 122.81,92.48 122.61,92.29 122.61,92.05 123.08,91.58 123.32,91.58 123.44,91.69 123.62,91.69 123.86,91.45 123.86,91.27 123.4,90.82 123.4,90.64 123.59,90.45 123.77,90.45 124.22,90.89 124.39,90.89 124.6,90.69 124.6,90.51 124.52,90.43 124.51,90.43 123.78,89.7 123.78,89.52 124.01,89.29 124.19,89.29 125.01,90.1 125.19,90.1 125.4,89.88 125.4,89.7 125,89.3 125,89.06 125.64,88.43 125.64,85.02 126.55,84.11 v1(126.55,82.28)
  BOTTOM w0.102: U45.AR42 119.66,110.56 v1(119.39,110.28)
  BOTTOM w0.216: JDIM1.95 126.98,82.71 v1(126.55,82.28)
